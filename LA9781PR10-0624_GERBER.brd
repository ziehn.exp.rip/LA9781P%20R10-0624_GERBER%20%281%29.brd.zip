# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPC_DOCK_LANE_C_N1: length 1.3
  BOTTOM w0.102: R2175.2 85.36,132.3 85.36,132.62 C440.1
DPC_DOCK_LANE_C_N2: length 1.3
  BOTTOM w0.102: R2177.2 87.27,132.3 87.27,132.62 C442.1
DPC_DOCK_LANE_C_N3: length 1.3
  BOTTOM w0.102: C444.1 89.17,132.62 89.17,132.3 R2179.2
DPC_DOCK_LANE_C_P0: length 1.3
  BOTTOM w0.102: C431.1 83.24,132.62 83.24,132.3 R2172.2
DPC_DOCK_LANE_C_P1: length 1.3
  BOTTOM w0.102: C439.1 85.15,132.62 85.15,132.3 R2174.2
DPC_DOCK_LANE_C_P2: length 1.3
  BOTTOM w0.102: R2176.2 87.05,132.3 87.05,132.62 C441.1
DPC_DOCK_LANE_C_P3: length 1.3
  BOTTOM w0.102: R2178.2 88.96,132.3 88.96,132.62 C443.1
DPC_DOCK_LANE_N0_R: length 4.8
  BOTTOM w0.102: JDOCK1.12 84.24,127.6 84.1,127.74 84.1,129.19 83.49,129.8 83.49,130.31 83.48,130.33 83.48,130.73 R2173.1
DPC_DOCK_LANE_N1_R: length 4.7
  BOTTOM w0.102: R2175.1 85.36,130.71 85.36,130.36 85.37,130.35 85.37,129.82 85.36,129.81 85.36,129.72 85.6,129.48 85.6,127.76 85.74,127.62 JDOCK1.18
DPC_DOCK_LANE_N2_R: length 4.6
  BOTTOM w0.102: JDOCK1.24 87.24,127.62 87.1,127.77 87.1,128.81 87.26,128.97 87.26,129.66 87.27,129.67 87.27,130.2 87.26,130.21 87.26,130.71 R2177.1
DPC_DOCK_LANE_N3_R: length 4.8
  BOTTOM w0.102: R2179.1 89.15,130.7 89.15,130.24 89.17,130.23 89.17,129.69 89.15,129.68 89.15,129.46 88.6,128.91 88.6,127.74 88.74,127.6 JDOCK1.30
DPC_DOCK_LANE_P0_R: length 4.8
  BOTTOM w0.102: R2172.1 83.26,130.7 v3(83.26,130.05) 83.26,129.72 83.88,129.1 83.88,127.74 83.74,127.6 JDOCK1.10
DPC_DOCK_LANE_P1_R: length 4.6
  BOTTOM w0.102: JDOCK1.16 85.24,127.62 85.38,127.76 85.38,129.39 85.14,129.63 v3(85.14,130.09) 85.14,130.72 R2174.1
DPC_DOCK_LANE_P2_R: length 4.6
  BOTTOM w0.102: JDOCK1.22 86.74,127.62 86.88,127.77 86.88,128.9 87.04,129.06 v3(87.04,129.93) 87.04,130.72 R2176.1
DPC_DOCK_LANE_P3_R: length 4.8
  BOTTOM w0.102: JDOCK1.28 88.24,127.6 88.38,127.74 88.38,129 88.94,129.55 v3(88.94,129.96) 88.94,130.73 R2178.1
DPC_DOCK_SW_AUX: length 51.9
  TOP w0.102: U20.3 56.22,106.09 57.1,106.97 57.1,107.48 57.76,108.14 57.76,108.8 v2(57.55,109) 57.76,109.21 57.76,109.44 56.87,110.33 U20.11
  IN1 w0.117: v2(89.69,125.31) 89.86,125.14 89.86,122.47 86.34,118.94 83.75,118.94 82.36,117.56 82.36,117.05 81.18,115.87 77.22,115.87 74.89,113.55 74.39,113.55 72.91,112.07 72.91,111.59 v2(72.57,111.24) 72.86,110.94 72.86,110.7 72.09,109.93 58.1,109.93 57.75,109.58 57.75,109.2 v2(57.55,109)
  BOTTOM w0.102: v2(72.57,111.24) 72.44,111.24 72.35,111.33 Q113.1 ; v2(89.69,125.31) 89.88,125.5 89.88,125.74 89.74,125.88 JDOCK1.34
DPC_DOCK_SW_AUX#: length 51.9
  TOP w0.102: U20.8 58.82,110.28 57.97,109.44 57.97,109.2 v2(58.16,109) 57.97,108.81 57.97,108.05 57.31,107.39 57.31,106.99 58.17,106.13 U20.6
  IN1 w0.117: v2(90.27,125.31) 90.1,125.14 90.1,122.37 86.43,118.71 83.84,118.71 82.6,117.46 82.6,116.95 81.28,115.63 77.32,115.63 74.99,113.31 74.48,113.31 73.15,111.98 73.15,111.54 v2(73.46,111.24) 73.1,110.88 73.1,110.6 72.19,109.69 58.19,109.69 57.99,109.48 57.99,109.18 v2(58.16,109)
  BOTTOM w0.102: v2(90.27,125.31) 90.09,125.49 90.09,125.74 90.24,125.89 JDOCK1.36 ; v2(73.46,111.24) 73.65,111.05 Q113.4
DPD_CA_DET: length 110.6
  TOP w0.102: R491.2 23.42,150.58 v2(23.9,151.07) ; R491.2 23.9,150.18 24.71,150.99 24.71,151.35 25.01,151.64 U9.42 ; R491.2 C1332.1 ; Q336.2 17.88,148.96 v2(18.44,148.4)
  IN1 w0.109: v2(23.9,151.07) 23.9,150.81 22.53,149.44 19.48,149.44 v2(18.44,148.4)
  IN3 w0.127: v2(82.07,108.75) 81.81,109.01 76.48,109.01 75.84,108.37 50.69,108.37 43.82,115.24 43.82,119.08 43.36,119.55 42.42,119.55 42.14,119.83 42.14,127.88 38.3,131.71 36.55,131.71 20.8,147.46 19.38,147.46 v2(18.44,148.4)
  BOTTOM w0.102: v2(82.07,108.75) 81.94,108.75 81.68,109 v1(81.68,109.45) 81.68,111 82.14,111.46 82.14,116.24 82.74,116.84 JDOCK1.5
DPD_CPU_LANE_N0: length 178.1
  TOP w0.102: v2(175.14,133.31) 174.67,132.84 JCPU1.P29
  IN1 w0.089: 176.82,140.35 176.82,140.34 176.84,140.32 176.84,140.09 177.48,139.45 177.48,135.15 176.25,133.92 175.83,133.92 175.5,133.59 175.5,133.4 175.41,133.31 v2(175.14,133.31)
  IN1 w0.117: 176.82,140.35 176.82,141.36 169.62,148.56 162.09,148.56 155.6,155.05 139.84,155.05 135.7,150.91 119.3,150.91 118.44,150.05 108.13,150.05 107.69,149.62 80.39,149.62 79.07,148.29 71.11,148.29 70.43,147.61 68.07,147.61 66.88,146.42 66.27,146.42 65.58,145.73 56.41,145.73 55.65,144.97 50.14,144.97 45.29,140.12 45.29,120.39 45,120.09 45,119.94 44.72,119.67 44.57,119.67 44.33,119.42 44.33,119.27 44.05,119 43.9,119 43.66,118.75 43.1,118.75 43.02,118.67 42.94,118.67 42.85,118.58 v2(42.85,118.4)
  BOTTOM w0.102: v2(42.85,118.4) 42.61,118.64 42.42,118.64 C515.1
DPD_CPU_LANE_N0_C: length 3.3
  BOTTOM w0.102: C515.2 40.84,118.63 40.51,118.63 40.12,119.02 40.11,119.02 39.73,119.39 39.73,119.41 39.57,119.57 39.01,119.57 38.92,119.48 U629.12
DPD_CPU_LANE_N1: length 179
  TOP w0.102: JCPU1.N28 173.67,131.84 v2(174.14,132.31)
  IN1 w0.089: v2(174.14,132.31) 174.5,132.68 174.5,133 174.55,133.05 174.55,133.58 174.89,133.92 175.26,133.92 175.5,134.16 175.5,135.95 176.03,136.49 176.03,140.13 176.01,140.16 176.01,140.17
  IN1 w0.117: v2(42.85,116.5) 42.85,116.68 42.94,116.77 43.02,116.77 43.1,116.85 43.76,116.85 44.03,117.12 44.18,117.12 44.45,117.39 44.45,117.54 44.7,117.79 44.85,117.79 45.12,118.06 45.12,118.21 46.16,119.24 46.16,139.51 48.69,142.04 50.5,142.04 51.31,142.85 51.31,143.4 52.04,144.13 55.95,144.13 56.82,145 65.91,145 66.6,145.68 67.23,145.68 68.43,146.88 70.79,146.88 71.46,147.55 79.87,147.55 80.79,148.47 85.54,148.47 85.92,148.85 88.42,148.85 89.2,148.07 98.61,148.07 99.4,148.86 111.04,148.86 111.46,149.28 118.71,149.28 119.61,150.18 136.01,150.18 140.15,154.32 155.24,154.32 162.18,147.38 169.76,147.38 176.01,141.13 176.01,140.17
  BOTTOM w0.102: v2(42.85,116.5) 42.61,116.73 42.42,116.73 C517.1
DPD_CPU_LANE_N1_C: length 3.9
  BOTTOM w0.102: C517.2 41.17,116.45 40.88,116.74 40.73,116.74 40.44,117.03 40.44,117.44 40.23,117.64 40.21,117.64 39.79,118.07 39.79,118.08 39.5,118.37 39.15,118.37 39.06,118.28 U629.15
DPD_CPU_LANE_N2: length 173.7
  TOP w0.102: JCPU1.P31 174.59,134.87 v2(174.14,135.32)
  IN1 w0.089: 174.98,140.09 174.98,140.08 175,140.06 175,139.28 174.47,138.75 174.47,137.63 174.56,137.54 174.56,135.74 v2(174.14,135.32)
  IN1 w0.117: v2(42.85,114.59) 42.85,114.77 42.94,114.86 43.02,114.86 43.1,114.94 43.76,114.94 44.03,115.21 44.18,115.21 44.45,115.49 44.45,115.64 44.7,115.88 44.85,115.88 45.12,116.16 45.12,116.31 47,118.18 47,138.76 48.89,140.65 49.05,140.65 49.7,141.31 50.82,141.31 51.47,141.96 54.16,141.96 54.91,142.71 55.6,142.71 57.12,144.23 66.24,144.23 66.95,144.95 67.61,144.95 68.78,146.11 71.09,146.11 71.78,146.8 84.94,146.8 86.21,148.07 88.11,148.07 88.86,147.33 99,147.33 99.79,148.11 111.36,148.11 111.77,148.52 120.37,148.52 121.29,149.44 136.33,149.44 139.81,152.92 155.39,152.92 161.7,146.61 169.46,146.61 174.98,141.09 174.98,140.09
  BOTTOM w0.102: C519.1 42.42,114.83 42.61,114.83 v2(42.85,114.59)
DPD_CPU_LANE_N2_C: length 4.9
  BOTTOM w0.102: U629.17 38.91,117.48 39.01,117.58 39.28,117.58 39.71,117.14 39.71,116.74 v3(39.91,116.54) 40.08,116.37 40.08,115.41 40.66,114.83 40.84,114.83 C519.2
DPD_CPU_LANE_N3: length 174.3
  TOP w0.102: v2(173.02,134.3) 173.49,133.84 JCPU1.N30
  IN1 w0.089: 173.45,140.29 173.45,140.27 173.47,140.25 173.47,139.17 173.48,139.16 173.48,134.51 173.27,134.3 v2(173.02,134.3)
  IN1 w0.117: v2(42.85,112.69) 42.85,112.87 42.94,112.96 43.02,112.96 43.1,113.04 43.76,113.04 44.03,113.31 44.18,113.31 44.45,113.58 44.45,113.73 44.7,113.98 44.85,113.98 45.12,114.25 45.12,114.4 47.88,117.15 47.88,138.57 49.22,139.91 53.52,139.91 55.56,141.95 57.86,141.95 58.57,142.66 65.87,142.66 66.85,143.64 66.85,143.8 67.26,144.21 67.92,144.21 68.99,145.28 71.4,145.28 72.19,146.06 85.24,146.06 86.51,147.33 87.58,147.33 89,145.91 94.13,145.91 94.81,146.59 99.33,146.59 100.12,147.38 111.74,147.38 112.14,147.77 120.96,147.77 121.36,148.17 130.2,148.17 130.61,148.58 136.54,148.58 139.5,151.54 144.4,151.54 144.75,151.19 156.05,151.19 161.45,145.79 169.23,145.79 173.45,141.57 173.45,140.29
  BOTTOM w0.102: C522.1 42.42,112.92 42.61,112.92 v2(42.85,112.69)
DPD_CPU_LANE_N3_C: length 5.6
  BOTTOM w0.102: U629.20 38.93,116.28 39.01,116.36 39.1,116.36 39.28,116.18 39.28,114.99 39.36,114.9 39.36,114.89 39.74,114.5 39.76,114.5 40.19,114.07 v3(40.19,113.6) 40.19,113.26 40.52,112.93 40.83,112.93 C522.2
DPD_CPU_LANE_P0: length 178.1
  TOP w0.102: JCPU1.R29 175.74,132.84 176.06,133.16 v2(176.06,133.31)
  IN1 w0.089: 177.06,140.35 177.06,140.34 177.03,140.32 177.03,140.17 177.67,139.53 177.67,135.07 176.33,133.73 175.91,133.73 175.69,133.51 175.69,133.4 175.78,133.31 v2(176.06,133.31)
  IN1 w0.117: 177.06,140.35 177.06,141.46 169.72,148.8 162.19,148.8 155.7,155.29 139.74,155.29 135.6,151.15 119.2,151.15 118.34,150.29 108.03,150.29 107.6,149.86 80.3,149.86 78.97,148.53 71.01,148.53 70.33,147.85 67.97,147.85 66.78,146.66 66.17,146.66 65.48,145.97 56.31,145.97 55.55,145.21 50.04,145.21 45.06,140.22 45.06,120.49 43.56,118.99 42.95,118.99 v2(42.85,119.09)
  BOTTOM w0.102: v2(42.85,119.09) 42.61,118.85 42.42,118.85 C516.1
DPD_CPU_LANE_P0_C: length 3.3
  BOTTOM w0.102: C516.2 40.83,118.85 40.6,118.85 v3(40.08,119.37) 39.66,119.79 39.01,119.79 38.92,119.88 U629.11
DPD_CPU_LANE_P1: length 179
  TOP w0.102: v2(175.06,132.31) 175.06,132.13 174.77,131.84 JCPU1.P28
  IN1 w0.089: 176.25,140.17 176.25,140.15 176.22,140.12 176.22,136.41 175.69,135.88 175.69,134.08 175.34,133.73 174.97,133.73 174.74,133.5 174.74,132.97 174.69,132.92 174.69,132.68 v2(175.06,132.31)
  IN1 w0.117: v2(42.85,117.18) 42.95,117.08 43.66,117.08 45.92,119.34 45.92,139.61 48.59,142.28 50.4,142.28 51.07,142.95 51.07,143.5 51.95,144.37 55.86,144.37 56.72,145.23 65.81,145.23 66.5,145.92 67.13,145.92 68.33,147.11 70.69,147.11 71.36,147.78 79.77,147.78 80.69,148.7 85.44,148.7 85.82,149.09 88.52,149.09 89.3,148.31 98.51,148.31 99.3,149.1 110.95,149.1 111.36,149.52 118.61,149.52 119.51,150.41 135.91,150.41 140.05,154.55 155.34,154.55 162.28,147.62 169.86,147.62 176.25,141.23 176.25,140.17
  BOTTOM w0.102: C518.1 42.42,116.95 42.61,116.95 v2(42.85,117.18)
DPD_CPU_LANE_P1_C: length 3.9
  BOTTOM w0.102: U629.14 39.06,118.68 39.15,118.59 39.59,118.59 v3(40.15,118.03) 40.65,117.53 40.65,117.12 40.82,116.95 40.92,116.95 41.17,117.21 C518.2
DPD_CPU_LANE_P2: length 173.7
  TOP w0.102: v2(175.12,135.3) 175.59,134.84 JCPU1.R31
  IN1 w0.089: v2(175.12,135.3) 175.12,135.32 174.75,135.69 174.75,137.62 174.66,137.71 174.66,138.67 175.2,139.2 175.2,140.06 175.22,140.08 175.22,140.09
  IN1 w0.117: 175.22,140.09 175.22,141.18 169.55,146.85 161.8,146.85 155.49,153.16 139.71,153.16 136.24,149.68 121.19,149.68 120.27,148.76 111.67,148.76 111.26,148.35 99.69,148.35 98.9,147.56 88.95,147.56 88.21,148.31 86.11,148.31 84.84,147.04 71.68,147.04 71,146.35 68.68,146.35 67.52,145.18 66.86,145.18 66.14,144.47 57.03,144.47 55.5,142.95 54.81,142.95 54.06,142.2 51.38,142.2 50.72,141.54 49.6,141.54 48.95,140.89 48.8,140.89 46.76,138.85 46.76,118.28 43.66,115.18 42.95,115.18 v2(42.85,115.28)
  BOTTOM w0.102: C520.1 42.42,115.04 42.61,115.04 v2(42.85,115.28)
DPD_CPU_LANE_P2_C: length 4.9
  BOTTOM w0.102: U629.16 38.91,117.88 39,117.79 39.37,117.79 39.93,117.23 39.93,116.85 40.3,116.48 40.3,115.5 40.75,115.04 40.84,115.04 C520.2
DPD_CPU_LANE_P3: length 174.3
  TOP w0.102: JCPU1.P30 174.45,133.84 174.13,134.16 v2(174.13,134.34)
  IN1 w0.089: v2(174.13,134.34) 173.85,134.34 173.67,134.51 173.67,139.24 173.66,139.25 173.66,140.25 173.69,140.27 173.69,140.29
  IN1 w0.117: v2(42.85,113.37) 42.95,113.27 43.66,113.27 47.64,117.25 47.64,138.67 49.12,140.15 53.42,140.15 55.46,142.18 57.76,142.18 58.47,142.9 65.78,142.9 66.62,143.74 66.62,143.9 67.16,144.45 67.82,144.45 68.89,145.51 71.3,145.51 72.09,146.3 85.14,146.3 86.41,147.57 87.68,147.57 89.1,146.15 94.03,146.15 94.71,146.83 99.24,146.83 100.02,147.61 111.64,147.61 112.04,148.01 120.86,148.01 121.26,148.41 130.1,148.41 130.51,148.81 136.44,148.81 139.4,151.78 144.5,151.78 144.85,151.43 156.15,151.43 161.55,146.03 169.33,146.03 173.69,141.67 173.69,140.29
  BOTTOM w0.102: v2(42.85,113.37) 42.61,113.14 42.42,113.14 C521.1
DPD_CPU_LANE_P3_C: length 5.5
  BOTTOM w0.102: U629.19 38.91,116.68 39.01,116.57 39.19,116.57 39.5,116.27 39.5,115.08 v3(39.72,114.85) 40.41,114.16 40.41,113.88 40.42,113.87 40.42,113.34 40.61,113.14 40.84,113.14 C521.2
DPD_DOCK_AUX: length 126.2
  TOP w0.102: v2(31.22,147.1) 31,147.32 31,147.41 31.15,147.57 31.15,149.16 30.9,149.41 30.9,150.13 31,150.23 U9.55 ; Q337.1 18.25,145.74 v2(18.41,145.91)
  IN3 w0.127: v2(89.54,116.83) 89.72,116.64 90.01,116.64 90.34,116.32 90.34,114.79 90.06,114.51 90.06,110.27 86.82,107.03 50.72,107.03 45.95,111.8 42.75,111.8 41.61,112.95 41.61,117.51 40.35,118.77 40.35,122.84 40.19,123 40.19,127.55 38.74,129 38.74,129.53 37.41,130.85 36.3,130.85 22.05,145.1 19.28,145.1 18.47,145.91 v2(18.41,145.91)
  IN4 w0.117: v2(18.41,145.91) 18.64,145.91 19.41,145.14 29.7,145.14 31.03,146.47 31.03,146.92 31.22,147.1 v2(31.22,147.1)
  BOTTOM w0.102: JDOCK1.33 89.74,117.8 89.97,117.58 89.97,116.68 89.84,116.55 89.56,116.55 89.46,116.65 89.46,116.74 v2(89.54,116.83)
DPD_DOCK_AUX#: length 126.1
  TOP w0.102: U9.54 30.6,150.26 30.68,150.18 30.68,149.32 30.94,149.07 30.94,147.66 30.78,147.5 30.78,147.28 v2(30.61,147.1) ; Q337.4 v2(19.55,146.25)
  IN3 w0.127: v2(19.55,146.25) 19.37,146.42 19.07,146.42 18.91,146.27 18.91,145.82 19.38,145.35 22.15,145.35 36.4,131.1 37.51,131.1 38.99,129.63 38.99,129.1 40.44,127.65 40.44,123.11 40.6,122.95 40.6,118.88 41.86,117.62 41.86,113.05 42.86,112.05 46.05,112.05 50.82,107.28 86.71,107.28 89.81,110.38 89.81,114.61 90.09,114.89 90.09,116.21 89.91,116.4 89.59,116.4 89.48,116.29 89.48,116.2 v2(89.53,116.14)
  IN4 w0.117: v2(30.61,147.1) 30.8,146.91 30.8,146.57 29.61,145.38 19.51,145.38 18.93,145.95 18.93,146.19 19.07,146.33 19.47,146.33 v2(19.55,146.25)
  BOTTOM w0.102: v2(89.53,116.14) 89.71,116.32 89.93,116.32 90.19,116.58 90.19,117.74 90.24,117.79 JDOCK1.35
DPD_DOCK_AUX_Q: length 11
  TOP w0.102: v1(18.46,144.21) 18.9,144.64 Q337.2 Q337.5 18.9,148.86 Q336.3 18.53,149.43 18.9,149.8 19.85,149.8 Q335.2 20.55,149.36 20.55,150.31 20.42,150.43 Q335.5 R2153.2
DPD_DOCK_LANE_N0: length 1.5
  BOTTOM w0.102: C367.1 83.33,112.49 83.33,113.06 R2165.1
DPD_DOCK_LANE_N0_R: length 4.9
  BOTTOM w0.102: R2165.2 83.32,114.66 83.32,115.17 83.34,115.18 83.34,115.71 83.32,115.72 83.32,116.1 83.44,116.22 84.1,116.88 84.1,117.51 84.24,117.65 JDOCK1.11
DPD_DOCK_LANE_N1: length 1.5
  BOTTOM w0.102: R2167.1 85.23,113.06 85.23,112.49 C369.1
DPD_DOCK_LANE_N1_R: length 4.7
  BOTTOM w0.102: R2167.2 85.25,114.63 85.25,115.18 85.27,115.19 85.27,115.72 85.25,115.73 85.25,115.85 85.6,116.19 85.6,117.51 85.74,117.65 JDOCK1.17
DPD_DOCK_LANE_N2: length 1.5
  BOTTOM w0.102: R2169.1 87.14,113.06 87.14,112.49 C425.1
DPD_DOCK_LANE_N2_R: length 4.6
  BOTTOM w0.102: R2169.2 87.15,114.64 87.15,115.19 87.16,115.2 87.16,115.73 87.15,115.75 87.15,116.54 87.1,116.58 87.1,117.51 87.24,117.65 JDOCK1.23
DPD_DOCK_LANE_N3: length 1.5
  BOTTOM w0.102: C427.1 89.04,112.49 89.04,113.06 R2171.1
DPD_DOCK_LANE_N3_R: length 4.8
  BOTTOM w0.102: R2171.2 89.04,114.66 89.04,114.87 88.61,115.3 88.61,115.82 88.6,115.84 88.6,117.51 88.74,117.65 JDOCK1.29
DPD_DOCK_LANE_P0: length 1.5
  BOTTOM w0.102: C366.1 83.11,112.49 83.11,113.06 R2164.1
DPD_DOCK_LANE_P0_R: length 4.9
  BOTTOM w0.102: JDOCK1.9 83.74,117.65 83.88,117.51 83.88,116.97 83.11,116.19 v3(83.11,115.44) 83.11,114.64 R2164.2
DPD_DOCK_LANE_P1: length 1.5
  BOTTOM w0.102: C368.1 85.02,112.49 85.02,113.06 R2166.1
DPD_DOCK_LANE_P1_R: length 4.7
  BOTTOM w0.102: JDOCK1.15 85.24,117.65 85.38,117.51 85.38,116.28 85.04,115.94 v3(85.04,115.46) 85.04,114.67 R2166.2
DPD_DOCK_LANE_P2: length 1.5
  BOTTOM w0.102: C424.1 86.92,112.49 86.92,113.06 R2168.1
DPD_DOCK_LANE_P2_R: length 4.6
  BOTTOM w0.102: JDOCK1.21 86.74,117.65 86.88,117.51 86.88,116.49 86.93,116.45 v3(86.93,115.47) 86.93,114.66 R2168.2
DPD_DOCK_LANE_P3: length 1.5
  BOTTOM w0.102: R2170.1 88.83,113.06 88.83,112.49 C426.1
DPD_DOCK_LANE_P3_R: length 4.8
  BOTTOM w0.102: R2170.2 88.82,114.64 88.82,114.78 88.38,115.22 v3(88.38,115.56) 88.38,117.51 88.24,117.65 JDOCK1.27
DPD_GPU_HPD: length 104.4
  TOP w0.102: v2(26.21,155.92) 26.21,155.9 25.96,155.64 U9.32
  IN3 w0.127: v2(26.21,155.92) 27.33,154.8 27.41,154.8 29.72,152.49 29.72,151.96 30.3,151.37 33.5,151.37 35,149.87 35,144.92 43.02,136.9 43.02,135.78 47.8,131 47.8,116.8 50.34,114.26 67.69,114.26 69.16,115.74 83.87,115.74 85.93,117.79 85.93,117.97 88.1,120.14 89.9,120.14 v2(89.94,120.1)
  BOTTOM w0.102: v2(89.94,120.1) 89.94,120.05 89.96,120.03 90.73,120.03 91.24,119.52 JDOCK1.39 v1(91.24,115.6) 91.24,114.36 C695.1 R757.1
DPD_GPU_LANE_N0: length 94.7
  TOP w0.102: v2(23.87,152.92) 24.05,152.74 24.72,152.74 24.82,152.84 U9.39
  IN3 w0.127: v2(23.87,152.92) 23.69,152.74 23.39,152.74 23.09,152.44 23.09,149.95 23.56,149.48 23.56,145.82 26.52,142.86 30.79,142.86 38.07,135.58 38.07,132.78 42.78,128.08 42.78,127.06 43.46,126.38 43.86,126.38 44.33,125.92 44.33,115.45 50.26,109.52 75.26,109.52 75.46,109.72 81.84,109.72 82.17,109.39 82.52,109.39 v2(82.7,109.21)
  BOTTOM w0.102: v2(82.7,109.21) 82.7,109.26 82.92,109.47 83.11,109.47 83.41,109.78 83.41,110.99 C367.2
DPD_GPU_LANE_N1: length 96.7
  TOP w0.102: v2(23.47,154.14) 23.67,153.94 24.83,153.94 24.93,154.04 U9.36
  IN3 w0.127: v2(23.47,154.14) 23.63,153.98 24.69,153.98 25.18,153.49 25.18,152.05 24.79,151.65 24.79,150.89 24.66,150.76 24.66,146.65 27.23,144.08 31.39,144.08 39.16,136.31 39.16,133.17 45.52,126.81 45.52,115.86 50.68,110.7 74.04,110.7 74.67,111.34 85.04,111.34 85.32,111.06 85.32,110.66 v2(85.42,110.55)
  BOTTOM w0.102: C369.2 85.23,110.9 85.23,110.74 v2(85.42,110.55)
DPD_GPU_LANE_N2: length 98.3
  TOP w0.102: v2(23.85,155.33) 24.09,155.09 24.19,155.09 24.25,155.16 24.71,155.16 24.79,155.24 U9.33
  IN3 w0.127: v2(23.85,155.33) 23.98,155.2 24.69,155.2 26.01,153.88 26.01,149.92 25.85,149.76 25.85,146.88 27.66,145.07 31.98,145.07 41.73,135.32 41.73,131.69 46.28,127.14 46.28,116.22 50.98,111.52 62.2,111.52 62.88,112.2 86.28,112.2 87.25,111.24 87.25,110.63 v2(87.32,110.55)
  BOTTOM w0.102: C425.2 87.14,110.9 87.14,110.74 v2(87.32,110.55)
DPD_GPU_LANE_N3: length 99.7
  TOP w0.102: v2(23.01,156.15) 23.29,155.87 23.39,155.87 23.87,156.35 v3(24.12,156.35) 24.64,156.35 24.73,156.44 U9.30
  IN3 w0.127: v2(23.01,156.15) 23.22,155.94 23.39,155.94 23.8,156.35 24.87,156.35 26.8,154.42 26.8,153.91 28.19,152.51 28.19,151.8 33.45,146.55 33.45,145.68 42.51,136.62 42.51,132.05 47.16,127.4 47.16,116.5 49.98,113.68 86.79,113.68 89.15,111.31 89.15,110.63 v2(89.23,110.55)
  BOTTOM w0.102: v2(89.23,110.55) 89.04,110.74 89.04,110.9 C427.2
DPD_GPU_LANE_P0: length 94.7
  TOP w0.102: U9.40 24.82,152.44 24.73,152.53 24.06,152.53 v2(23.87,152.34)
  IN3 w0.127: v2(23.87,152.34) 23.72,152.49 23.49,152.49 23.34,152.34 23.34,150.05 23.81,149.59 23.81,145.92 26.62,143.11 30.89,143.11 38.32,135.68 38.32,132.89 43.03,128.18 43.03,127.16 43.56,126.63 43.97,126.63 44.58,126.02 44.58,115.56 50.37,109.77 75.16,109.77 75.36,109.97 79.96,109.97 80.06,110.07 80.49,110.07 80.59,109.97 80.97,109.97 81.07,110.07 81.51,110.07 81.61,109.97 81.94,109.97 82.27,109.64 82.8,109.64 82.93,109.77 82.93,109.97 82.83,110.07 v2(82.7,110.07)
  BOTTOM w0.102: v2(82.7,110.07) 82.7,109.82 82.83,109.69 83.02,109.69 83.2,109.87 83.2,111.02 82.98,111.24 C366.2
DPD_GPU_LANE_P1: length 96.6
  TOP w0.102: U9.37 24.84,153.64 24.77,153.72 23.74,153.72 v2(23.47,153.45)
  IN3 w0.127: v2(84.81,110.55) 85.07,110.81 85.07,110.96 84.94,111.09 81.54,111.09 81.44,110.99 81.01,110.99 80.91,111.09 80.53,111.09 80.42,110.99 79.99,110.99 79.89,111.09 74.78,111.09 74.14,110.45 50.57,110.45 45.27,115.76 45.27,126.71 38.91,133.06 38.91,136.21 31.29,143.83 27.12,143.83 24.41,146.54 24.41,150.87 24.54,150.99 24.54,151.76 24.93,152.15 24.93,153.39 24.59,153.73 23.6,153.73 23.47,153.61 v2(23.47,153.45)
  BOTTOM w0.102: v2(84.81,110.55) 85.02,110.76 85.02,110.9 C368.2
DPD_GPU_LANE_P2: length 98.3
  TOP w0.102: U9.34 24.79,154.84 24.7,154.94 24.34,154.94 24.28,154.88 24.08,154.88 v2(23.85,154.65)
  IN3 w0.127: v2(86.71,110.55) 86.72,110.55 87,110.83 87,111.13 86.18,111.95 85.62,111.95 85.52,111.85 85.09,111.85 84.99,111.95 84.61,111.95 84.5,111.85 84.07,111.85 83.97,111.95 62.99,111.95 62.31,111.27 50.87,111.27 46.03,116.12 46.03,127.04 41.48,131.58 41.48,135.22 31.87,144.82 27.56,144.82 25.6,146.78 25.6,149.86 25.76,150.03 25.76,153.78 24.59,154.95 24.03,154.95 23.85,154.78 v2(23.85,154.65)
  BOTTOM w0.102: v2(86.71,110.55) 86.92,110.76 86.92,110.9 C424.2
DPD_GPU_LANE_P3: length 99.7
  TOP w0.102: U9.31 24.73,156.04 24.64,156.13 24.39,156.13 24.38,156.12 23.95,156.12 23.49,155.66 23.32,155.66 v2(23.01,155.36)
  IN3 w0.127: v2(88.62,110.55) 88.62,110.55 88.9,110.84 88.9,111.21 88.5,111.61 88.4,111.61 88.4,111.61 88.35,111.61 88.03,111.93 88.03,111.98 88.03,112.09 87.76,112.35 87.66,112.35 87.66,112.35 87.61,112.35 87.29,112.67 87.29,112.73 87.29,112.83 86.68,113.43 49.88,113.43 46.91,116.4 46.91,127.3 42.26,131.94 42.26,136.51 33.2,145.58 33.2,146.44 27.94,151.7 27.94,152.41 26.55,153.81 26.55,154.32 24.76,156.1 23.9,156.1 23.49,155.69 23.19,155.69 23.01,155.51 v2(23.01,155.36)
  BOTTOM w0.102: v2(88.62,110.55) 88.83,110.76 88.83,110.9 C426.2
DPD_PCH_HPD: length 86.3
  TOP w0.102: v2(39.27,119.09) v1(39.91,119.09)
  IN1 w0.109: v2(57,93.94) 57,93.23 60.76,89.47 64.06,89.47 68.05,85.48 71.08,85.48 71.32,85.73 72.78,85.73 73.96,84.54 75.51,84.54 78.35,81.71 79.49,81.71 80.21,80.99 80.21,76.57 80.44,76.34 80.44,71.44 79.6,70.6 79.6,66.92 81.1,65.42 81.1,64.05 81.56,63.59 82.07,63.59 82.4,63.26 82.4,63.01 82.83,62.57 83.29,62.57 83.62,62.24 v2(83.62,62.12)
  IN3 w0.127: v2(57,93.94) 57,94.5 54.51,96.99 53.47,96.99 48.33,102.12 48.33,105.72 42.82,111.24 42.38,111.24 40.94,112.69 40.94,117.39 39.27,119.06 v2(39.27,119.09)
  BOTTOM w0.102: UH1.H39 83.91,61.82 v2(83.62,62.12) ; U629.13 39.22,119.08 39.22,119.09 v2(39.27,119.09)
DSCHRG_MOSFET_GC: length 4.7
  BOTTOM w0.102: v1(268.62,32.98) 268.39,32.75 266.93,32.75 PR1004.2
  BOTTOM w0.254: PU1001.29 265.52,32.68 265.9,32.3 PR1004.2
DSWODVREN: length 12.1
  BOTTOM w0.076: 70.2,57.44 70.2,57.93 70.66,58.38 70.66,58.56 70.94,58.84 70.94,59.26 UH1.C8
  BOTTOM w0.102: RH67.1 69.8,51.32 69.37,51.32 68.12,52.57 68.12,53.98 v1(69.23,55.08) RH81.2 70.6,55.35 70.6,55.53 69.95,56.17 69.95,56.71 70.2,56.97 70.2,57.44
DYN_TUR_CURRNT_SET#: length 73.1
  TOP w0.102: v2(257.05,47.13) 257.35,46.83 257.35,45.4 259.05,43.7 259.05,25.9 258.6,25.44 258.6,21.08 256.92,19.4 256.92,19.13 256.1,18.31 256.1,15.65 254.6,14.15 243.81,14.15 241.64,16.32 237.55,16.32 236.71,15.48 233.48,15.48 v2(233.34,15.62)
  BOTTOM w0.102: U51.A35 249.54,48.92 249.81,49.19 249.81,50.11 250.37,50.67 250.37,51.4 R1980.2 250.85,51.73 251.2,51.37 252.68,51.37 252.86,51.19 252.86,50.3 253.85,49.31 253.85,47.86 254.19,47.51 255.09,47.51 255.47,47.13 v1(256.23,47.13) v2(257.05,47.13) ; PQ708.5 v2(233.34,15.62)
DYN_TURB_GPU_PWR_ALRT#: length 287.7
  TOP w0.102: v2(117.02,128.99) 117.44,129.42 117.44,130.95 R14.2 116.86,131.54 D19.1 ; v2(215.04,73.29) 215.29,73.04 216.02,73.04 217.11,71.95 224.36,71.95 225.32,70.98 v2(227.07,70.98) ; PR30.2 3.15,142.33 3.31,142.16 v2(3.31,141.34)
  IN1 w0.109: v2(49.78,130.78) 49.79,130.77 53.25,130.77 53.35,130.67 64.85,130.67 66.3,129.22 83.33,129.22 84.01,129.9 108.78,129.9 109.8,128.88 114.59,128.88 114.81,129.1 115.77,129.1 116.2,128.66 116.69,128.66 v2(117.02,128.99)
  BOTTOM w0.102: v2(49.78,130.78) 44.56,136 40.58,136 38.12,138.47 v1(33.51,138.47) 19.05,138.47 18.13,139.38 7.43,139.38 7.22,139.18 3.78,139.18 3.31,139.64 v2(3.31,141.34) ; v2(227.07,70.98) 227.07,71.39 227.43,71.74 229.08,71.74 229.74,72.4 232.08,72.4 232.33,72.16 U46.A46 ; v2(215.04,73.29) 215.04,73.67 211.66,77.04 211.66,80.58 210.29,81.95 210.29,84.57 208.08,86.78 200.56,86.78 195.4,91.94 192.1,91.94 187.88,96.15 155.84,96.15 153.79,98.21 149.95,98.21 149.11,97.37 141.7,97.37 129.49,109.58 129.49,129.77 126.27,132.99 121.07,132.99 117.08,128.99 v2(117.02,128.99)
EC5048_TX: length 333.7
  IN1 w0.109: v2(242.13,72.8) 243.37,72.8 243.94,73.37 244.65,73.37 244.78,73.24 246.69,73.24 247.42,72.51 248.67,72.51 249.26,71.92 261.1,71.92 261.38,71.65 275.7,71.65 276.33,72.28 276.73,72.28 v2(276.78,72.33)
  IN4 w0.109: v2(242.13,72.8) 242.44,73.11 242.44,73.62 242.01,74.05 234.14,74.05 233.1,73.02 233.1,70.08 231.98,68.96 229.45,68.96 227.26,66.77 218.87,66.77 216.57,69.07 210.18,69.07 185.72,93.53 145.06,93.53 134.77,103.82 132.99,103.82 132.93,103.89 122.39,103.89 119.64,106.64 119.64,114.22 122.08,116.66 125.31,116.66 127.03,118.38 127.03,127.06 125.75,128.33 125.75,129.74 125.04,130.45 124.57,130.45 123.37,131.65 123.37,133.96 122.71,134.62 122.71,138.34 121.28,139.78 121.28,149.82 123.27,151.82 123.27,152.97 126.16,155.85 126.16,158.27 126.83,158.94 128.16,158.94 129.66,160.44 129.66,162.53 126.88,165.32 124.2,165.32 123.65,165.88 v2(123.65,165.9)
  BOTTOM w0.102: U46.B2 242.8,72.88 242.21,72.88 v2(242.13,72.8) ; JDEG2.2 275.34,31.59 275.11,31.36 275.11,30.9 275.28,30.72 275.28,29.73 274.06,28.51 R849.2 273.81,27.75 274.52,27.04 v1(275.51,27.04) 279.37,27.04 282.14,29.81 282.14,38.11 289.04,45.01 289.04,56.52 287.62,57.94 281.18,57.94 281.05,57.81 277.66,57.81 276.43,59.04 276.43,70.83 277.01,71.41 277.01,72.1 v2(276.78,72.33) ; JMINI2.17 120.29,167.15 121.54,165.9 v2(123.65,165.9)
EC_32KHZ_ECE5048: length 52.8
  TOP w0.102: v2(220.09,53.86) 220.85,53.1 222.43,53.1 225.63,49.9 226.56,49.9 229.89,46.56 229.89,42.46 231.47,40.88 234.2,40.88 235.49,42.18 237.84,42.18 238.89,43.22 240,43.22 240.33,43.55 241.07,43.55 241.45,43.17 241.45,42.64 241.87,42.23 v2(242.01,42.23)
  IN3 w0.127: v2(232.43,64.25) 230.73,64.25 228.6,62.12 227.79,62.12 223.8,58.13 223.8,57.77 220.09,54.06 v2(220.09,53.86)
  BOTTOM w0.102: U51.B62 242.05,42.19 v2(242.01,42.23) ; v1(232.14,62.94) 232.43,63.23 v2(232.43,64.25) 233.07,64.25 233.63,64.81 U46.B35
EC_WAKE#: length 214.9
  TOP w0.076: v2(71.88,64) 72.32,63.56 72.59,63.56 72.95,63.21 72.95,61.15 72.82,61.02 72.82,59.7 72.59,59.47 72.59,59.37
  TOP w0.102: RH216.1 72.97,50.84 72.97,55.7 72.59,56.08 72.59,59.37 ; v2(242.01,49.51) 241.58,49.09 240.87,49.09 240.61,49.34 240.61,50.49 238.61,52.49 234.67,52.49 233.73,53.43 v2(230.91,53.43)
  IN1 w0.109: v2(71.88,64) 71.88,63.85 72.19,63.54 72.69,63.54 72.87,63.36 72.87,59.4 72.46,58.99 72.46,55.66 73.56,54.56 73.56,54.05 74.27,53.34 74.27,52.16 75.28,51.15 75.28,50.37 76.28,49.38 77.05,49.38 78.58,47.84 82.92,47.84 85.22,45.54 92.72,45.54 94.35,47.17 98.04,47.17 98.46,46.75 106.77,46.75 107.11,46.4 111.69,46.4 114.89,43.2 120.47,43.2 122.55,41.12 171.69,41.12 171.69,41.13 173.31,41.13 174.04,41.85 185.48,41.85 185.65,41.68 185.66,41.68 185.71,41.62 192.76,41.62 200.23,49.09 214.58,49.09 217.75,52.26 227.84,52.26 229.01,53.43 v2(230.91,53.43)
  BOTTOM w0.102: U51.B23 241.55,49.97 v2(242.01,49.51) ; v2(230.91,53.43) v1(230.91,51.96) 231.37,51.5 R846.1 ; v2(71.88,64) 71.88,64.26 UH1.R11
EDID_SELECT#: length 164.1
  TOP w0.102: v2(239.11,72.75) 239.11,72.68 238.48,72.05 235.43,72.05 234.77,72.71 234.77,73.72 232.54,75.96 231.15,75.96 229.7,74.51 225.22,74.51 223.21,72.5 217.19,72.5 215.64,74.05 212.39,74.05 v2(212.06,73.72)
  BOTTOM w0.102: U46.B61 238.73,73.7 238.68,73.66 238.68,73.18 v2(239.11,72.75) ; v2(212.06,73.72) 209.7,73.72 207.62,75.81 207.62,76.71 206.87,77.46 206.39,77.46 205.58,78.27 198.12,78.27 192.07,84.32 189.06,84.32 187.99,85.38 179.67,85.38 179.57,85.28 169.31,85.28 165.35,89.25 154.28,89.25 152.25,87.21 147.64,87.21 146.45,86.02 139.27,86.02 126.16,99.12 v1(125.64,99.12) 124.52,99.12 123.5,100.14 118.46,100.14 114.55,104.05 105.87,104.05 104.85,103.04 97.53,103.04 U19.1
EDP_COMP: length 3.9
  TOP w0.305: JCPU1.E24 165.59,127.8 v2(166.06,127.33)
  BOTTOM w0.089: v2(166.06,127.33) 165.64,126.91 v1(165.38,126.91)
  BOTTOM w0.381: v2(166.06,127.33) 166.53,126.86 167.84,126.86 RC1.2
EDP_CPU_AUX: length 61.7
  TOP w0.102: v2(173.08,131.31) 173.55,130.84 JCPU1.N27
  BOTTOM w0.102: R2198.1 132.47,146.45 133.11,146.45 R1995.1 133.77,146.44 134.14,146.44 136.87,143.71 136.87,143.33 140.51,139.69 v3(143.56,139.69) 155.26,139.69 158,142.43 173.71,142.43 176.05,140.09 176.05,138.11 173.51,135.57 173.51,130.98 173.3,130.77 172.92,130.77 172.82,130.87 172.82,131.04 v2(173.08,131.31)
EDP_CPU_AUX#: length 61.7
  TOP w0.102: v2(173.08,130.31) 172.59,130.8 JCPU1.M27
  BOTTOM w0.102: v2(173.08,130.31) 173.09,130.32 173.15,130.32 173.72,130.89 173.72,135.48 176.26,138.02 176.26,140.18 173.8,142.65 157.91,142.65 155.17,139.9 143.84,139.9 143.83,139.92 143.29,139.92 143.28,139.9 140.6,139.9 137.08,143.42 137.08,143.8 134.23,146.65 133.77,146.65 R1994.2 133.14,146.67 132.47,146.67 R2199.1
EDP_CPU_AUX#_C: length 2.6
  BOTTOM w0.102: U23.3 127.42,146.5 127.51,146.41 127.94,146.41 128.2,146.67 128.85,146.67 C105.1
EDP_CPU_AUX#_R: length 1.4
  BOTTOM w0.102: C105.2 130.43,146.67 130.88,146.67 R2199.2
EDP_CPU_AUX_C: length 2.6
  BOTTOM w0.102: C104.1 128.85,146.45 128.29,146.45 128.03,146.19 127.51,146.19 127.42,146.1 U23.4
EDP_CPU_AUX_R: length 1.4
  BOTTOM w0.102: R2198.2 130.88,146.45 130.43,146.45 C104.2
EDP_CPU_LANE_N0: length 50.9
  TOP w0.102: JCPU1.P35 174.59,139.49 v2(174.63,139.53)
  BOTTOM w0.102: C101.2 130.43,144.55 131.64,144.55 132.31,143.88 v3(133.48,143.88) 134.31,143.88 139.2,138.99 155.68,138.99 158.36,141.67 173.43,141.67 175.18,139.92 175.18,139.71 174.99,139.53 v2(174.63,139.53)
EDP_CPU_LANE_N0_C: length 2.8
  BOTTOM w0.102: C101.1 128.85,144.55 128.75,144.55 128.36,144.16 128.04,144.16 127.61,144.59 127.51,144.59 127.42,144.5 U23.8
EDP_CPU_LANE_N1: length 50.8
  TOP w0.102: JCPU1.N34 173.53,137.84 v2(173.06,138.31)
  BOTTOM w0.102: C118.2 130.43,142.64 131.37,142.64 131.47,142.54 131.47,141.91 131.7,141.68 132.29,141.68 132.52,141.91 132.52,142.54 132.62,142.64 133.85,142.64 138.47,138.02 v3(147.32,138.02) 155.89,138.02 158.81,140.95 169.36,140.95 171.52,138.78 173.37,138.78 173.61,138.54 173.61,138.39 173.52,138.31 v2(173.06,138.31)
EDP_CPU_LANE_N1_C: length 3.1
  BOTTOM w0.102: C118.1 128.85,142.64 128.67,142.64 128.36,142.95 128.36,143.21 128.01,143.55 127.86,143.55 127.62,143.79 127.5,143.79 127.41,143.7 U23.10
EDP_CPU_LANE_P0: length 50.9
  TOP w0.102: JCPU1.R35 175.59,139.5 v2(175.61,139.52)
  BOTTOM w0.102: v2(175.61,139.52) 175.39,139.74 175.39,140 173.5,141.88 158.27,141.88 155.59,139.21 139.29,139.21 134.4,144.09 133.75,144.09 133.74,144.11 133.21,144.11 133.2,144.09 132.4,144.09 131.73,144.76 130.43,144.76 C100.2
EDP_CPU_LANE_P0_C: length 2.8
  BOTTOM w0.102: C100.1 128.85,144.76 128.66,144.76 128.27,144.37 128.13,144.37 127.7,144.81 127.51,144.81 127.42,144.9 U23.7
EDP_CPU_LANE_P1: length 50.8
  TOP w0.102: JCPU1.P34 174.53,137.84 v2(174.06,138.31)
  BOTTOM w0.102: C103.2 130.43,142.86 131.46,142.86 131.69,142.63 131.69,142 131.79,141.9 132.2,141.9 132.3,142 132.3,142.63 132.53,142.86 133.94,142.86 138.56,138.24 147.04,138.24 147.05,138.25 147.58,138.25 147.6,138.24 155.8,138.24 158.72,141.16 169.45,141.16 171.61,139 173.46,139 173.81,138.65 173.81,138.44 173.95,138.31 v2(174.06,138.31)
EDP_CPU_LANE_P1_C: length 3.1
  BOTTOM w0.102: C103.1 128.85,142.86 128.76,142.86 128.57,143.04 128.57,143.31 128.29,143.59 ; 128.29,143.59 128.12,143.76 127.95,143.76 127.71,144.01 127.5,144.01 127.41,144.1 U23.9 ; 128.29,143.59 v3(128.28,143.61)
EDP_HPD#: length 28.3
  TOP w0.102: JCPU1.P27 174.59,130.86 v2(174.14,131.31)
  BOTTOM w0.102: v2(174.14,131.31) 174.67,131.84 176.17,131.84 176.55,132.22 176.55,132.47 176.91,132.83 177.24,132.83 177.64,133.23 177.64,136.44 177.42,136.67 v1(177.42,137.67) 177.42,139.92 173.13,144.21 168.12,144.21 167.28,145.05 RC65.1 166.6,147.18 QC6.1
EMBCLK_REQ#: length 146.2
  IN3 w0.127: v2(66.09,66.05) 66.06,66.05 64.41,67.7 64.41,71.34 66.34,73.27 66.78,73.27 67.18,73.67 67.18,74.27 66.79,74.66 66.79,75.31 65.76,76.34 63.04,76.34 61.21,78.17 60.2,78.17 59.26,79.11 54.46,79.11 52.58,77.23 49.27,77.23 42.67,83.83 42.67,86.79 41.66,87.8 41.1,87.8 38.25,90.64 38.25,98.13 23.16,113.22 21.3,113.22 19.49,115.02 19.49,117.75 16.67,120.57 16.67,122.83 14.82,124.69 14.82,125.92 4.16,136.57 4.16,141.38 2.91,142.63 2.91,145.23 5.62,147.94 6.96,147.94 7.82,148.81 7.82,155.26 v2(8.96,156.4)
  BOTTOM w0.076: 66.95,66.33 67.36,66.33 67.46,66.23 67.92,66.23 68.12,66.43 68.62,66.43 UH1.Y3
  BOTTOM w0.102: 66.95,66.33 66.45,66.33 66.17,66.05 v2(66.09,66.05) 65.84,66.31 v1(64.53,66.31) 62.36,66.31 RH140.1 ; v2(8.96,156.4) 9.47,155.89 11.56,155.89 12.04,156.38 JMINI4.7
EMC4021_BC_CLK: length 258.7
  IN4 w0.109: v2(34.26,86.47) 34.72,86.02 34.72,82.77 39.58,77.92 41.27,77.92 42.79,76.4 42.79,74.21 43.67,73.34 44.05,73.34 45.46,71.93 46.81,71.93 51.26,67.48 52.04,67.48 52.39,67.13 52.39,61.21 52.28,61.1 51.92,61.1 51.81,60.99 51.81,60.67 51.92,60.56 52.28,60.56 52.39,60.45 52.39,60.12 52.17,59.9 52.17,59.58 52.39,59.36 52.39,57.86 54.25,56 55.97,56 56.39,55.58 56.39,54.37 62.28,48.48 64.14,48.48 65.41,47.21 84.11,47.21 86.47,44.85 108.61,44.85 109.32,44.14 109.32,43.96 109.19,43.83 107.92,43.83 107.8,43.7 107.8,43.4 107.92,43.27 110.19,43.27 110.49,42.97 120.57,42.97 122.18,41.36 170.93,41.36 172.05,42.48 176.81,42.48 177.15,42.83 184.9,42.83 185.73,43.65 196.28,43.65 199.6,46.98 208.56,46.98 209.86,45.67 220.74,45.67 220.91,45.83 227.46,45.83 228.2,46.58 232.34,46.58 233.27,45.65 233.27,44.63 233.61,44.29 234.63,44.29 235.61,43.31 237.37,43.31 238.89,41.8 244.3,41.8 244.47,41.97 244.47,42.94 244.88,43.35 245.89,43.35 v2(246.38,43.84)
  BOTTOM w0.102: U29.8 v1(33.15,87.44) 33.15,86.55 33.4,86.3 34.09,86.3 v2(34.26,86.47) ; v2(246.38,43.84) 246.38,43.66 246.62,43.42 247.24,43.42 247.5,43.17 U51.B49
EMC4021_BC_DAT: length 264
  IN1 w0.109: v2(246.96,43.84) 249.03,41.77 v2(249.6,41.77)
  IN4 w0.109: v2(33.72,86.7) 33.72,86.49 33.61,86.38 32.7,86.38 32.59,86.27 32.59,85.94 32.7,85.84 33.61,85.84 33.72,85.73 33.72,85.4 33.61,85.29 32.7,85.29 32.59,85.18 32.59,84.85 32.7,84.74 33.27,84.74 33.4,84.62 33.4,84.32 33.27,84.2 32.7,84.2 32.59,84.09 32.59,83.76 32.7,83.65 33.15,83.65 33.27,83.52 33.27,82.51 34.06,81.73 35.47,81.73 39.49,77.7 40.28,77.7 42.54,75.44 42.54,74.16 43.66,73.04 44.05,73.04 45.37,71.72 46.68,71.72 51.48,66.92 51.48,58.47 54.15,55.79 55.88,55.79 56.16,55.51 56.16,54.29 62.19,48.27 64.05,48.27 65.39,46.93 72.03,46.93 72.63,46.33 74.4,46.33 74.83,46.75 84.27,46.75 86.38,44.64 103.9,44.64 105.78,42.76 120.48,42.76 122.1,41.15 171.01,41.15 172.13,42.27 177.05,42.27 177.4,42.62 184.99,42.62 185.81,43.44 196.37,43.44 199.67,46.75 208.48,46.75 209.77,45.46 220.83,45.46 220.95,45.58 227.5,45.58 228.29,46.37 232.26,46.37 233.06,45.56 233.06,44.54 233.53,44.07 234.55,44.07 235.52,43.1 237.28,43.1 238.82,41.57 245.21,41.57 245.52,41.87 245.52,42.37 246.96,43.81 v2(246.96,43.84)
  BOTTOM w0.102: v2(33.72,86.7) 33.72,87.45 33.35,87.82 33.35,89.78 33.65,90.07 U29.7 ; v2(249.6,41.77) 249.76,41.77 v1(250.05,42.06) 250.51,42.52 250.89,42.52 R1126.2 ; v2(246.96,43.84) 247.14,43.67 U51.B48
EMC4021_BC_INT#: length 261.6
  IN4 w0.109: v2(249.27,49.42) 247.96,48.1 246.1,48.1 241.35,43.35 240.03,43.35 239.9,43.22 238.71,43.22 238.4,43.52 235.69,43.52 234.65,44.56 234.65,45.38 234.16,45.87 233.35,45.87 232.43,46.79 228.12,46.79 227.4,46.08 220.85,46.08 220.66,45.88 209.98,45.88 208.66,47.21 199.53,47.21 196.19,43.86 185.64,43.86 184.81,43.04 177.07,43.04 176.72,42.69 171.96,42.69 170.84,41.57 122.27,41.57 120.64,43.2 110.55,43.2 108.7,45.06 86.56,45.06 84.2,47.42 65.53,47.42 64.25,48.7 62.36,48.7 56.79,54.27 56.79,55.47 56.05,56.21 54.33,56.21 52.6,57.94 52.6,67.22 52.13,67.69 51.35,67.69 46.89,72.14 45.55,72.14 44.14,73.55 43.79,73.55 43.15,74.18 43.15,76.37 35,84.52 35,86.48 v2(34.82,86.65)
  BOTTOM w0.102: U29.9 30.68,91.28 R385.2 R386.2 v1(31.25,89.98) 31.95,89.98 32.5,89.44 32.5,86.91 33.39,86.02 34.48,86.02 34.82,86.36 v2(34.82,86.65) ; U51.A34 v2(249.27,49.42)
EN_1.5VSP: length 6.1
  BOTTOM w0.102: v1(100.18,28.63) 99.92,28.88 PR403.2
  BOTTOM w0.254: PR403.2 PR404.1 PR406.2 PC406.1 103.25,29.34 103.63,29.34 103.8,29.51 PU400.5
EN_+1.05VSP: length 40.8
  TOP w0.102: v2(59.99,54.01) 60.15,54.01 60.65,54.52 v1(60.65,55.06) 60.78,55.18 PR315.1 PR303.2
  IN3 w0.127: v2(59.99,54.01) 57.58,54.01 55.89,55.7 53.37,55.7 49.33,59.75 49.33,68.19 v2(49.2,68.31)
  BOTTOM w0.102: PU300.3 39.09,67.19 39.09,67.19 38.71,67.57 38.71,68.11 38.45,68.36 38.45,69.63 39.28,70.46 39.28,70.69 PC307.1 40.13,71.2 42.73,68.59 48.92,68.59 v2(49.2,68.31)
EN_DK_PWRBAR: length 3.2
  BOTTOM w0.254: PU1001.17 257.81,32.68 257.5,32.98 v1(257.35,32.98) 257.22,32.98 256.94,32.7 PR1028.1 PR1027.1
EN_DOCK_PWR_BAR: length 55.8
  TOP w0.254: v2(254.61,34.02) 254.61,35.57 253.82,36.36 252.75,36.36 252.27,36.84 252.27,37.69 248.82,41.15 248.82,42.48 249.1,42.76 249.99,42.76 251.74,44.51 251.74,46.5 250.54,47.69 250.2,47.69 249.96,47.93 249.96,50.07 249.02,51.01 249.02,54.91 248.08,55.84 248.08,57.16 248.54,57.62 248.54,58.48 247.83,59.2 247.83,62.87 245.13,65.57 243.84,65.57 242.97,66.45 242.97,67.68 242.34,68.31 240.73,68.31 240.65,68.39 236.86,68.39 236.63,68.16 236.23,68.16 235.45,67.37 234.52,67.37 234.29,67.15 v2(234.29,66.87)
  BOTTOM w0.102: v2(254.61,34.02) 254.43,33.85 v1(254.43,33.49)
  BOTTOM w0.254: U46.B37 233.89,66.41 234.29,66.81 v2(234.29,66.87) ; v2(254.61,34.02) 254.91,34.02 255.34,33.59 PR1027.2
EN_I2S_NB_CODEC#: length 268.5
  TOP w0.102: v2(16.79,79.42) 16.27,78.9 JIO1.81
  IN3 w0.127: v2(202.41,42.36) 202.41,42.89 212.62,53.1 219.35,53.1 219.63,53.38 219.63,54.45 228.04,62.85 228.8,62.85 230.61,64.66 230.61,66.15 231.67,67.22 233.32,67.22 234.54,66 v2(234.58,66)
  IN4 w0.109: v2(202.41,42.36) 202.31,42.25 200.35,42.25 198.06,39.95 190.27,39.95 188.81,38.49 177.48,38.49 177.24,38.25 175.79,38.25 174.04,36.51 167.72,36.51 167.04,37.19 121.54,37.19 120.54,38.2 116.38,38.2 113.58,38.2 113.16,38.62 103.07,38.62 101.57,37.12 96.65,37.12 96.04,36.51 87.93,36.51 86.97,37.48 86.03,37.48 85.93,37.58 84.4,37.58 84.12,37.3 81.41,37.3 80.94,36.83 77.83,36.83 76.57,38.09 62.26,38.09 54.47,45.88 54.47,49.4 52.23,51.65 52.23,53.04 48.41,56.86 48.41,64.56 48.1,64.86 46.83,66.14 45.8,66.14 44.79,67.14 44.08,67.14 42.82,68.41 42.6,68.41 41.43,69.58 41.43,70.22 40.03,71.62 29.37,71.62 28.56,70.81 27.06,70.81 26.87,70.99 23.13,70.99 22.93,71.19 21.17,71.19 16.38,75.98 16.38,78.14 16.79,78.55 v2(16.79,79.42)
  BOTTOM w0.102: v2(202.41,42.36) 202.42,42.36 v1(202.88,42.81) ; U46.B36 234.48,65.91 v2(234.58,66)
EN_INVPWR: length 251.8
  TOP w0.102: v2(215.8,66.1) 215.8,66.08 222.07,59.8 225.53,59.8 225.78,59.55 236.88,59.55 237.31,59.12 240.94,59.12 243.74,56.33 243.74,53.23 243.48,52.97 v2(243.31,52.97)
  IN4 w0.109: v2(215.8,66.1) 215.04,66.87 212.8,66.87 211.26,68.4 209.89,68.4 185.39,92.9 144.79,92.9 134.51,103.19 132.73,103.19 132.66,103.26 122.13,103.26 119.01,106.38 119.01,114.49 121.82,117.3 125.05,117.3 126.34,118.59 126.34,126.8 124.31,128.83 124.31,129.82 122.71,131.43 122.71,133.73 121.27,135.16 121.27,137.11 120.45,137.93 120.45,151.65 121.17,152.38 121.17,153.62 121.03,153.76 121.03,154.27 123.19,156.43 124.64,156.43 125.53,157.32 125.53,158.53 126.58,159.59 127.92,159.59 129.03,160.7 129.03,161.63 127.61,163.06 v2(125.27,163.06)
  BOTTOM w0.102: U51.A25 243.3,51.91 243.52,52.13 243.52,52.76 v2(243.31,52.97) 242.95,52.97 v1(242.8,53.12) 242.64,53.28 242.64,53.71 243.17,54.24 RP7.6 ; v2(125.27,163.06) 124.31,162.09 119.72,162.09 118.86,161.23 115.89,161.23 115.42,161.7 109.13,161.7 108.31,160.87 106.09,160.87 106.01,160.78 101.82,160.78 Q22.2
EN_LCDPWR: length 71.4
  TOP w0.102: v2(118.63,159.61) 118.72,159.53 118.72,158.08 118.99,157.81 JEDP1.24 ; v2(94.16,163.31) 94.33,163.49 R1140.1 94.8,165.27 94.98,165.45 U28.3 ; U33.3 113.61,170.54 113.61,172.17 v1(113.42,172.36) 112.5,173.29 v2(112.35,173.29) ; JEDP1.17 122.49,158.32 v2(122.4,158.41)
  IN3 w0.127: v2(122.4,158.41) 122.06,158.41 121.15,159.32 118.92,159.32 v2(118.63,159.61) 118.54,159.7 110.17,159.7 109.01,160.86 97.07,160.86 94.79,163.13 94.33,163.13 v2(94.16,163.31)
  BOTTOM w0.102: v2(112.35,173.29) 111.52,172.45 106.6,172.45 105.61,173.44 103.83,173.44 100.33,169.94 95.02,169.94 94.14,169.06 94.14,164.87 93.8,164.53 D53.1 93.79,164.22 ; 93.79,164.22 93.79,164.13 94.16,163.77 v2(94.16,163.31) ; 93.79,164.22 93.22,163.64 D6.1
ENVDD_PCH: length 314.4
  TOP w0.102: v2(82.78,61.28) 82.95,61.1 85.16,61.1 85.5,61.43 85.5,63.17 85.71,63.39 86.8,63.39 87.91,64.5 RH118.2 88.37,64.12 89.65,64.12 90.35,64.82 v1(91.86,64.82) v2(93.19,64.82)
  IN1 w0.109: v2(198.53,63.28) 199.72,63.28 200.56,64.12 204.49,64.12 204.98,64.61 208.57,64.61 208.91,64.95 212.9,64.95 213.47,65.51 219.79,65.51 221.56,67.29 234.46,67.29 v2(234.88,66.87)
  IN3 w0.127: v2(93.19,64.82) 93.19,64.81 94.61,63.39 94.61,61.2 98.86,56.96 101.05,56.96 103.97,54.04 119.09,54.04 122.1,51.03 123.66,51.03 125.3,49.39 147.93,49.39 150.71,46.61 162.83,46.61 164.11,47.89 164.11,48.3 164.64,48.83 165.48,48.83 167.28,50.62 188.86,50.62 190.85,52.62 191.62,52.62 193.78,54.78 193.78,59.17 197.88,63.28 v2(198.53,63.28)
  IN4 w0.109: v2(93.19,64.82) 92.68,65.33 92.68,68.31 91.35,69.64 91.35,76.1 92.68,77.44 92.68,79.01 92.16,79.54 92.16,83.85 91.26,84.75 91.26,87.39 101.07,97.19 103.77,97.19 105.15,98.57 106.76,98.57 108.1,99.91 108.1,100.93 109.12,101.96 109.12,103.46 110.5,104.84 110.5,106.62 111.03,107.15 111.03,114.53 113.14,116.63 113.14,130.45 114.73,132.04 114.73,135.4 115.26,135.93 115.26,138.5 116.79,140.03 116.79,153.62 117.51,154.34 117.51,156.1 117.44,156.17 117.44,157.59 117.82,157.98 117.82,161.35 v2(117.37,161.8)
  BOTTOM w0.102: UH1.G36 82.62,61.28 v2(82.78,61.28) ; U55.2 96.11,160.08 96.32,159.88 99.26,159.88 99.62,160.24 99.62,160.81 100.11,161.3 102.59,161.3 102.82,161.07 108.22,161.07 109.19,162.04 115.37,162.04 115.98,161.43 117,161.43 v2(117.37,161.8) ; v2(234.88,66.87) 234.88,66.87 234.45,67.3 234.15,67.3 233.75,66.91 U46.B38
ERC1: length 2.4
  BOTTOM w0.254: PC1007.1 v1(262.61,26.91) 262.61,26.96 262.47,27.11 PU1001.3
ERC2: length 4.4
  BOTTOM w0.102: v1(254.53,30.77) 254.89,31.13 256.01,31.13 PC1009.1
  BOTTOM w0.254: PC1009.1 256.49,30.65 257.96,30.65 257.99,30.68 PU1001.13
ERC3: length 4.1
  BOTTOM w0.102: v1(256.83,28.02) 256.45,28.4 PC1008.1
  BOTTOM w0.254: 257.58,30.16 257.6,30.18 PU1001.12
  BOTTOM w0.508: 257.58,30.16 257.1,30.16 256.46,29.53 PC1008.1
ESATA_PE1: length 6.9
  TOP w0.102: v1(9.51,151.88) 9.32,151.69 v2(9.32,151.14) 9.17,150.99 R44.2 8.78,149.92 U44.9 ; R49.2 9.17,148.32 v2(8.61,148.88)
  BOTTOM w0.102: v2(9.32,151.14) 9.32,151.02 8.61,150.31 v2(8.61,148.88)
ESATA_PE2: length 7.3
  TOP w0.102: U44.8 R43.2 9.17,149.24 9.57,148.83 10.39,148.83 R45.2 11.82,150.27 11.82,151.21 v1(10.96,152.07)
ESATA_PRX_DTX_N3: length 2
  TOP w0.102: U44.4 6.19,146.99 6.33,146.85 6.33,146.63 6.67,146.3 6.67,146.15 C665.1
ESATA_PRX_DTX_N3_BP: length 8.5
  BOTTOM w0.102: R842.2 6.66,146.15 6.66,147.04 6.95,147.32 6.95,150.32 5.26,152 5.26,152.89 C680.1
ESATA_PRX_DTX_N3_C: length 105.8
  TOP w0.102: C665.2 6.65,144.56 6.65,144.26 v2(6.45,144.06)
  IN3 w0.127: v2(64.18,86.22) 64,86.4 62.94,86.4 60.63,88.72 55.36,88.72 42.78,101.29 40.81,101.29 35.35,106.75 34.82,106.75 19.9,121.67 19.9,125.33 10.49,134.73 10.49,138.8 6.58,142.71 6.58,143.93 v2(6.45,144.06)
  BOTTOM w0.076: 72.31,77.63 72.31,77.62 72.34,77.6 72.34,76.95 72.5,76.79 UH1.BC12
  BOTTOM w0.102: 72.31,77.63 72.31,77.79 72.21,77.89 72.21,78.9 71.85,79.27 71.85,80.09 69.85,82.09 69.85,85.81 69.25,86.41 64.38,86.41 v2(64.18,86.22) ; C665.2 6.65,144.56 6.65,144.26 v2(6.45,144.06)
ESATA_PRX_DTX_N3_RP: length 2.8
  TOP w0.102: C673.1 5.27,152.93 5.27,152.78 5.7,152.35 6.07,152.35 6.33,152.09 6.33,152.01 6.19,151.87 U44.12
ESATA_PRX_DTX_P3: length 2
  TOP w0.102: C666.1 6.88,146.14 6.88,146.39 6.55,146.72 6.55,146.83 6.69,146.97 U44.5
ESATA_PRX_DTX_P3_BP: length 8.5
  BOTTOM w0.102: C677.1 5.48,152.89 5.48,152.09 7.16,150.41 7.16,147.23 6.88,146.95 6.88,146.15 R844.2
ESATA_PRX_DTX_P3_C: length 105.8
  TOP w0.102: v2(7.03,144.06) 6.87,144.22 6.87,144.55 C666.2
  IN3 w0.127: v2(7.03,144.06) 6.95,144.06 6.87,143.97 6.87,143.88 6.83,143.84 6.83,142.82 10.74,138.9 10.74,134.84 20.15,125.43 20.15,121.77 34.92,107 35.46,107 40.91,101.54 42.88,101.54 55.46,88.96 60.73,88.96 63.04,86.65 64.16,86.65 64.29,86.78 64.29,86.88 v2(64.18,86.98)
  BOTTOM w0.076: 72.53,77.63 72.53,77.61 72.5,77.59 72.5,77.48 72.57,77.41 72.71,77.41 72.77,77.36 72.77,77.14 72.7,77.07 UH1.BE12
  BOTTOM w0.102: 72.53,77.63 72.53,77.88 72.43,77.98 72.43,78.99 72.07,79.35 72.07,80.18 70.07,82.18 70.07,85.9 69.34,86.63 64.18,86.63 64.08,86.73 64.08,86.88 v2(64.18,86.98) ; v2(7.03,144.06) 6.87,144.22 6.87,144.55 C666.2
ESATA_PRX_DTX_P3_RP: length 2.8
  TOP w0.102: U44.11 6.69,151.85 6.55,151.99 6.55,152.18 6.16,152.57 5.79,152.57 5.49,152.87 5.49,152.95 C674.1
ESATA_PTX_DRX_N3: length 2.2
  TOP w0.102: C664.1 4.75,145.81 4.6,145.96 4.6,146.14 5.05,146.59 5.05,146.82 5.19,146.96 U44.2
ESATA_PTX_DRX_N3_BP: length 8.1
  BOTTOM w0.102: R828.2 4.58,146.15 4.58,146.27 4.6,146.28 4.6,147.14 4.58,147.15 4.58,148.39 4.46,148.51 4.46,149.23 4.47,149.24 v3(4.47,149.44) 4.47,149.77 4.46,149.78 4.46,151.72 3.62,152.56 3.62,152.93 C678.1
ESATA_PTX_DRX_N3_C: length 108.6
  TOP w0.102: C664.2 4.59,144.56 4.59,144.37 v2(4.85,144.11)
  IN3 w0.089: 69.37,77.82 69.39,77.82 69.42,77.79 69.77,77.79 71.75,75.81 71.75,75.65 72.19,75.22 72.19,74.33 73,73.52 73,72.91 72.78,72.69 72.63,72.69 v2(72.41,72.48)
  IN3 w0.127: 69.37,77.82 69.2,77.82 68.14,78.89 68.14,79.9 66.39,81.65 66.39,82.64 64.01,85.02 62.67,85.02 61.77,85.92 61.77,86.58 60.38,87.97 55.15,87.97 49.63,93.48 49.63,93.5 49.48,93.65 47.53,93.65 35.53,105.65 34.97,105.65 32.74,107.89 32.71,107.89 19.25,121.35 19.25,125.02 9.74,134.53 9.74,138.62 4.72,143.63 4.72,143.98 v2(4.85,144.11)
  BOTTOM w0.102: v2(72.41,72.48) 72.68,72.75 UH1.AR13 ; C664.2 4.6,144.56 4.6,144.36 v2(4.85,144.11)
ESATA_PTX_DRX_N3_RP: length 3.4
  TOP w0.102: C672.1 3.53,152.9 3.53,152.67 3.77,152.43 v3(4.35,152.43) 4.76,152.43 5.03,152.16 5.03,152.01 5.19,151.85 U44.14
ESATA_PTX_DRX_P3: length 2.2
  TOP w0.102: U44.1 4.69,146.96 4.83,146.82 4.83,146.68 4.38,146.23 4.38,145.99 4.2,145.81 C663.1
ESATA_PTX_DRX_P3_BP: length 8.1
  BOTTOM w0.102: C679.1 3.1,153.14 3.4,152.85 3.4,152.47 4.24,151.63 4.24,148.42 4.37,148.3 v3(4.37,146.88) 4.37,146.14 R827.2
ESATA_PTX_DRX_P3_C: length 108.5
  TOP w0.102: C663.2 4.06,144.89 4.37,144.58 4.37,144.29 v2(4.19,144.11)
  IN3 w0.089: v2(72.41,73.06) 72.61,72.87 72.71,72.87 72.82,72.98 72.82,73.45 72.01,74.26 72.01,75.15 71.58,75.58 71.58,75.73 69.7,77.61 69.42,77.61 69.39,77.57 69.37,77.57
  IN3 w0.127: v2(4.19,144.11) 4.32,144.11 4.43,143.99 4.43,143.93 4.47,143.89 4.47,143.53 9.49,138.51 9.49,134.42 19,124.91 19,121.25 32.61,107.64 32.64,107.64 34.87,105.4 35.43,105.4 47.43,93.4 49.38,93.4 49.38,93.4 49.38,93.38 55.04,87.72 60.27,87.72 61.52,86.47 61.52,85.82 62.56,84.77 63.91,84.77 66.15,82.54 66.15,81.55 67.89,79.8 67.89,78.78 69.1,77.57 69.37,77.57
  BOTTOM w0.102: v2(72.41,73.06) 72.69,73.34 UH1.AT13 ; v2(4.19,144.11) 4.38,144.3 4.38,144.58 4.06,144.89 C663.2
ESATA_PTX_DRX_P3_RP: length 3.3
  TOP w0.102: C671.1 3.31,152.98 3.31,152.58 3.69,152.2 4.68,152.2 4.81,152.07 4.81,151.98 4.69,151.86 U44.15
ESATA_USB_PWR_EN#: length 370
  TOP w0.102: U48.4 20.29,162.26 20.34,162.32 20.73,162.32 20.79,162.26 U48.5 21.08,161.91 23.09,163.92 v1(23.51,163.92) v2(24.48,163.92)
  IN1 w0.109: v2(234.35,70.27) 231.16,73.45 v2(231.16,73.65)
  IN3 w0.127: v2(24.48,163.92) 24.31,164.1 11.36,164.1 2.73,155.46 2.73,154.51 3.22,154.01 3.22,147.9 1.31,145.99 1.31,140.58 2.44,139.45 2.44,128.32 16.31,114.44 16.65,114.44 29.15,101.95 29.15,91.34 27.25,89.45 27.25,84.28 31.51,80.02 34.79,80.02 37.39,77.43 37.39,73.85 41.6,69.63 41.6,68.49 42.68,67.41 42.68,64.57 43.32,63.94 43.32,62.46 45.34,60.44 45.34,58.1 54.39,49.04 57.56,49.04 60.04,46.56 66.22,46.56 67.64,45.14 69.54,45.14 70.64,44.04 75.58,44.04 76.23,43.4 100.16,43.4 101.96,41.59 121.08,41.59 122.62,40.04 144.58,40.04 147.58,37.05 166.75,37.05 168.19,38.48 172.54,38.48 174.17,40.12 187.21,40.12 188.48,41.39 192.2,41.39 197.66,46.85 203.86,46.85 207.87,50.86 207.87,51.33 224.65,68.11 226.47,68.11 227.89,69.53 228.83,69.53 230.17,70.88 233.27,70.88 233.88,70.27 v2(234.35,70.27)
  BOTTOM w0.102: v2(231.16,73.65) 230.93,73.89 RP1.8 ; U46.B44 233.97,69.91 234.35,70.28 v2(234.35,70.27)
EXPCLK_REQ#: length 67.9
  TOP w0.102: v2(24.2,88.99) 24.18,88.99 v1(23.57,88.38) 22.49,87.3 JIO1.54
  IN1 w0.109: v2(24.2,88.99) 24.99,89.78 34.47,89.78 36.63,87.62 36.63,86.27 37.54,85.36 41.73,85.36 43.37,83.72 43.37,78.69 47.54,74.52 47.54,71.95 49.46,70.03 50.09,70.03 51.33,68.8 v2(51.94,68.8)
  BOTTOM w0.102: v2(51.94,68.8) 51.94,68.87 52.32,68.49 53.59,68.49 54.38,67.7 54.38,66.72 55.3,65.8 55.78,65.8 56.89,66.92 58.11,66.92 58.29,67.09 59.51,67.09 RH125.1 59.99,66.23 60.48,65.75 65.61,65.75 65.71,65.65 66.38,65.65 v2(66.68,65.95) 66.76,66.03 67.95,66.03 68.16,65.82 68.62,65.82 UH1.V3
FAN1_PWM: length 63.5
  IN3 w0.127: v2(242.9,52.49) 243.46,52.49 244.22,53.25 244.22,53.4 247.55,56.72 249.51,56.72 250.78,58 250.78,58.93 251.35,59.5 251.35,61.3 253.99,63.94 253.99,75.49 247.76,81.72 241.81,81.72 v2(241.65,81.88)
  BOTTOM w0.102: U51.A24 242.8,52.39 v2(242.9,52.49) ; v2(241.65,81.88) v1(240.32,81.88) 236.67,81.88 235.85,81.06 234.19,81.06 R407.2 233.22,80.58 230.94,82.87 227.18,82.87 JFAN1.2
FAN1_TACH_FB: length 67.5
  IN3 w0.127: v2(241.2,82.39) 241.22,82.41 241.91,82.41 242.37,81.95 247.86,81.95 254.4,75.41 254.4,64.02 251.58,61.2 251.58,59.41 251.01,58.83 251.01,57.9 249.61,56.5 248.38,56.5 246.73,54.85 246.73,54.62 245.15,53.04 244.56,53.04 243.08,51.55 242.47,51.55 241.07,50.15 v2(241.07,50.1)
  BOTTOM w0.102: v2(241.07,50.1) 241.13,50.15 241.13,50.69 U51.B22 ; JFAN1.3 225.76,83.22 231.19,83.22 232.81,81.6 R408.2 233.7,81.83 234.19,82.31 v1(236.19,82.31) 241.12,82.31 v2(241.2,82.39)
FAN2_PWM: length 27.1
  IN3 w0.127: v2(31.46,94.47) 31.42,94.43 31.42,91.76 31.08,91.43 30.32,91.43 28.22,89.33 28.22,87.39 28.35,87.26 v2(28.42,87.26)
  BOTTOM w0.102: v2(28.42,87.26) 28.35,87.19 27.51,87.19 26.72,86.4 23.37,86.4 22.88,85.91 19.48,85.91 v1(18.13,84.55) 17.33,83.76 R409.2 14.78,84.9 D90.1 14.64,86.17 R213.2 ; v2(31.46,94.47) 31.65,94.28 U29.15
