# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCD_SMBCLK: length 221.2
  TOP w0.102: v2(239.7,44.57) 239.28,44.16 237.9,44.16 237.41,43.68 231.75,43.68 v2(231.51,43.43) ; v2(132.82,101.84) 133.2,101.84 133.35,101.69 133.75,101.69 134.14,102.08 134.14,103.82 133.78,104.18 133.78,115.15 132.54,116.4 132.54,123.64 129.59,126.58 129.59,128.49 130.83,129.74 130.83,134.33 127.91,137.25 125.93,137.25 123.62,139.56 123.01,139.56 121.31,141.26 121.31,153.61 120.85,154.06 120.85,154.9 120.99,155.04 JEDP1.20
  IN4 w0.109: v2(214.35,64.88) 214.5,65.04 214.22,65.32 213.46,65.32 213.26,65.11 211.48,65.11 209.06,67.53 209.06,67.94 187.91,89.08 172.87,89.08 170.03,91.93 142.5,91.93 133.44,100.98 133.44,101.41 133.01,101.84 v2(132.82,101.84)
  BOTTOM w0.102: v2(214.35,64.88) 214.53,64.71 214.53,62.98 214.12,62.57 214.12,45.68 212.9,44.46 212.9,39.26 215.26,36.89 220.34,36.89 223.89,40.45 225.57,40.45 226.64,41.52 227.63,41.52 229.67,43.55 231.39,43.55 v2(231.51,43.43) 231.7,43.24 R418.2 ; v2(239.7,44.57) 239.29,44.17 U51.B5
LCD_SMBDAT: length 216.5
  TOP w0.102: v2(133.27,102.3) 133.27,102.09 133.44,101.92 133.65,101.92 133.91,102.17 133.91,103.73 133.55,104.08 133.55,115.06 132.31,116.3 132.31,123.54 129.36,126.49 129.36,128.59 130.61,129.83 130.61,134.23 127.82,137.02 125.84,137.02 123.53,139.33 122.92,139.33 121.08,141.17 121.08,153.51 120.63,153.97 120.63,154.85 120.49,154.99 JEDP1.21
  IN4 w0.109: v2(214.93,64.88) 214.76,65.06 214.76,65.11 214.32,65.55 213.36,65.55 213.16,65.35 211.58,65.35 209.29,67.63 209.29,68.03 188.01,89.32 172.97,89.32 170.13,92.16 142.59,92.16 133.68,101.08 133.68,101.51 133.27,101.92 v2(133.27,102.3)
  BOTTOM w0.102: v2(214.93,64.88) 214.76,64.71 214.76,62.89 214.35,62.48 214.35,45.59 213.13,44.37 213.13,39.35 215.36,37.12 220.24,37.12 223.8,40.68 225.47,40.68 226.54,41.75 227.54,41.75 229.57,43.78 231.27,43.78 231.52,44.03 234.64,44.03 235.39,43.28 R420.2 235.96,43.24 236.64,43.92 U51.A4
LCD_TST: length 229.7
  TOP w0.102: v2(130.58,126.53) 132.21,128.16 132.21,129.47 133.2,130.46 133.2,143.74 v1(132.59,144.34) 132.05,144.88 132.05,148.7 130.66,150.1 129.36,150.1 128.78,150.69 128.78,152.24 128.34,152.67 128.34,153.26 127.69,153.91 126.01,153.91 124.99,154.93 JEDP1.12 124.99,156.86 124.45,157.4 124.17,157.4 123.75,157.83 v2(123.75,158.33) ; v2(93.33,157.35) 93.24,157.26 JLVDS1.12 ; v2(218.9,69.53) 218.9,69.24 221.24,66.89 231.85,66.89 v2(231.95,66.79)
  IN3 w0.127: v2(231.95,66.79) 232.89,65.85 232.89,64.07 232.03,63.21 v2(232.03,62.24) ; v2(93.33,157.35) 93.41,157.43 101.87,157.43 103.39,155.92 106.04,155.92 109.6,159.47 116.69,159.47 117.07,159.09 121.06,159.09 122.22,157.93 123.34,157.93 v2(123.75,158.33)
  BOTTOM w0.102: v2(232.03,62.24) 231.76,62.51 231.76,62.97 231.17,63.56 RP8.2 ; v2(218.9,69.53) 218.9,70.09 211.86,77.13 211.86,84.52 207.57,88.81 202.4,88.81 196.73,94.48 191.19,94.48 188.57,97.09 161.62,97.09 157.48,101.23 157.48,105.81 152.8,110.49 145.88,110.49 140.41,105.02 136.29,105.02 132.41,108.89 132.41,116.8 131.29,117.92 131.29,124.27 130.58,124.98 v2(130.58,126.53) ; v2(231.95,66.79) 232.32,67.16 U46.A36
LCD_VCC_TEST_EN: length 252.7
  IN4 w0.109: v2(231.72,69.58) 229.47,69.58 227.09,67.2 219.05,67.2 214.18,72.07 208.11,72.07 186.01,94.17 145.32,94.17 135.03,104.45 133.26,104.45 133.19,104.52 122.65,104.52 120.27,106.9 120.27,112.88 121.49,114.1 124.24,114.1 127.66,117.52 127.66,127.32 127.03,127.96 127.03,130.17 125.76,131.44 125.76,132.63 124.31,134.08 124.31,141.49 123.36,142.44 123.36,147.08 127.23,150.96 128.18,150.96 129.47,152.25 129.47,154.5 130.73,155.76 130.73,159.89 131.48,160.63 131.48,163.94 131.04,164.38 130.91,164.38 129.92,165.37 129.92,165.57 126.28,169.21 126.28,170.85 125.6,171.53 125.6,172.81 125.88,173.09 v2(125.96,173.09)
  BOTTOM w0.102: v2(125.96,173.09) 125.55,173.09 124.45,172 122.16,172 120.1,174.05 v1(109.12,174.05) 104.09,174.05 100.18,170.14 94.89,170.14 93.89,169.14 93.89,165.81 92.66,164.58 92.45,164.58 90.86,162.99 D6.2 ; U46.A40 232.4,69.16 231.98,69.58 v2(231.72,69.58)
LDDC_CLK_SW: length 13.6
  TOP w0.102: JLVDS1.18 90.24,156.84 90.1,156.97 90.1,157.4 89.64,157.86 89.18,157.86 89.08,157.76 v2(88.79,157.76)
  IN4 w0.102: v2(87.73,150.76) 87.74,150.76 87.92,150.95 88.31,151.34 88.31,157.28 v2(88.79,157.76)
  BOTTOM w0.102: v2(87.73,150.76) 88.56,149.93 U11.4 ; v2(88.79,157.76) 88.75,157.8 C1188.1 R159.2
LDDC_DATA_SW: length 7.1
  TOP w0.102: JLVDS1.19 89.74,156.9 89.88,157.04 89.88,157.31 89.55,157.63 89.28,157.63 89.09,157.44 v2(89.09,157.25)
  BOTTOM w0.102: v2(89.09,157.25) 89.41,156.93 89.41,156.02 R160.2 90.5,154.52 91.18,153.85 U11.12
LED_10_GRN#: length 3.4
  TOP w0.102: Q327.3 103.96,102.15 v1(104.77,102.15) 105.66,102.15 106.07,102.56 U32.41
LED_10_GRN#_Q: length 93.2
  TOP w0.102: Q327.1 v2(102.49,101.92)
  IN4 w0.109: v2(102.49,101.92) 101.93,102.47 101.93,108.48 102.72,109.27 102.72,113.11 102.6,113.22 102.6,120.78 103.02,121.2 103.02,132.82 98.08,137.76 98.08,138.48 95.22,141.34 95.22,155.74 93.97,156.99 93.97,158.71 92.51,160.18 90.38,160.18 88.44,162.11 87.41,162.11 85.46,160.16 83.64,160.16 v2(82.98,160.82)
  BOTTOM w0.102: v2(82.98,160.82) 82.98,160.62 82.22,159.86 76.63,159.86 76.15,160.34 68.81,160.34 v1(68.18,160.97) 67.79,161.35 R1170.1
LED_100_ORG#: length 16.4
  TOP w0.102: v1(103.54,97.31) Q325.4 103.9,98.6 v2(104.37,99.07) ; U32.18 115.73,102.06 116.09,101.7 116.09,101.12 v2(116.05,101.08)
  IN3 w0.127: v2(104.37,99.07) 104.54,99.25 114.72,99.25 116.05,100.58 v2(116.05,101.08)
LED_100_ORG#_Q: length 98.1
  TOP w0.102: v2(102.82,99.07) 102.35,98.6 Q325.3
  IN4 w0.109: v2(83.39,161.3) 83.46,161.23 83.46,160.82 83.79,160.49 85.49,160.49 87.32,162.32 88.53,162.32 90.46,160.39 92.59,160.39 94.18,158.8 94.18,157.08 95.45,155.81 95.45,141.41 98.29,138.57 98.29,137.85 103.4,132.74 103.4,125.64 103.89,125.16 103.89,121.61 102.81,120.54 102.81,113.31 102.93,113.19 102.93,109.18 102.14,108.39 102.14,102.9 102.94,102.1 102.94,99.2 v2(102.82,99.07)
  BOTTOM w0.102: R1167.1 68.3,160.47 68.63,160.13 75.88,160.13 v1(76.13,159.89) 76.36,159.65 82.42,159.65 83.39,160.62 v2(83.39,161.3)
LED_SATA_DIAG_OUT#: length 266.5
  TOP w0.102: v2(34.24,85.61) 34.61,85.98 D62.1
  IN3 w0.127: v2(244.85,69.53) 243.79,70.6 243.79,74.23 243.91,74.36 243.91,76.29 242.49,77.71 239.72,77.71 239.46,77.97 229.34,77.97 228.09,76.72 227.05,76.72 223.07,72.75 221.38,72.75 218.41,69.78 218.41,66.31 206.13,54.03 201.28,54.03 192.03,44.78 185.64,44.78 184.26,43.4 177.28,43.4 176.57,42.69 170.4,42.69 168.94,41.22 168.52,41.22 168.2,40.91 166.66,40.91 165.82,40.07 147.47,40.07 145.44,42.1 123.77,42.1 122.22,43.65 112.01,43.65 110.51,45.15 101.32,45.15 100.07,46.39 98.44,46.39 97.76,47.08 94.68,47.08 94.5,46.9 91.77,46.9 90.36,48.31 80.45,48.31 80.17,48.03 76.53,48.03 76.1,48.46 69.49,48.46 65.3,52.65 65.3,52.69 65.05,52.95 63.76,52.95 63.24,52.43 55.21,52.43 48.31,59.33 48.31,66.29 47.88,66.73 47.88,70.13 44.87,73.14 44.87,76.54 38.67,82.74 37.5,82.74 36.23,84.01 35.25,84.01 34.24,85.02 v2(34.24,85.61)
  BOTTOM w0.102: v1(244.97,68.89) 244.85,69 v2(244.85,69.53) 243.98,68.66 U46.A10
LED_WWAN_OUT#: length 7.8
  BOTTOM w0.102: 259.17,45.4 R719.1 ; 259.17,45.4 JMINI1.42 ; 259.17,45.4 259.49,45.09 259.49,44.01 Q77.3 257.64,41.62 v1(257.15,41.12)
LG_3V: length 10.3
  IN4 w1.016: 38.71,40.7 39.22,41.21 39.22,43.12 34.9,47.44 34.9,48.96
  vias: v1(33.92,50.64) v3(34.09,49.9) v3(34.44,50.51) v3(37.77,39.33) v3(38.4,39.36)
LG_5V: length 2.6
  TOP w0.102: v3(38.07,36.64) 38.07,36.89 v1(37.84,37.12)
  IN1 w1.016: 38.38,35.23 38.07,34.93 38.07,33.83 37.69,33.45
  vias: v2(37.69,32.58) v2(37.73,31.99) v3(38.07,36.01)
LG_+1.05VSP: length 7.6
  TOP w0.102: v1(41.73,63.34) 42.14,62.93 v3(42.14,62.45)
  IN3 w1.016: 42.9,55.18 42.9,56.83 42.14,57.6 42.14,61.41
  vias: v3(41.5,62.45) v3(42.98,54.09) v3(42.98,53.45)
LGATE1: length 15.9
  IN1 w1.016: 168.12,158.69 168.5,158.31 171.3,158.31 171.93,158.94 ; 165.84,158.94 165.33,158.94 160.65,163.61 158.09,163.61 157.3,164.4
  BOTTOM w0.102: v3(166.98,158.94) v1(166.09,158.94)
  vias: v3(156.49,165.82) v3(156.49,165.19) v3(166.98,158.31) v3(173.15,158.94) v3(173.15,158.31)
LGATE2: length 26.7
  TOP w0.102: v3(179.5,158.28) 179.5,157.58 v1(179.88,157.2)
  IN1 w1.016: 159.99,165.67 160.04,165.62 161.95,165.62 166.65,160.92 178.46,160.92 179.42,159.96 ; 184.63,158.56 184.35,158.28 181.1,158.28 181.08,158.31
  vias: v3(158.16,166.08) v3(158.8,166.13) v3(179.5,158.92) v3(185.6,158.92) v3(185.6,158.28)
LGATE3: length 17.7
  TOP w0.102: v3(193.52,158.69) v1(192.15,158.69)
  IN3 w1.016: 203.22,169.3 203.22,167.56 202.92,167.26 202.92,166.42 203.13,166.21 203.13,164.01 202.82,163.69 202.82,160.66 200.59,158.43 200.43,158.43 200.4,158.46
  IN4 w1.016: 194.66,158.18 194.79,158.05 198.6,158.05
  vias: v3(193.52,158.05) v3(199.52,158.71) v3(199.52,158.08) v3(202.83,170.89) v3(202.83,170.23)
LID_CL#: length 283.2
  TOP w0.102: v2(11.58,78.04) 11.53,77.99 11.53,76.59 12.22,75.9 JIO1.91 ; v2(29.36,87.16) 30.02,87.82 U58.2
  IN3 w0.127: v2(223.85,71.03) 223.85,71.13 222.83,70.12 222.83,68.82 206.89,52.88 201.75,52.88 192.42,43.55 186.03,43.55 184.73,42.25 177.76,42.25 177.05,41.54 170.87,41.54 169.41,40.08 169.07,40.08 168.71,39.71 168.12,39.71 167.81,39.4 167.81,39.4 166.37,37.96 147.96,37.96 144.96,40.96 123.15,40.96 121.6,42.51 102.34,42.51 99.89,44.96 79.92,44.96 79.49,44.53 76.39,44.53 75.96,44.96 72.83,44.96 72.17,45.62 70.35,45.62 69.92,46.05 68.02,46.05 66.3,47.78 64.28,47.78 63.62,48.44 61.71,48.44 59.89,50.27 54.46,50.27 46.25,58.47 46.25,60.82 44.23,62.84 44.23,64.32 43.6,64.95 43.6,70.56 42.39,71.77 40.92,71.77 39.51,73.18 39.51,74.58 38.3,75.79 38.3,77.81 35.17,80.94 33.67,80.94 31.46,83.14 31.46,86.01 30.31,87.16 v2(29.36,87.16)
  BOTTOM w0.102: v2(29.36,87.16) v1(28.87,86.67) 28.37,86.17 27.74,86.17 25.32,83.75 25.32,80.8 24.6,80.07 21.06,80.07 18.39,77.41 15.21,77.41 14.93,77.69 13.51,77.69 13.16,78.04 v2(11.58,78.04) ; R807.1 233.27,79.08 232.71,79.64 231.88,79.64 229.54,77.31 228.8,77.31 223.85,72.35 v2(223.85,71.03)
LID_CL_SIO#: length 8.5
  TOP w0.102: v2(235.05,76.67) 235.05,73.59 v2(235.3,73.33)
  BOTTOM w0.102: U46.B54 235.2,73.98 235.2,73.44 v2(235.3,73.33) ; v2(235.05,76.67) 234.39,77.33 C716.1 R807.2 R805.2 v1(231.04,77.33)
LOM_ACTLED_YEL#: length 12
  TOP w0.102: v2(107.9,94.25) 107.9,94.07 108.28,93.69 U31.26 ; U32.15 114.1,100.54 114.27,100.37 v2(114.27,100.22)
  IN1 w0.109: v2(107.9,94.25) 111.43,97.78 112.01,97.78 114.27,100.04 v2(114.27,100.22)
  BOTTOM w0.102: v2(107.9,94.25) 108.1,94.25 v1(108.58,94.73)
LOM_SPD10LED_GRN#: length 12.6
  TOP w0.102: U32.42 106.39,102.06 v2(105.97,101.64) ; U31.25 108.43,94.41 108.43,94.63 108,95.06 U15.2 105.52,95.06 105.18,95.4 v2(105.18,96.53)
  IN1 w0.109: v2(105.18,96.53) 105.18,100.85 v2(105.97,101.64)
  BOTTOM w0.102: v1(106.89,101.49) 106.12,101.49 v2(105.97,101.64)
LOM_SPD100LED_ORG#: length 16.3
  TOP w0.102: v2(107.52,93.79) 106.9,94.41 U15.1 106.46,94.26 107.44,93.29 U31.27 ; U32.16 114.6,100.48 v2(114.86,100.22)
  IN4 w0.109: v2(114.86,100.22) 114.86,100.19 112.8,98.13 112.05,98.13 108.41,94.49 108.41,94.02 108.18,93.79 v2(107.52,93.79)
  BOTTOM w0.102: v2(107.52,93.79) v1(106.68,93.79)
LPC_LAD0: length 396.6
  TOP w0.102: v2(236.8,62.27) 237.29,62.75 238.83,62.75 239.09,63.01 239.09,63.34 239.34,63.59 240.57,63.59 240.95,63.21 241.94,63.21 242.57,62.58 242.57,61.99 244.25,60.32 244.25,58.06 244.63,57.68 244.63,57.24 244.9,56.97 244.9,53.06 245.64,52.31 v2(245.67,52.31)
  IN1 w0.109: v2(75.87,57.58) 75.25,56.96 75.25,55.26 75.25,55.26 75.25,54.75 75.61,54.38 75.71,54.38 78.28,51.81 78.28,50.53 79.28,49.53 83.62,49.53 84.87,48.29 85.92,48.29 v2(86.57,47.64)
  IN3 w0.127: v2(7.12,154.33) 7.59,153.86 7.59,148.96 6.84,148.21 5.52,148.21 2.68,145.37 2.68,141.14 3.81,140.01 3.81,136.6 14.59,125.82 14.59,124.59 16.44,122.73 16.44,120.48 19.26,117.66 19.26,114.81 31.82,102.26 31.82,99.29 34.42,96.7 34.42,90.39 33.29,89.26 33.29,85.64 34.08,84.86 35.15,83.78 36.06,83.78 44.64,75.21 44.64,73.05 47.65,70.04 47.65,66.63 48.08,66.2 48.08,59.23 55.22,52.1 65.21,52.1 69.43,47.88 70.68,47.88 71.09,47.47 76.37,47.47 76.58,47.26 80.05,47.26 80.51,47.71 84.84,47.71 85.48,47.08 86.01,47.08 v2(86.57,47.64)
  IN4 w0.109: v2(253.87,59.96) 253.87,59.37 250.95,56.45 250.95,55.56 249.91,54.52 249.35,54.52 248.23,53.4 247.12,53.4 246.02,52.31 v2(245.67,52.31) 244.9,51.55 240.08,51.55 239.06,52.57 232.84,52.57 230.35,50.08 207.54,50.08 206.96,50.66 199.21,50.66 195.27,46.72 159.61,46.72 158.8,45.91 113.71,45.91 111.17,48.46 87.39,48.46 v2(86.57,47.64)
  BOTTOM w0.076: UH1.A20 75.84,58.38 75.84,57.6 v2(75.87,57.58)
  BOTTOM w0.102: U46.A27 236.98,62.44 v2(236.8,62.27) ; JMINI4.16 15.64,150.78 14.01,152.41 8.61,152.41 7.84,153.19 7.84,153.62 v2(7.12,154.33) ; U51.A30 245.8,52.18 v2(245.67,52.31) ; v2(253.87,59.96) 253.87,61.13 251.05,63.95 U39.26
LPC_LAD1: length 399.5
  TOP w0.102: v2(238.07,62.27) 238.64,62.27 239,62.62 239.55,62.62 240.13,63.21 240.54,63.21 240.74,63.01 241.86,63.01 242.37,62.5 242.37,61.91 244.04,60.23 244.04,57.98 244.42,57.6 244.42,57.16 244.69,56.89 244.69,52.98 245.11,52.55 245.11,50.88 245.87,50.13 v2(245.87,50.1)
  IN1 w0.109: v2(88.59,47.64) 88.59,48.36 87.56,49.39 85.16,49.39 84.18,50.37 80.51,50.37 79.85,51.03 79.85,51.44 77.43,53.86 77.43,57.07 76.91,57.6 v2(76.63,57.6)
  IN3 w0.127: v2(88.59,47.64) 87.35,46.39 85.15,46.39 84.6,46.94 80.7,46.94 80.33,46.57 76.19,46.57 75.97,46.79 70.8,46.79 70.4,47.19 69.15,47.19 67.19,49.15 65.75,50.59 64.93,51.41 54.93,51.41 52.6,53.74 52.6,53.74 47.4,58.95 47.4,61.29 45.4,63.28 45.4,65.45 46.7,66.74 46.7,70.02 42.28,74.43 42.28,75.47 40.06,77.69 40.06,78.7 36.61,82.15 35.63,82.15 32.6,85.18 32.6,89.55 33.02,89.96 33.02,97.13 31.14,99.01 31.14,101.97 28.14,104.97 27.39,105.72 23.1,110.01 22.2,110.9 19.32,113.79 18.58,114.53 18.58,117.37 16.27,119.68 15.97,119.98 15.76,120.19 15.76,122.37 12.4,125.72 12.4,127.04 3.51,135.93 3.12,136.32 3.12,139.73 1.99,140.86 1.99,145.65 3.97,147.63 3.97,151 6.19,153.21 6.67,153.21 v2(7.1,153.64)
  IN4 w0.109: v2(253.82,57.37) 253.23,57.37 252.76,56.9 252.76,55.95 250.61,53.8 250.61,51.66 249.84,50.89 246.66,50.89 v2(245.87,50.1) 245.05,50.91 239.52,50.91 238.5,51.93 233.22,51.93 230.82,49.53 199.05,49.53 195.8,46.28 160.14,46.28 159.33,45.47 112.35,45.47 110.07,47.75 92.56,47.75 92.02,47.22 88.8,47.22 88.59,47.42 v2(88.59,47.64)
  BOTTOM w0.089: UH1.C20 76.29,59.35 76.62,59.01 76.62,58.75 76.39,58.52 76.39,58.25
  BOTTOM w0.102: U39.23 251.07,62 253.82,59.25 v2(253.82,57.37) ; v2(7.1,153.64) 8.53,152.21 13.64,152.21 14.84,151.01 JMINI4.14 ; 76.39,58.25 76.63,58.01 v2(76.63,57.6) ; U46.A26 237.48,62.87 v2(238.07,62.27) ; v2(245.87,50.1) 246.05,50.28 U51.B32
LPC_LAD2: length 395.4
  TOP w0.102: v2(238.23,65.47) 238.28,65.47 238.66,65.85 238.66,66.21 238.91,66.46 239.59,66.46 239.7,66.36 240.53,66.36 240.89,65.99 240.89,65.28 241.34,64.83 241.63,64.83 241.83,64.63 242.56,64.63 243.91,63.28 244.34,63.28 245.46,62.16 245.46,61.35 246.53,60.29 246.53,55.19 247.52,54.2 247.52,53.06 v2(247.24,52.78)
  IN1 w0.109: v2(75.87,56.41) 76.29,55.99 76.29,54.41 79.43,51.26 79.43,50.86 80.34,49.95 83.8,49.95 84.78,48.97 86.58,48.97 87.57,47.98 87.57,47.36 87.7,47.22 88.78,47.22 v2(89.18,47.63)
  IN3 w0.127: v2(89.18,47.63) 87.72,46.17 85.05,46.17 84.51,46.71 80.8,46.71 80.43,46.34 76.1,46.34 75.88,46.56 70.71,46.56 70.3,46.97 69.05,46.97 67.03,48.98 65.78,50.23 65.59,50.43 64.84,51.18 54.84,51.18 47.17,58.85 47.17,61.2 45.17,63.19 45.17,65.54 46.47,66.84 46.47,69.92 44.24,72.15 42.05,74.34 42.05,75.37 32.38,85.05 32.38,89.64 32.79,90.06 32.79,97.03 30.91,98.91 30.91,101.88 23.14,109.64 23.1,109.68 22.04,110.74 19.15,113.63 18.35,114.43 18.35,117.28 16.11,119.52 15.81,119.82 15.53,120.1 15.53,122.27 12.17,125.63 12.17,126.95 11.52,127.59 2.89,136.22 2.89,139.64 1.77,140.76 1.77,145.75 3.74,147.72 3.74,151.09 6.28,153.63 v2(6.49,153.63)
  IN4 w0.109: v2(89.18,47.63) 89.8,48.25 109.87,48.25 112.43,45.68 158.89,45.68 159.71,46.5 195.37,46.5 198.61,49.74 230.32,49.74 232.93,52.35 238.87,52.35 239.89,51.34 245.8,51.34 v2(247.24,52.78) 249,52.78 251.87,55.66 251.87,56.79 v2(253.08,58)
  BOTTOM w0.102: v2(6.49,153.63) 6.89,153.24 7.22,153.24 8.45,152.01 12.72,152.01 14.04,150.69 JMINI4.12 ; v2(75.87,56.41) 75.09,57.19 UH1.A18 ; U51.A31 246.3,52.07 247.01,52.78 v2(247.24,52.78) ; U39.20 252.33,60.05 253.14,59.25 253.14,58.06 v2(253.08,58) ; 238.23,64.81 238.25,64.84 238.25,65.42 238.2,65.47 v2(238.23,65.47)
LPC_LAD3: length 395.1
  TOP w0.102: v2(246.98,50.1) 247.36,50.49 247.36,52.3 247.81,52.75 247.81,54.2 246.73,55.27 246.73,60.37 245.67,61.44 245.67,62.24 244.42,63.49 243.99,63.49 242.62,64.86 241.89,64.86 241.71,65.04 241.43,65.04 241.1,65.37 241.1,66.08 240.61,66.56 239.78,66.56 239.68,66.67 238.79,66.67 238.2,66.08 238.22,66.06 v2(238.23,66.06)
  IN1 w0.109: v2(75.87,57) 75.46,56.59 75.46,55.36 75.46,55.36 75.46,54.83 75.7,54.59 75.8,54.59 79.22,51.17 79.22,50.77 80.25,49.74 83.71,49.74 84.69,48.76 86.04,48.76 v2(87.16,47.64)
  IN3 w0.127: v2(87.16,47.64) 86.37,46.85 85.38,46.85 84.83,47.4 80.51,47.4 80.14,47.03 76.49,47.03 76.27,47.24 70.99,47.24 70.59,47.65 69.34,47.65 65.12,51.87 55.12,51.87 47.85,59.14 47.85,66.1 47.42,66.54 47.42,69.94 44.41,72.95 44.41,75.11 35.97,83.55 35.06,83.55 33.91,84.7 33.06,85.55 33.06,89.36 34.19,90.49 34.19,96.61 31.59,99.2 31.59,102.16 19.04,114.72 19.04,117.56 16.77,119.82 16.22,120.38 16.22,122.64 14.36,124.5 14.36,125.73 3.58,136.51 3.58,139.92 2.45,141.05 2.45,145.46 4.46,147.47 4.46,150.83 5.97,152.35 6.8,152.35 v2(7.13,152.68)
  IN4 w0.109: v2(87.16,47.64) 88.01,46.79 92.29,46.79 92.81,47.31 109.89,47.31 112.15,45.05 159.53,45.05 160.34,45.86 171.48,45.86 172.41,44.93 176.71,44.93 176.72,44.94 195.06,44.94 199.22,49.11 232.93,49.11 233.56,48.48 235.99,48.48 236.11,48.36 238.2,48.36 238.41,48.57 239.32,48.57 239.58,48.83 245.5,48.83 246.77,50.1 v2(246.98,50.1) 247.34,50.47 250.01,50.47 251.03,51.49 251.03,53.63 253.87,56.46 v2(254.01,56.46)
  BOTTOM w0.076: UH1.C18 75.09,58.88 75.39,58.59 75.39,57.48 v2(75.87,57)
  BOTTOM w0.102: U39.17 251.27,58.1 251.49,57.87 251.82,57.87 253.23,56.46 v2(254.01,56.46) ; v2(238.23,66.06) 238.25,66.06 238.73,65.58 U46.B25 ; v2(246.98,50.1) 246.55,50.53 U51.B33 ; JMINI4.10 13.24,150.73 12.17,151.8 8.01,151.8 v2(7.13,152.68)
LPC_LDRQ1#: length 183.6
  IN1 w0.109: v2(197.14,60.77) 197.27,60.64 199.25,60.64 199.72,61.11 201.63,61.11 202.05,61.53 209.54,61.53 210.55,62.54 218.21,62.54 218.67,63.01 222.35,63.01 223.7,64.35 230.56,64.35 231.91,63.01 234.43,63.01 234.83,63.41 236.98,63.41 237.67,62.73 239.19,62.73 239.52,63.06 v2(239.52,63.18)
  IN3 w0.127: v2(76.33,61.28) 76.48,61.28 78.43,59.32 82.27,59.32 83.18,60.24 83.18,60.52 83.64,60.97 86.1,60.97 86.92,60.16 91.17,60.16 92.1,59.23 92.99,59.23 93.67,58.55 94.91,58.55 96.73,56.73 100.95,56.73 103.87,53.81 118.99,53.81 122,50.8 123.56,50.8 125.2,49.16 146.76,49.16 148.21,47.71 149.28,47.71 150.81,46.19 163.56,46.19 167.49,50.11 188.68,50.11 190.95,52.39 191.77,52.39 195.53,56.15 195.53,59.16 v2(197.14,60.77)
  BOTTOM w0.102: v1(239.84,62.76) 239.52,63.08 v2(239.52,63.18) 239.48,63.23 U46.A22 ; UH1.G20 76.15,61.28 v2(76.33,61.28)
LPC_LFRAME#: length 392.7
  TOP w0.102: v2(245.64,49.56) 245.18,49.09 244.76,49.09 244.41,49.44 244.41,50.26 243.83,50.85 243.83,52.63 244.19,52.99 244.19,56.44 243.53,57.1 243.53,58.48 243.84,58.79 243.84,60.15 243.23,60.76 242.16,61.82 242.16,62.41 241.77,62.8 v2(240.36,62.8)
  IN1 w0.109: v2(76.58,57.01) 76.71,57.01 77.2,56.52 77.2,53.79 79.64,51.35 79.64,50.95 80.42,50.16 83.88,50.16 84.87,49.18 86.96,49.18 87.98,48.16 v2(87.98,47.64)
  IN3 w0.127: v2(87.98,47.64) 86.97,46.62 85.24,46.62 84.69,47.17 80.61,47.17 80.24,46.8 76.29,46.8 76.07,47.02 70.9,47.02 70.49,47.42 69.24,47.42 67.36,49.31 65.02,51.64 55.03,51.64 52.6,54.07 47.62,59.04 47.62,61.39 46.3,62.71 45.63,63.38 45.63,65.35 46.92,66.65 46.92,70.11 42.51,74.53 42.51,76.69 38.93,80.27 35.87,83.33 34.96,83.33 33.75,84.53 32.83,85.45 32.83,89.45 33.96,90.58 33.96,96.51 31.37,99.1 31.37,102.07 27.55,105.88 23.26,110.17 22.36,111.07 18.81,114.62 18.81,117.47 16.43,119.84 15.99,120.29 15.99,122.46 14.13,124.32 14.13,125.63 3.35,136.41 3.35,139.83 2.22,140.95 2.22,145.56 4.2,147.54 4.2,150.9 6.07,152.77 v2(6.55,152.77)
  IN4 w0.109: v2(253.39,56.95) 252.97,56.53 252.97,55.86 250.82,53.71 250.82,51.57 249.93,50.68 246.75,50.68 246.31,50.24 246.31,49.95 245.92,49.56 v2(245.64,49.56) 245.15,49.07 239.52,49.07 239.28,48.83 238.36,48.83 238.11,48.57 236.2,48.57 236.08,48.69 233.65,48.69 233.02,49.32 199.14,49.32 195.04,45.22 172.42,45.22 171.57,46.07 160.26,46.07 159.44,45.26 112.23,45.26 109.97,47.52 92.72,47.52 92.2,47 88.62,47 v2(87.98,47.64)
  BOTTOM w0.076: v2(76.58,57.01) 76.25,57.34 76.25,58 76.19,58.07 76.19,58.75 UH1.B21
  BOTTOM w0.102: v2(245.64,49.56) 245.46,49.73 245.46,50.28 245.55,50.37 U51.B31 ; U46.A21 239.98,63.26 240.36,62.88 v2(240.36,62.8) ; v2(6.55,152.77) 6.55,152.68 7.63,151.6 11.52,151.6 12.44,150.68 JMINI4.8 ; v2(253.39,56.95) 253.39,57.74 253.54,57.89 253.54,59.2 251.39,61.35 U39.22
LVDS_A0+: length 36.7
  BOTTOM w0.102: U11.16 93.18,153.93 93.06,154.04 93.06,154.39 93.92,155.25 94.27,155.25 94.36,155.16 94.55,155.16 94.64,155.25 94.91,155.25 95.18,154.98 95.18,154.85 95.42,154.6 95.55,154.6 96.1,154.05 96.47,154.05 97.66,152.86 99.25,152.86 101.2,150.91 v3(112.5,150.91) 115.92,150.91 116.34,151.33 120.74,151.33 120.85,151.22 120.85,150.94 120.93,150.86 121.11,150.86 121.18,150.94 121.18,151.26 121.26,151.33 121.35,151.33 123.39,149.29 123.39,148.65 123.33,148.59 U23.41
LVDS_A0-: length 36.8
  BOTTOM w0.102: U23.42 123.73,148.57 123.66,148.64 123.66,149.4 121.46,151.6 v3(119.15,151.6) 116.23,151.6 115.81,151.18 101.31,151.18 99.36,153.12 97.77,153.12 96.58,154.32 96.21,154.32 95.66,154.87 95.53,154.87 95.45,154.96 95.45,155.09 95.02,155.51 93.81,155.51 92.8,154.5 92.8,154.02 92.67,153.9 U11.15
LVDS_A1+: length 30.3
  BOTTOM w0.102: U11.20 95.62,151.93 95.73,152.05 97.31,152.05 97.4,151.96 97.76,151.96 97.85,152.05 98.39,152.05 98.64,151.79 98.64,151.66 98.88,151.42 99.01,151.42 100.37,150.06 v3(105.79,150.06) 120.69,150.06 120.78,149.97 120.78,149.9 120.85,149.82 121.08,149.82 121.18,149.92 121.18,149.96 121.28,150.06 121.55,150.06 122.66,148.96 122.66,148.66 122.53,148.52 U23.39
LVDS_A1-: length 30.2
  BOTTOM w0.102: U23.40 122.93,149.07 121.66,150.33 v3(117.4,150.33) 100.48,150.33 98.5,152.32 95.73,152.32 95.62,152.43 U11.19
LVDS_A2+: length 28.6
  BOTTOM w0.102: U23.37 121.73,148.59 121.79,148.66 121.79,148.76 121.69,148.86 121.41,148.86 121.33,148.78 121.33,148.7 121.23,148.6 121,148.6 120.93,148.68 120.93,148.78 120.85,148.86 120.22,148.86 120.12,148.76 v3(119.24,148.76) 99.8,148.76 99.11,149.44 98.98,149.44 98.74,149.68 98.74,149.81 98.5,150.05 98.28,150.05 98.18,149.95 97.82,149.95 97.72,150.05 95.78,150.05 95.67,149.93 U11.24
LVDS_A2-: length 28.5
  BOTTOM w0.102: U11.23 95.67,150.43 95.78,150.32 98.61,150.32 99.91,149.02 v3(114.21,149.02) 120,149.02 120.11,149.12 121.8,149.12 122.06,148.87 122.06,148.66 122.13,148.59 U23.38
LVDS_ACLK+: length 29.5
  BOTTOM w0.102: U23.35 120.43,146.9 120.37,146.96 119.44,146.96 118.41,147.99 v3(117.08,147.99) 98.8,147.99 98.33,147.52 95.69,147.52 94.42,146.25 94.04,146.25 93.79,146.5 93.79,146.8 93.67,146.91 U11.29
LVDS_ACLK-: length 29.5
  BOTTOM w0.102: U23.36 120.43,147.3 120.37,147.23 120.14,147.23 120.06,147.31 120.06,147.38 119.99,147.46 119.81,147.46 119.76,147.41 119.76,147.33 119.66,147.23 119.55,147.23 118.52,148.26 v3(103.52,148.26) 98.69,148.26 98.22,147.79 96.38,147.79 96.31,147.87 95.95,147.87 95.87,147.79 95.58,147.79 95.26,147.47 95.13,147.47 94.89,147.23 94.89,147.1 94.31,146.52 94.15,146.52 94.06,146.61 94.06,146.8 94.18,146.91 U11.28
LVDS_B0+: length 47.5
  BOTTOM w0.102: U23.31 120.41,145.3 120.34,145.36 119.8,145.36 117.92,147.24 v3(100.63,147.24) 99.16,147.24 98.69,146.77 96.01,146.77 94.72,145.49 92.96,145.49 92.86,145.39 92.86,144.89 92.58,144.6 92.1,144.6 91.82,144.89 91.82,146.29 91.69,146.42 91.44,146.42 91.31,146.29 91.31,144.53 91.03,144.25 90.55,144.25 90.27,144.53 90.27,145.73 90.14,145.86 89.89,145.86 89.76,145.73 89.76,144.58 89.48,144.3 89,144.3 88.72,144.58 88.72,145.56 88.53,145.75 88.35,145.75 88.21,145.61 87.76,145.61 87.46,145.9 87.46,146.45 87.82,146.81 87.82,147.06 86.6,148.28 86.16,148.28 86.04,148.16 U13.16
LVDS_B0-: length 47.5
  BOTTOM w0.102: U23.32 120.41,145.7 120.34,145.63 119.91,145.63 118.03,147.51 v3(106.3,147.51) 99.05,147.51 98.58,147.04 95.9,147.04 94.61,145.76 92.85,145.76 92.59,145.5 92.59,145 92.47,144.87 92.21,144.87 92.09,145 92.09,146.4 91.8,146.69 91.33,146.69 91.04,146.4 91.04,144.64 90.92,144.51 90.66,144.51 90.54,144.64 90.54,145.84 90.25,146.13 89.78,146.13 89.49,145.84 89.49,144.69 89.37,144.56 89.11,144.56 88.99,144.69 88.99,145.67 88.64,146.01 88.24,146.01 88.1,145.87 87.87,145.87 87.73,146.01 87.73,146.34 88.09,146.7 88.09,147.17 86.71,148.55 86.16,148.55 86.04,148.66 U13.15
LVDS_B1+: length 46.4
  BOTTOM w0.102: U23.29 120.51,144.5 120.45,144.56 119.51,144.56 117.59,146.48 100.3,146.48 99.85,146.03 99.39,146.03 99.28,145.92 99.28,145.41 99.03,145.15 98.5,145.15 98.24,145.41 98.24,145.92 98.14,146.03 97.84,146.03 97.73,145.92 97.73,145.41 97.48,145.15 96.95,145.15 96.69,145.41 96.69,145.92 96.59,146.03 96.32,146.03 95.03,144.73 v3(94.32,144.73) 93.79,144.73 92.79,143.73 92.79,143.59 93.39,142.98 93.39,142.62 93.02,142.25 92.65,142.25 92.05,142.85 91.91,142.85 91.3,142.24 88.33,142.24 87.5,143.07 87.5,143.27 85.84,144.93 84.55,144.93 84.14,145.34 84.14,145.55 84.02,145.67 U13.20
LVDS_B1-: length 46.4
  BOTTOM w0.102: U23.30 120.5,144.9 120.43,144.83 120.28,144.83 120.22,144.89 120.22,145 120.14,145.07 119.99,145.07 119.94,145.02 119.94,144.91 119.86,144.83 119.62,144.83 117.7,146.75 v3(111.17,146.75) 100.19,146.75 99.74,146.29 99.27,146.29 99.02,146.03 99.02,145.52 98.92,145.42 98.61,145.42 98.51,145.52 98.51,146.03 98.25,146.29 97.73,146.29 97.47,146.03 97.47,145.52 97.37,145.42 97.06,145.42 96.96,145.52 96.96,146.03 96.7,146.29 96.21,146.29 94.92,145 93.68,145 92.52,143.84 92.52,143.48 93.12,142.87 93.12,142.73 92.91,142.51 92.76,142.51 92.16,143.12 91.8,143.12 91.19,142.51 88.44,142.51 87.77,143.18 87.77,143.38 86.54,144.61 86.54,144.71 86.28,144.98 86.17,144.98 85.95,145.2 85.49,145.2 85.41,145.28 85.06,145.28 84.98,145.2 84.66,145.2 84.41,145.45 84.41,145.55 84.52,145.67 U13.19
LVDS_B2+: length 47.5
  BOTTOM w0.102: U13.24 82.02,145.67 82.14,145.55 82.14,143.94 84.47,141.61 87.37,141.61 87.49,141.48 93.53,141.48 96.44,144.39 100.04,144.39 101.37,145.72 v3(104.14,145.72) 114.08,145.72 114.18,145.62 114.18,145.09 114.46,144.81 114.94,144.81 115.22,145.09 115.22,145.62 115.32,145.72 115.63,145.72 115.73,145.62 115.73,145.17 116.01,144.88 116.49,144.88 116.77,145.17 116.77,145.59 116.9,145.72 117.17,145.72 117.3,145.59 117.3,145.43 117.52,145.2 117.81,145.2 119.24,143.76 120.32,143.76 120.39,143.7 U23.27
LVDS_B2-: length 47.5
  BOTTOM w0.102: U23.28 120.39,144.1 120.32,144.03 120.17,144.03 120.09,144.11 120.09,144.23 120.01,144.31 119.86,144.31 119.79,144.23 119.79,144.13 119.68,144.03 119.35,144.03 117.92,145.47 117.63,145.47 117.56,145.54 117.56,145.7 117.28,145.99 116.79,145.99 116.5,145.7 116.5,145.28 116.38,145.15 116.12,145.15 116,145.28 116,145.73 115.74,145.99 115.21,145.99 114.95,145.73 114.95,145.2 114.83,145.07 114.57,145.07 114.45,145.2 114.45,145.73 114.19,145.99 101.26,145.99 99.93,144.65 v3(98.39,144.65) 96.33,144.65 93.42,141.75 87.6,141.75 87.48,141.87 84.58,141.87 83.69,142.76 83.69,142.86 83.43,143.13 83.33,143.13 83.11,143.34 83.11,143.44 82.84,143.71 82.74,143.71 82.41,144.05 82.41,145.55 82.52,145.67 82.52,146.26
LVDS_BCLK+: length 53.9
  BOTTOM w0.102: U23.25 120.42,142.9 120.34,142.98 118.79,142.98 117.72,144.04 v3(114.81,144.04) 110.68,144.04 109.76,144.96 101.71,144.96 96.43,139.68 88.28,139.68 87.43,138.82 82.93,138.82 81.27,140.49 81.27,141.4 80.1,142.57 80.1,143.85 77.8,146.15 77.8,147.16 78.05,147.41 78.79,147.41 79.04,147.66 U13.29
LVDS_BCLK-: length 53.9
  BOTTOM w0.102: U13.28 78.92,147.16 78.84,147.08 78.84,146.75 78.74,146.65 78.56,146.65 78.48,146.72 78.48,147.08 78.41,147.16 78.18,147.16 78.07,147.04 78.07,146.26 80.36,143.96 80.36,142.68 81.53,141.51 81.53,140.6 83.04,139.09 87.32,139.09 88.17,139.94 96.32,139.94 101.6,145.23 v3(107.56,145.23) 109.88,145.23 110.79,144.31 115.85,144.31 115.93,144.39 116.29,144.39 116.36,144.31 116.67,144.31 116.74,144.39 117.1,144.39 117.18,144.31 117.83,144.31 118.9,143.24 120.36,143.24 120.42,143.3 U23.26
LX_CHG: length 9.1
  IN2 w1.016: 215.37,26.99 219.58,26.99 221.23,28.64
  BOTTOM w0.254: 224.64,29.78 224.87,29.55 PU700.19
  BOTTOM w0.508: PC734.1 223.3,29.78 224.64,29.78
  vias: v1(212.69,28.75) v3(214.35,25.97) v3(214.98,25.97) v3(222.66,28.79) v3(223.29,28.79)
M_CLK_DDR0: length 62
  TOP w0.102: v2(178.06,107.31) JCPU1.V4
  IN1 w0.089: 178.63,102.35 178.63,102.37 178.65,102.39 178.65,102.63 179.46,103.44 179.46,105.54 179.63,105.71 179.63,105.89 179.46,106.05 179.46,106.57 179.3,106.73 178.73,106.73 178.48,106.97 178.48,107.58 178.34,107.72 178.15,107.72 178.06,107.63 v2(178.06,107.31)
  IN1 w0.109: 178.63,102.35 178.63,100.19 167.08,88.64 167.08,87.99 159.54,80.46 159.23,80.46 158.99,80.21 158.99,79.58 159.26,79.31 159.26,79.13 158.89,78.76 158.67,78.76 158.64,78.79 158.33,78.79 157.91,78.37 157.91,77.44 158.16,77.18 158.16,76.07 156.88,74.79 156.88,74.44 157.02,74.31 157.02,73.95 156.95,73.88 156.6,73.88 156.5,73.99 156.5,74.2 156.26,74.45 155.87,74.45 155.49,74.07 155.49,73.22 155.73,72.99 156.92,72.99 157.02,72.89 157.02,71.56 156.85,71.39 156.85,71.03 157.02,70.86 157.02,69.73 156.87,69.59 156.67,69.59 156.56,69.69 156.56,69.89 v2(156.6,69.93)
  BOTTOM w0.102: v2(156.6,69.93) 156.84,69.69 157.12,69.69 157.58,69.22 157.58,68.62 157.35,68.39 157.35,65.92 156.72,65.28 156.72,65.14 156.84,65.02 JDIMM2.101
M_CLK_DDR1: length 60.8
  TOP w0.102: v2(178.06,106.31) JCPU1.V3
  IN1 w0.089: v2(178.06,106.31) 177.69,106.31 177.6,106.22 177.6,105.93 177.65,105.88 178.49,105.88 178.65,105.72 178.65,105.15 179.18,104.61 179.18,103.54 178.17,102.53 178.17,102.43 178.19,102.41 178.19,102.38
  IN1 w0.109: v2(156.6,75.24) 156.88,75.51 157.02,75.51 157.49,75.98 157.49,78.69 157.81,79.01 157.81,79.78 157.9,79.87 158.34,79.87 158.57,80.1 158.57,80.43 158.19,80.81 157.93,80.81 157.81,80.93 157.81,81.55 157.9,81.65 158.14,81.65 158.26,81.77 158.4,81.77 158.89,81.28 159.18,80.99 159.49,80.99 161.04,82.54 161.04,82.89 160.15,83.78 160.15,83.91 160.29,84.05 160.46,84.05 161.34,83.17 161.67,83.17 162.87,84.37 162.87,84.74 162.02,85.59 162.02,85.76 162.14,85.88 162.32,85.88 162.47,85.73 163.15,85.05 163.55,85.05 164.75,86.25 164.75,86.59 164.15,87.19 163.86,87.48 163.86,87.62 164.01,87.77 164.15,87.77 165.04,86.88 165.38,86.88 165.69,87.2 165.69,87.53 165.61,87.61 165.61,87.75 165.78,87.91 165.92,87.91 165.99,87.85 166.32,87.85 166.65,88.17 166.65,88.51 166.58,88.57 166.58,88.73 178.19,100.34 178.19,102.38
  BOTTOM w0.102: JDIMM2.102 156.54,73.13 156.35,73.32 156.35,73.53 156.53,73.7 157.39,73.7 157.68,74 157.68,74.32 157.32,74.68 156.26,74.68 156.12,74.82 156.12,75.42 156.22,75.52 156.33,75.52 v2(156.6,75.24)
M_CLK_DDR2: length 77.3
  TOP w0.102: JCPU1.AA4 181.47,107.84 181.02,108.29 v2(181.02,108.32)
  IN3 w0.094: v2(157.2,47.28) 156.96,47.52 156.96,47.66 157.24,47.93 157.95,47.93 158.32,48.3 158.32,48.79 158.1,49 157.71,49 157.61,49.11 157.61,57.85 158.24,58.48 158.24,62.49 160.53,64.78 160.53,71.41 161.56,72.44 161.56,74.03 174.06,86.54 174.06,87.67 180.13,93.73 180.13,102.29 181.66,103.83 181.66,107.51 181.29,107.87 180.73,107.87 180.66,107.94 180.66,108.24 180.74,108.32 v2(181.02,108.32)
  BOTTOM w0.102: JDIMM4.101 156.84,48.9 156.67,48.73 156.67,48.4 157,48.07 157,47.49 v2(157.2,47.28)
M_CLK_DDR3: length 76.2
  TOP w0.102: JCPU1.AA3 181.49,106.84 v2(181.03,107.3)
  IN3 w0.094: v2(156.04,52.24) 155.86,52.42 155.74,52.42 155.52,52.19 155.52,52.12 155.28,51.89 154.95,51.89 154.72,52.12 154.72,52.59 154.84,52.71 154.84,53.22 155.03,53.41 155.28,53.41 155.43,53.56 155.43,53.92 155.28,54.07 155.12,54.07 154.84,54.36 154.84,56.55 155.62,57.33 155.62,58.69 155.77,58.85 155.77,63.08 156.62,63.93 156.62,65.49 157.11,65.98 157.11,70.91 159.52,73.32 159.52,74.83 172.05,87.36 172.05,88.5 173.59,90.05 173.59,90.73 178.07,95.21 178.07,103.12 178.97,104.02 178.97,104.64 179.46,105.12 179.46,106.59 179.79,106.93 180.66,106.93 v2(181.03,107.3)
  BOTTOM w0.102: v2(156.04,52.24) 156.22,52.41 156.38,52.41 156.79,52.82 156.79,56.36 156.43,56.73 156.43,56.95 156.54,57.06 156.54,57.62 156.54,57.62 JDIMM4.102
M_CLK_DDR4: length 58.6
  TOP w0.102: JDIMM1.101 156.84,73.27 156.65,73.45 156.65,73.76 156.44,73.98 154.53,73.98 154.41,74.11 154.41,75.36 154.53,75.49 v3(154.86,75.49) 155.28,75.49 v2(155.48,75.29) ; JCPU1.V2 v2(178.06,105.31)
  IN1 w0.089: v2(178.06,105.31) 177.71,105.31 177.63,105.23 177.63,104.96 177.7,104.89 178.33,104.89 178.78,104.45 178.78,103.86 178.55,103.63 178.31,103.63 178.24,103.57 178.24,103.39 177.52,102.67 177.52,102.48 177.54,102.46 177.54,102.45
  IN1 w0.109: v2(155.48,75.29) 155.75,75.55 155.93,75.55 156.16,75.78 156.16,76.9 156.85,77.59 156.85,79.09 157.15,79.4 157.15,81.81 157.65,82.31 157.83,82.31 158.14,82.61 158.14,82.8 158.39,83.04 158.53,83.04 158.62,82.95 158.62,82.47 159.19,81.9 159.48,81.9 160.15,82.56 160.15,82.86 159.24,83.77 159.24,83.92 160.3,84.98 160.45,84.98 161.34,84.09 161.67,84.09 161.97,84.39 161.97,84.72 161.09,85.6 161.09,85.74 162.19,86.85 162.34,86.85 163.22,85.97 163.55,85.97 163.84,86.26 163.84,86.59 162.95,87.48 162.95,87.62 163.75,88.43 164.42,88.43 164.73,88.12 165.05,88.12 165.52,88.58 165.68,88.58 165.92,88.82 165.92,88.98 177.54,100.61 177.54,102.45
M_CLK_DDR5: length 57.9
  TOP w0.102: v2(156.6,67.64) 156.87,67.38 157.29,67.38 157.58,67.09 157.58,66.74 157.3,66.47 157.3,66.33 157.58,66.05 157.58,65.6 157.35,65.37 156.49,65.37 156.37,65.25 156.37,65.16 156.54,65 JDIMM1.102 ; JCPU1.V1 v2(178.06,104.31)
  IN1 w0.109: v2(178.06,104.31) 177.8,104.31 177.7,104.2 177.7,103.68 176.89,102.86 176.89,100.87 165.11,89.09 163.5,89.09 156.49,82.08 156.49,79.74 156.2,79.45 156.2,77.91 155.07,76.78 155.07,72.63 155.14,72.56 156.36,72.56 156.59,72.32 156.59,71.72 156.33,71.46 155.65,71.46 155.52,71.34 155.52,71.16 155.65,71.03 155.95,71.03 156.18,70.8 156.18,70.27 155.91,69.99 155.91,69.69 156.13,69.46 156.13,69.1 155.91,68.88 155.91,68.57 156.21,68.27 156.21,67.93 155.91,67.63 155.91,67.4 155.98,67.33 156.29,67.33 v2(156.6,67.64)
M_CLK_DDR6: length 75.2
  TOP w0.102: v2(156.04,55.29) 156.12,55.21 156.12,55.04 156.01,54.93 155.77,54.93 155.54,55.17 155.54,56.27 155.8,56.54 156.4,56.54 156.63,56.77 156.63,56.93 156.84,57.14 JDIMM3.101 ; JCPU1.AA2 v2(181.06,105.31)
  IN3 w0.094: v2(181.06,105.31) 180.81,105.31 180.65,105.15 180.65,104.93 180.41,104.69 179.89,104.69 179.66,104.46 179.66,103.58 178.91,102.83 178.91,94.22 178.59,93.89 178.28,93.89 178.14,94.03 178.01,94.03 177.76,93.78 177.76,93.64 177.9,93.5 177.9,93.2 177.59,92.89 177.29,92.89 177.15,93.03 177.02,93.03 174.39,90.41 174.39,89.73 172.85,88.18 172.85,87.02 160.32,74.49 160.32,72.98 159.31,71.97 159.31,70.93 159.12,70.74 158.08,70.74 157.9,70.57 157.9,70.35 158,70.24 158.27,70.24 158.51,70.01 158.51,69.67 158.27,69.43 158.04,69.43 157.9,69.3 157.9,68.97 158.03,68.85 158.25,68.85 158.49,68.61 158.49,68.23 158.25,67.98 158.01,67.98 157.9,67.87 157.9,67.6 158.03,67.48 158.25,67.48 158.49,67.24 158.49,66.9 158.25,66.66 158.01,66.66 157.9,66.55 157.9,66.28 158.38,65.8 159.1,65.8 159.28,65.62 159.28,65.32 158.74,64.78 158.22,64.78 157.72,65.28 157.54,65.28 157.42,65.15 157.42,64.97 158.03,64.36 158.03,64.04 157.02,63.03 157.02,58.97 156.42,58.37 156.42,56.99 155.64,56.22 155.64,55.06 155.77,54.93 155.97,54.93 156.1,55.06 156.1,55.23 v2(156.04,55.29)
M_CLK_DDR7: length 74.1
  TOP w0.102: JCPU1.AA1 v2(181.06,104.31) ; JDIMM3.102 156.54,48.83 156.41,48.7 156.41,48.28 156.05,47.92 155.73,47.92 v2(155.56,47.75)
  IN3 w0.094: v2(155.56,47.75) 155.78,47.97 156.39,47.97 156.63,48.21 156.63,49.37 156.39,49.61 155.11,49.61 154.99,49.74 154.99,49.91 155.11,50.03 156.77,50.03 157.01,50.27 157.01,58.1 157.63,58.72 157.63,62.75 159.92,65.04 159.92,71.74 160.93,72.75 160.93,74.25 173.45,86.76 173.45,87.91 179.53,93.99 179.53,102.51 180.66,103.64 180.66,104.1 180.87,104.31 v2(181.06,104.31)
M_CLK_DDR#0: length 62.1
  TOP w0.102: JCPU1.U4 178.09,108.34 v2(178.09,108.34)
  IN1 w0.089: v2(178.09,108.34) 178.09,108 178.18,107.91 178.42,107.91 178.67,107.66 178.67,107.05 178.81,106.92 179.38,106.92 179.65,106.64 179.65,106.13 179.82,105.96 179.82,105.63 179.65,105.46 179.65,103.37 178.84,102.55 178.84,102.39 178.86,102.37 178.86,102.35
  IN1 w0.109: 178.86,102.35 178.86,100.1 167.31,88.54 167.31,87.9 159.63,80.22 159.33,80.22 159.22,80.11 159.22,79.67 159.49,79.4 159.49,79.03 158.98,78.53 158.58,78.53 158.55,78.56 158.43,78.56 158.14,78.27 158.14,77.54 158.4,77.28 158.4,75.97 157.11,74.69 157.11,74.54 157.25,74.4 157.25,73.85 157.05,73.65 156.51,73.65 156.27,73.89 156.27,74.11 156.16,74.21 155.97,74.21 155.73,73.97 155.73,73.32 155.83,73.22 157.01,73.22 157.25,72.98 157.25,71.46 157.08,71.29 157.08,71.13 157.25,70.96 157.25,69.64 156.97,69.36 156.8,69.36 v2(156.6,69.16)
  BOTTOM w0.102: v2(156.6,69.16) 156.9,69.46 157.02,69.46 157.35,69.13 157.35,68.71 157.12,68.49 157.12,66.01 156.49,65.37 156.49,65.25 156.24,65.01 JDIMM2.103
M_CLK_DDR#1: length 60.8
  TOP w0.102: v2(177.06,106.4) 177.05,106.4 177.49,106.84 JCPU1.U3
  IN1 w0.089: 177.96,102.38 177.96,102.41 177.98,102.43 177.98,102.61 178.99,103.62 178.99,104.53 178.46,105.07 178.46,105.64 178.41,105.69 177.57,105.69 177.41,105.85 177.41,106.23 177.24,106.4 v2(177.06,106.4)
  IN1 w0.109: 177.96,102.38 177.96,100.44 166.35,88.83 166.35,88.48 166.41,88.41 166.41,88.27 166.23,88.08 166.08,88.08 166.02,88.15 165.68,88.15 165.38,87.85 165.38,87.51 165.46,87.44 165.46,87.29 165.28,87.12 165.14,87.12 164.25,88.01 163.91,88.01 163.63,87.72 163.63,87.39 163.99,87.03 164.51,86.5 164.51,86.34 163.45,85.28 163.24,85.28 162.63,85.89 162.41,86.11 162.05,86.11 161.79,85.86 161.79,85.49 162.63,84.65 162.63,84.46 161.57,83.4 161.44,83.4 160.56,84.28 160.19,84.28 159.92,84.01 159.92,83.68 160.81,82.79 160.81,82.64 159.39,81.22 159.28,81.22 159.05,81.45 158.49,82 158.17,82 158.04,81.88 157.81,81.88 157.58,81.65 157.58,80.84 157.83,80.58 158.09,80.58 158.34,80.33 158.34,80.2 158.24,80.1 157.81,80.1 157.58,79.87 157.58,79.11 157.26,78.79 157.26,76.08 156.93,75.75 156.8,75.75 156.6,75.95 v2(156.6,76)
  BOTTOM w0.102: JDIMM2.104 155.94,73.22 156.12,73.39 156.12,73.62 156.43,73.94 157.29,73.94 157.45,74.09 157.45,74.22 157.22,74.45 156.16,74.45 155.89,74.72 155.89,75.52 156.12,75.75 156.35,75.75 v2(156.6,76)
M_CLK_DDR#2: length 77.3
  TOP w0.102: JCPU1.Y4 180.55,107.84 v2(180.06,108.32)
  IN3 w0.094: v2(156.56,47.28) 156.77,47.49 156.77,47.74 157.15,48.13 157.87,48.13 158.12,48.38 158.12,48.71 158.02,48.81 157.63,48.81 157.41,49.03 157.41,57.93 158.04,58.56 158.04,62.58 160.33,64.86 160.33,71.49 161.36,72.52 161.36,74.11 173.87,86.62 173.87,87.75 179.93,93.81 179.93,102.38 181.46,103.91 181.46,107.42 181.21,107.67 180.65,107.67 180.47,107.86 180.47,108.24 180.36,108.34 180.09,108.34 v2(180.06,108.32)
  BOTTOM w0.102: JDIMM4.103 156.24,48.91 156.44,48.71 156.44,48.3 156.76,47.97 156.76,47.48 v2(156.56,47.28)
M_CLK_DDR#3: length 76.2
  TOP w0.102: JCPU1.Y3 180.59,106.76 v2(181.07,106.28)
  IN3 w0.094: v2(156.04,53) 156.09,52.95 156.09,52.81 155.89,52.61 155.66,52.61 155.32,52.27 155.32,52.2 155.2,52.08 155.03,52.08 154.91,52.2 154.91,52.51 155.03,52.63 155.03,53.13 155.11,53.21 155.36,53.21 155.63,53.48 155.63,54 155.36,54.27 155.2,54.27 155.03,54.44 155.03,56.47 155.81,57.25 155.81,58.61 155.97,58.77 155.97,62.99 156.82,63.85 156.82,65.41 157.31,65.9 157.31,70.83 159.72,73.24 159.72,74.75 172.25,87.28 172.25,88.42 173.79,89.96 173.79,90.64 178.27,95.13 178.27,103.04 179.17,103.94 179.17,104.56 179.65,105.04 179.65,106.51 179.87,106.73 180.95,106.73 181.15,106.53 181.15,106.35 v2(181.07,106.28)
  BOTTOM w0.102: v2(156.04,53) 156.01,52.96 156.01,52.76 156.12,52.64 156.29,52.64 156.56,52.92 156.56,56.27 156.2,56.63 156.2,56.87 155.94,57.12 JDIMM4.104
M_CLK_DDR#4: length 58.6
  TOP w0.102: JCPU1.U2 v2(177.06,105.31) ; v2(155.48,76) 155.2,75.72 154.44,75.72 154.17,75.46 154.17,74.01 154.44,73.75 156.34,73.75 156.42,73.67 156.42,73.51 156.24,73.33 JDIMM1.103
  IN1 w0.089: 177.31,102.45 177.31,102.47 177.33,102.49 177.33,102.75 178.05,103.47 178.05,103.65 178.23,103.82 178.47,103.82 178.59,103.94 178.59,104.37 178.26,104.7 177.62,104.7 177.44,104.88 177.44,105.19 177.33,105.31 v2(177.06,105.31)
  IN1 w0.109: 177.31,102.45 177.31,100.71 165.69,89.08 165.69,88.91 165.59,88.81 165.42,88.81 164.95,88.35 164.83,88.35 164.51,88.66 163.66,88.66 162.71,87.72 162.71,87.39 163.6,86.5 163.6,86.35 163.45,86.2 163.31,86.2 162.43,87.08 162.1,87.08 160.86,85.84 160.86,85.5 161.74,84.63 161.74,84.49 161.58,84.32 161.43,84.32 160.54,85.21 160.21,85.21 159.01,84.01 159.01,83.68 159.92,82.77 159.92,82.66 159.39,82.13 159.28,82.13 158.85,82.56 158.85,83.05 158.62,83.27 158.29,83.27 157.91,82.89 157.91,82.71 157.74,82.54 157.56,82.54 156.92,81.9 156.92,79.49 156.62,79.19 156.62,77.68 155.93,76.99 155.93,75.88 155.83,75.78 155.7,75.78 v2(155.48,76)
M_CLK_DDR#5: length 57.9
  TOP w0.102: v2(156.6,66.88) 156.87,67.15 157.2,67.15 157.35,66.99 157.35,66.84 157.07,66.56 157.07,66.23 157.35,65.95 157.35,65.7 157.25,65.6 156.39,65.6 156.14,65.35 156.14,65.19 155.94,64.99 JDIMM1.104 ; JCPU1.U1 v2(177.06,104.31)
  IN1 w0.109: v2(156.6,66.88) 156.39,67.1 155.88,67.1 155.68,67.3 155.68,67.73 155.98,68.03 155.98,68.17 155.68,68.47 155.68,68.97 155.9,69.2 155.9,69.36 155.68,69.59 155.68,70.09 155.95,70.37 155.95,70.71 155.86,70.8 155.55,70.8 155.29,71.06 155.29,71.43 155.55,71.69 156.23,71.69 156.36,71.82 156.36,72.23 156.27,72.32 155.04,72.32 154.84,72.53 154.84,76.88 155.97,78.01 155.97,79.55 156.26,79.84 156.26,82.18 163.4,89.32 165.01,89.32 176.66,100.96 176.66,102.96 177.47,103.77 177.47,104.23 177.39,104.31 v2(177.06,104.31)
M_CLK_DDR#6: length 75.2
  TOP w0.102: JCPU1.Y2 v2(180.06,105.31) ; JDIMM3.103 156.24,57.13 156.4,56.97 156.4,56.87 156.3,56.77 155.71,56.77 155.3,56.37 155.3,55.07 155.68,54.7 155.87,54.7 156.04,54.53 v2(156.04,54.53)
  IN3 w0.094: v2(156.04,54.53) 155.83,54.73 155.69,54.73 155.45,54.98 155.45,56.3 156.22,57.07 156.22,58.45 156.83,59.05 156.83,63.11 157.83,64.12 157.83,64.28 157.22,64.89 157.22,65.23 157.46,65.47 157.8,65.47 158.3,64.97 158.66,64.97 159.09,65.4 159.09,65.54 159.02,65.6 158.3,65.6 158.24,65.67 157.71,66.2 157.71,66.63 157.93,66.86 158.17,66.86 158.29,66.98 158.29,67.16 158.17,67.28 157.95,67.28 157.71,67.52 157.71,67.95 157.93,68.18 158.16,68.18 158.29,68.31 158.29,68.52 158.16,68.65 157.95,68.65 157.71,68.89 157.71,69.38 157.96,69.63 158.19,69.63 158.32,69.75 158.32,69.93 158.19,70.05 157.92,70.05 157.71,70.26 157.71,70.65 157.99,70.94 159.04,70.94 159.11,71.01 159.11,72.05 160.12,73.06 160.12,74.57 172.65,87.1 172.65,88.26 174.2,89.81 174.2,90.49 176.93,93.23 177.23,93.23 177.37,93.09 177.5,93.09 177.71,93.29 177.71,93.42 177.56,93.56 177.56,93.86 177.93,94.23 178.22,94.23 178.36,94.09 178.5,94.09 178.72,94.3 178.72,102.91 179.46,103.66 179.46,104.54 179.81,104.89 180.33,104.89 180.45,105.01 180.45,105.16 180.3,105.31 v2(180.06,105.31)
M_CLK_DDR#7: length 74
  TOP w0.102: JDIMM3.104 155.94,48.89 156.18,48.66 156.18,48.38 155.95,48.15 155.62,48.15 155.48,48.29 155.48,48.41 v2(155.55,48.48) ; JCPU1.Y1 v2(180.06,104.31)
  IN3 w0.094: v2(155.55,48.48) 155.48,48.41 155.48,48.26 155.58,48.17 156.31,48.17 156.44,48.29 156.44,49.29 156.31,49.42 155.03,49.42 154.79,49.65 154.79,49.99 155.03,50.23 156.69,50.23 156.82,50.36 156.82,58.18 157.44,58.8 157.44,62.83 159.72,65.12 159.72,71.82 160.73,72.84 160.73,74.33 173.25,86.84 173.25,87.99 179.33,94.07 179.33,102.59 180.47,103.72 180.47,104.1 180.26,104.31 v2(180.06,104.31)
M_ID2#: length 6.3
  TOP w0.102: JCRT1.4 89.53,171.85 89.53,169.89 v1(90.18,169.24) 90.79,168.63 C15.1
M_ODT0: length 66.8
  TOP w0.102: JCPU1.M8 172.59,111.81 v2(172.06,111.28)
  IN1 w0.089: v2(172.06,111.28) 172.47,111.7 176.47,111.7 176.65,111.52 176.65,111.09 176.47,110.91 174.62,110.91 174.47,110.76 173.86,110.76 173.68,110.58 173.68,110 173.43,109.74 172.92,109.74 172.63,109.45 172.63,103.7
  IN1 w0.178: 172.63,103.7 172.63,102.9 164.11,94.39 161.06,94.39 155.64,88.96 155.42,88.96 153.12,86.66 153.12,85.25 150.9,83.03 150.9,81.25 149.9,80.24 149.9,79.1 150.24,78.75 150.24,78.35 149.9,78 149.9,77.65 150.4,77.14 150.4,76.13 150.46,76.08 150.46,70.61 v2(150.53,70.54)
  BOTTOM w0.102: v2(150.53,70.54) 150.84,70.54 151.02,70.36 151.02,69.68 151.19,69.51 151.54,69.51 151.72,69.68 151.72,70.71 152.34,71.33 JDIMM2.116
M_ODT1: length 65.1
  TOP w0.102: JCPU1.L7 171.59,110.81 v2(171.06,110.28)
  IN1 w0.089: 171.17,104.86 171.44,105.13 171.44,105.74 171.04,106.13 171.04,106.67 171.44,107.06 171.44,110.02 171.49,110.07 171.49,110.58 171.36,110.71 171.19,110.71 171.06,110.58 v2(171.06,110.28)
  IN1 w0.178: v2(149.97,73.64) 149.52,74.08 149.52,74.97 147.95,76.55 147.95,78.03 148.42,78.5 148.42,79.21 147.94,79.69 147.94,80.13 148.42,80.61 148.42,80.89 148.77,81.23 148.77,81.49 147.95,82.31 147.6,82.31 147.45,82.46 147.45,82.64 147.75,82.94 147.75,83.25 147.45,83.55 147.45,84.49 150.39,87.43 150.6,87.43 150.75,87.28 150.75,87.07 150.18,86.49 150.18,86.28 150.33,86.13 150.54,86.13 151.53,87.12 151.53,87.34 151.17,87.7 151.17,87.92 151.33,88.07 151.55,88.07 151.9,87.72 152.13,87.72 152.28,87.88 152.28,88.1 151.95,88.42 151.95,88.65 152.11,88.8 152.33,88.8 152.66,88.47 152.88,88.47 153.04,88.63 153.04,88.85 152.87,89.01 152.87,89.23 153.03,89.39 153.25,89.39 153.41,89.23 153.63,89.23 154.82,90.41 155.04,90.41 160.46,95.83 163.51,95.83 171.17,103.49 171.17,104.86
  BOTTOM w0.102: JDIMM2.120 151.14,73.48 151.37,73.71 151.37,74.91 151.19,75.09 v1(150.94,75.09) 150.62,75.09 150.44,74.91 150.44,74.17 149.97,73.7 v2(149.97,73.64)
M_ODT2: length 77.5
  TOP w0.102: v2(175.06,107.31) JCPU1.R4
  IN3 w0.089: 173.15,102.17 173.15,102.38 174.81,104.05 174.81,104.56 175.35,105.09 175.35,105.59 175.08,105.86 174.92,105.86 174.66,106.11 174.66,107.21 174.79,107.34 175.03,107.34 v2(175.06,107.31)
  IN3 w0.152: v2(150.13,54.75) 149.93,54.75 149.69,54.5 149.69,53.73 149.55,53.58 149.35,53.58 149.21,53.73 149.21,54.63 149.67,55.09 149.67,56.35 149.7,56.39 149.7,58.56 150.13,58.98 150.13,59.24 149.96,59.41 149.96,65.47 150.11,65.62 150.11,65.9 149.96,66.05 149.96,66.36 150.09,66.49 150.09,66.82 149.96,66.94 149.96,71 153.59,74.63 153.59,77.35 154.07,77.84 154.07,78.12 153.99,78.2 153.99,78.39 154.13,78.53 154.46,78.53 154.63,78.7 154.63,79.04 155.07,79.48 155.07,79.69 154.77,79.99 154.77,80.64 155.07,80.94 155.55,80.94 155.73,81.12 155.73,81.29 173.14,98.71 173.14,98.9 173.01,99.04 172.81,99.04 171.81,98.04 171.62,98.04 171.48,98.18 171.48,98.37 172.64,99.53 172.97,99.53 173.15,99.71 173.15,102.17
  BOTTOM w0.102: v2(150.13,54.75) 150.56,55.17 150.56,56.01 151.34,56.79 152.15,56.79 152.34,56.98 JDIMM4.116
M_ODT3: length 76.8
  TOP w0.102: v2(175.06,106.31) JCPU1.R3
  IN3 w0.089: v2(175.06,106.31) 175.07,106.31 175.54,105.83 175.54,105 175.11,104.56 175.11,104.02 173.6,102.52 173.6,102.35
  IN3 w0.152: v2(150.13,56.02) 150.16,56.05 150.16,58.37 150.89,59.1 150.89,59.32 150.77,59.45 150.57,59.45 150.44,59.58 150.44,61.36 150.57,61.49 150.57,61.89 150.44,62.01 150.44,62.62 150.57,62.75 150.57,63.13 150.44,63.26 150.44,63.72 150.57,63.84 150.57,64.25 150.44,64.38 150.44,64.76 151.12,65.44 151.12,66.06 150.98,66.21 150.98,66.54 151.12,66.69 151.12,67.05 150.98,67.2 150.98,67.58 151.12,67.73 151.12,68.04 150.98,68.19 150.98,68.47 151.12,68.61 151.12,68.93 150.98,69.08 150.98,69.41 151.1,69.53 151.1,69.96 150.95,70.12 150.95,70.42 151.12,70.59 151.12,71.52 154.05,74.44 154.05,77.16 155.09,78.21 155.09,78.85 155.53,79.29 155.53,79.49 155.7,79.67 155.95,79.67 156.21,79.41 156.46,79.41 156.63,79.58 156.63,79.83 155.97,80.49 155.97,80.7 156.13,80.86 156.34,80.86 157.02,80.17 157.22,80.17 157.37,80.32 157.37,80.52 156.58,81.3 156.58,81.49 156.72,81.63 156.91,81.63 157.65,80.89 157.89,80.89 158.02,81.02 158.02,81.21 157.28,81.95 157.28,82.19 157.46,82.36 157.7,82.36 158.5,81.57 158.69,81.57 158.83,81.71 158.83,81.91 157.99,82.75 157.99,82.91 173.6,98.52 173.6,102.35
  BOTTOM w0.102: v2(150.13,56.02) 150.09,56.06 149.87,56.06 149.71,55.91 149.71,55.75 149.57,55.61 149.37,55.61 149.23,55.75 149.23,56.66 149.39,56.82 150.79,56.82 151.14,57.17 JDIMM4.120
M_ODT4: length 66
  TOP w0.102: JCPU1.L8 v2(171.06,111.31) ; v2(150.53,68) 150.95,67.57 150.95,67.55 152.34,66.16 JDIMM1.116
  IN1 w0.089: 170.11,103.79 170.43,104.12 170.43,111.06 170.68,111.31 v2(171.06,111.31)
  IN1 w0.178: 170.11,103.79 163.13,96.81 160.08,96.81 154.64,91.38 153.65,91.38 152.21,89.94 151.82,89.94 150.28,88.41 149.35,88.41 146.48,85.53 146.48,81.75 146.66,81.57 146.8,81.57 146.98,81.39 146.98,78.38 146.8,78.21 146.66,78.21 146.48,78.03 146.48,77.23 146.66,77.05 146.8,77.05 146.98,76.87 146.98,76.16 148.56,74.57 148.56,73.68 149.44,72.8 149.44,69.43 149.88,68.99 149.88,68.67 149.44,68.23 149.44,67.91 149.75,67.6 150.13,67.6 v2(150.53,68)
M_ODT5: length 68.4
  TOP w0.102: JCPU1.L10 v2(171.06,113.31) ; JDIMM1.120 151.14,65.07 151.84,65.77 151.84,66.21 151.32,66.73 v2(150.53,66.73)
  IN1 w0.089: v2(171.06,113.31) 171.35,113.31 171.65,113.01 171.65,112.29 171.04,111.68 169.9,111.68 169.68,111.46 169.68,103.94 169.28,103.53 169.16,103.53 168.93,103.3
  IN1 w0.178: v2(150.53,66.73) 149.94,66.73 148.96,67.71 148.96,72.6 148.08,73.48 148.08,74.37 146,76.45 146,85.73 149.15,88.89 150.08,88.89 151.62,90.42 152.01,90.42 153.45,91.86 154.44,91.86 159.88,97.29 162.93,97.29 168.93,103.3
M_ODT6: length 74.9
  TOP w0.102: v2(175.59,104.17) JCPU1.R1 ; JDIMM3.116 152.34,50.88 152.03,51.19 151.63,51.19 151.13,51.7 151.13,53.01 150.98,53.17 150.72,53.17 150.57,53.01 150.57,52.39 150.42,52.24 v2(150.13,52.24)
  IN3 w0.152: v2(175.59,104.17) 175.59,103.95 174.06,102.42 174.06,98.33 158.82,83.1 158.82,82.56 159.71,81.68 159.71,81.53 158.69,80.52 158.23,80.52 155.31,77.59 155.12,77.59 154.5,76.97 154.5,74.25 151.6,71.34 151.6,71.2 151.75,71.05 152,71.05 152.16,70.89 152.16,70.69 152,70.54 151.75,70.54 151.6,70.39 151.6,67.23 151.75,67.08 151.99,67.08 152.15,66.93 152.15,66.71 151.99,66.55 151.72,66.55 151.59,66.42 151.59,66.24 151.72,66.11 152,66.11 152.16,65.96 152.16,65.74 152,65.59 151.83,65.59 151.68,65.43 151.68,65.35 151.03,64.7 151.03,61.49 151.35,61.17 151.35,58.91 150.62,58.18 150.62,52.77 151.04,52.35 151.04,51.68 150.86,51.5 150.06,51.5 149.96,51.6 149.96,52.07 v2(150.13,52.24)
