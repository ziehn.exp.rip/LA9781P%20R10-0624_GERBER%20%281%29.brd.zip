# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D59: length 96.7
  TOP w0.102: JCPU1.B15 162.53,118.84 v2(162.06,119.31)
  TOP w0.14: v2(127.32,56.07) 128.89,56.07 129.84,57.02 JDIMM3.191
  IN3 w0.089: 160.12,119.06 160.17,119.11 160.68,119.11 160.91,118.89 161.64,118.89 v2(162.06,119.31)
  IN3 w0.127: 160.12,119.06 149.23,108.17 148.13,108.17 145.76,105.79 145.76,101.24 143.63,99.11 143.63,96.88 132.58,85.83 132.58,79.32 128.98,75.72 128.98,74.68 128.75,74.44 128.57,74.44 128.22,74.79 128.04,74.79 127.86,74.61 127.86,74.43 128.21,74.08 128.21,73.9 126.1,71.8 126.1,58.08 126.21,57.98 126.97,57.98 127.1,57.85 127.1,57.6 126.97,57.47 126.34,57.47 126.21,57.34 126.21,57.09 126.34,56.96 126.97,56.96 127.1,56.83 127.1,56.58 126.97,56.45 126.34,56.45 126.21,56.33 126.21,54.55 126.34,54.42 126.59,54.42 126.72,54.55 126.72,55.82 126.85,55.94 127.2,55.94 v2(127.32,56.07)
  BOTTOM w0.14: JDIMM4.192 129.54,56.9 129.09,56.45 127.7,56.45 v2(127.32,56.07)
DDR_B_D60: length 98
  TOP w0.102: JCPU1.E14 165.53,117.84 v2(165.06,118.31)
  TOP w0.14: v2(130.73,53.25) 131,53.25 133.14,51.11 JDIMM3.180
  IN3 w0.089: v2(165.06,118.31) 164.62,117.87 164.62,115.91 164.39,115.68 160.87,115.68 160.68,115.5
  IN3 w0.127: v2(130.73,53.25) 131.03,52.95 131.23,52.95 131.44,53.16 131.44,53.51 131.16,53.79 131.16,54.04 131.44,54.32 131.44,58.61 131.12,58.93 131.12,61.39 130.85,61.66 130.28,61.66 130.15,61.79 130.15,62.04 130.28,62.17 130.53,62.17 130.62,62.25 130.62,63.06 130.49,63.18 130.15,63.18 130.02,63.31 130.02,63.44 130.5,63.92 130.5,64.1 130.3,64.3 130.12,64.3 129.73,63.91 129.55,63.91 129.35,64.11 129.35,64.29 129.79,64.73 129.79,66.49 129.11,67.17 129.11,70.98 133.93,75.79 133.93,76.2 135.17,77.45 135.17,83.11 137.45,85.39 137.45,87.2 149.69,99.44 151.45,99.44 155.82,103.81 155.82,110.93 160.39,115.5 160.68,115.5
  BOTTOM w0.14: v2(130.73,53.25) 131.15,53.25 131.6,52.8 131.6,52.08 132.84,50.83 JDIMM4.181
DDR_B_D61: length 95.4
  TOP w0.102: v2(164.06,118.31) 164.53,117.84 JCPU1.D14
  TOP w0.14: v2(130.73,51.98) 130.76,52.01 131.37,52.01 132.54,50.83 JDIMM3.182
  IN3 w0.089: v2(164.06,118.31) 164.46,118.71 165.23,118.71 165.45,118.48 165.45,115.15 165.2,114.9 160.27,114.9 160.12,114.75
  IN3 w0.127: v2(130.73,51.98) 131.82,53.07 131.82,58.7 131.46,59.06 131.46,61.52 130.95,62.03 130.95,64.13 130.13,64.95 130.13,66.63 129.45,67.31 129.45,70.84 134.26,75.66 134.26,76.06 135.5,77.31 135.5,82.97 137.79,85.25 137.79,87.06 149.83,99.1 151.59,99.1 156.16,103.67 156.16,110.79 160.12,114.75
  BOTTOM w0.14: v2(130.73,51.98) 131.52,51.19 131.96,51.19 132.24,50.91 JDIMM4.183
DDR_B_D62: length 96.4
  TOP w0.102: v2(161.15,118.3) 161.59,117.85 JCPU1.A14
  TOP w0.14: JDIMM3.194 128.94,51.07 128.51,51.5 v2(127.33,51.5)
  IN3 w0.127: v2(127.33,51.5) 127.33,51.5 129.77,51.5 129.89,51.63 129.89,51.88 129.77,52.01 127.99,52.01 127.86,52.13 127.86,52.39 127.99,52.52 128.62,52.52 128.75,52.64 128.75,52.9 128.62,53.02 128.22,53.02 128.1,53.15 128.1,56.39 127.86,56.62 127.86,57.6 128.12,57.85 128.12,59.75 128.26,59.89 128.26,61.59 127.68,62.17 126.97,62.17 126.77,62.37 126.77,62.65 127.2,63.08 127.2,63.51 126.77,63.94 126.77,71.52 129.65,74.4 129.65,75.44 133.25,79.04 133.25,85.55 146.43,98.73 146.43,105.45 148.48,107.5 149.7,107.5 160.02,117.82 160.67,117.82 v2(161.15,118.3)
  BOTTOM w0.14: JDIMM4.193 129.24,51.07 128.82,51.5 v2(127.33,51.5)
DDR_B_D63: length 97.5
  TOP w0.102: JCPU1.B14 162.53,117.84 v2(162.06,118.31)
  TOP w0.14: JDIMM3.192 129.54,51.09 127.61,53.02 v2(127.32,53.02)
  IN3 w0.089: v2(162.06,118.31) 161.67,118.69 160.97,118.69 160.48,118.21 160.12,118.21
  IN3 w0.127: 160.12,118.21 159.93,118.21 149.56,107.83 148.27,107.83 146.09,105.65 146.09,101.1 143.99,99 143.99,96.77 132.91,85.69 132.91,79.18 129.32,75.58 129.32,74.54 126.44,71.66 126.44,61.94 126.59,61.79 127.3,61.79 127.43,61.66 127.43,61.44 127.3,61.32 126.59,61.32 126.47,61.19 126.47,60.52 126.59,60.39 126.97,60.39 127.1,60.26 127.1,60.01 126.97,59.88 126.59,59.88 126.47,59.75 126.47,59.5 126.59,59.37 127.61,59.37 127.74,59.25 127.74,58.99 127.61,58.87 126.97,58.87 126.85,58.74 126.85,58.48 126.97,58.36 127.65,58.36 127.78,58.23 127.78,57.99 127.48,57.69 127.48,56.53 127.76,56.25 127.76,53.46 v2(127.32,53.02)
  BOTTOM w0.14: v2(127.32,53.02) 127.89,53.02 129.84,51.07 JDIMM4.191
DDR_B_DQS0: length 91.7
  TOP w0.102: JCPU1.AP17 194.59,120.78 v2(195.06,120.31)
  TOP w0.127: JDIMM3.12 185.94,51.26 186.29,51.61 186.29,53.8 186.61,54.12 186.95,54.12 v2(187.18,54.34)
  IN3 w0.089: 197.79,118.72 197.77,118.72 197.75,118.74 196.79,118.74 196.46,119.07 196.46,119.47 196.25,119.68 195.7,119.68 195.49,119.9 195.49,120.61 195.28,120.82 195.02,120.82 194.87,120.66 194.87,120.5 v2(195.06,120.31)
  IN3 w0.127: 197.79,118.72 198.82,118.72 204.06,113.47 204.06,99.51 203.3,98.74 203.3,88.33 202.54,87.57 202.54,80.25 195.25,72.96 195.25,64.77 187.62,57.14 187.62,54.16 187.43,53.98 187.34,53.98 187.18,54.13 v2(187.18,54.34)
  BOTTOM w0.127: JDIMM4.12 185.94,57.12 186.05,57.01 186.23,57.01 186.31,56.93 186.31,56.6 187.65,55.26 187.65,54.18 187.53,54.05 187.31,54.05 187.18,54.18 v2(187.18,54.34)
DDR_B_DQS1: length 86.7
  TOP w0.102: v2(195.06,115.31) 194.59,115.78 JCPU1.AP12
  TOP w0.127: JDIMM3.29 180.84,56.35 181.08,56.12 181.49,56.12 181.58,56.03 181.58,55.78 180.95,55.15 180.95,54.29 181.18,54.06 181.58,54.06 181.91,54.39 182.07,54.39 v2(182.24,54.22)
  IN3 w0.089: 196.2,113.93 196.19,113.93 195.87,113.93 195.66,114.14 195.66,114.55 195.06,115.15 v2(195.06,115.31)
  IN3 w0.127: v2(182.24,54.22) 182.49,54.47 182.83,54.47 183.13,54.78 183.13,55.17 182.97,55.33 182.97,55.57 183.13,55.74 183.13,57.81 184.59,59.27 184.59,60.53 189.23,65.17 189.23,67.98 190.17,68.92 190.17,69.63 190.35,69.81 190.64,69.81 190.89,70.07 190.89,70.7 190.64,70.96 190.32,70.96 190.17,71.11 190.17,72.59 199.16,81.59 199.16,89.01 199.92,89.78 199.92,100.22 200.72,101.02 200.72,111 199.47,112.25 199.13,112.25 197.45,113.93 196.2,113.93
  BOTTOM w0.127: v2(182.24,54.22) 182.24,54.42 182.35,54.53 182.6,54.53 182.74,54.4 182.74,52.47 181.99,51.72 181.66,51.72 180.84,50.9 JDIMM4.29
DDR_B_DQS2: length 77.9
  TOP w0.102: JCPU1.AP6 194.59,109.78 v2(195.06,109.31)
  TOP w0.127: JDIMM3.47 175.44,57.07 175.54,56.97 175.54,56.48 175.93,56.09 175.93,55.32 175.54,54.92 175.54,54.19 175.82,53.91 176.17,53.91 176.45,54.19 176.65,54.19 v2(176.85,53.99)
  IN3 w0.089: v2(195.06,109.31) 195.27,109.1 195.45,109.1 195.67,108.88 195.67,107.18 195.91,106.93 196.34,106.93 196.66,106.61 196.66,106.32 196.67,106.31
  IN3 w0.127: v2(176.85,53.99) 176.85,54.01 177.15,54.31 177.3,54.31 177.5,54.5 177.5,55.83 177.09,56.25 177.09,56.88 180.35,60.15 180.35,61.65 183.82,65.11 183.82,70.29 183.45,70.65 183.45,70.94 195.62,83.11 195.62,95.25 196.39,96.02 196.39,104.43 196.86,104.9 196.86,105.89 196.67,106.09 196.67,106.31
  BOTTOM w0.127: v2(176.85,53.99) 176.85,54.16 176.96,54.27 177.2,54.27 177.29,54.17 177.29,52.99 175.81,51.51 175.81,51.06 175.72,50.97 175.56,50.97 175.44,50.84 JDIMM4.47
DDR_B_DQS3: length 76.5
  TOP w0.102: v2(191.06,106.31) 190.59,106.78 JCPU1.AK3
  TOP w0.127: v2(171.39,54.74) 171.25,54.6 170.94,54.6 170.64,54.29 170.64,53.63 171.03,53.24 171.03,51.61 170.54,51.13 170.54,50.94 170.34,50.74 JDIMM3.64
  IN3 w0.089: v2(191.06,106.31) 190.91,106.16 190.55,106.16 190.46,106.25 190.46,106.55 190.64,106.73 191.22,106.73 191.48,106.47 191.48,106.08 191.83,105.73 192.18,105.73 192.47,105.45 192.47,104.14 192.39,104.07 192.39,103.88 192.38,103.87 192.38,103.85
  IN3 w0.127: 192.38,103.85 192.38,103.65 191.82,103.09 191.82,85.3 178.34,71.83 178.34,65.13 172.97,59.75 172.97,58.42 172.52,57.97 172.52,56.48 172.05,56.01 172.05,54.64 171.79,54.38 171.51,54.38 171.39,54.5 v2(171.39,54.74)
  BOTTOM w0.127: JDIMM4.64 170.34,57.05 170.46,56.93 170.61,56.93 170.71,56.83 170.71,56.74 171.05,56.4 171.78,56.4 172.24,55.95 172.24,54.77 171.89,54.42 171.52,54.42 171.39,54.55 v2(171.39,54.74)
DDR_B_DQS4: length 81.2
  TOP w0.102: v2(172.06,106.31) JCPU1.M3
  TOP w0.127: v2(145.32,53.57) 145.3,53.57 145.21,53.48 145.21,53.35 145.34,53.23 145.64,53.23 145.83,53.42 145.83,56.39 146.23,56.78 146.23,56.92 146.04,57.11 JDIMM3.137
  IN3 w0.089: 169.31,103.42 169.32,103.42 169.32,103.44 169.32,103.44 169.34,103.44 169.65,103.75 169.65,105.43 169.91,105.7 170.28,105.7 170.87,106.29 171.41,106.29 171.97,106.85 172.16,106.85 172.24,106.77 172.24,106.49 v2(172.06,106.31)
  IN3 w0.127: 169.31,103.42 168.01,102.11 168.01,101.35 152.75,86.1 152.6,86.1 151.23,84.72 150.57,84.72 149.05,83.2 149.05,81.85 147.14,79.95 147.04,79.95 145.67,78.58 145.67,73.18 144.93,72.44 144.93,71.36 143.6,70.03 143.6,65.76 144.02,65.34 144.02,59.47 144.55,58.93 144.55,57.71 145.05,57.22 145.05,54.65 144.83,54.44 144.83,53.38 144.96,53.25 145.16,53.25 145.32,53.41 v2(145.32,53.57)
  BOTTOM w0.127: v2(145.32,53.57) 145.32,53.56 145.12,53.37 144.59,53.37 144.19,52.97 144.19,52.21 145.03,51.37 146.01,51.37 146.16,51.22 146.16,51.05 146.04,50.93 JDIMM4.137
DDR_B_DQS5: length 87.5
  TOP w0.102: v2(168.06,112.31) 168.53,111.84 JCPU1.H8
  TOP w0.127: v2(139.59,53.34) 139.59,53.58 139.7,53.68 140.06,53.68 140.18,53.56 140.18,52.41 139.87,52.11 139.87,51.74 140.26,51.35 140.63,51.35 140.75,51.47 140.98,51.47 141.2,51.25 141.2,50.99 141.12,50.91 141.02,50.91 140.94,50.84 JDIMM3.154
  IN3 w0.089: 165.29,104.44 165.3,104.45 165.3,104.47 165.29,104.47 165.3,104.47 165.68,104.86 165.68,110.5 165.89,110.71 167.29,110.71 167.65,111.08 167.65,112.57 167.8,112.71 167.94,112.71 168.06,112.59 v2(168.06,112.31)
  IN3 w0.127: v2(139.59,53.34) 139.59,53.55 139.74,53.7 140.04,53.7 140.38,54.03 140.38,55.16 139.71,55.83 139.71,61.11 138.3,62.52 138.3,70.99 141.18,73.87 141.18,80.7 147.36,86.87 147.71,86.87 165.29,104.44
  BOTTOM w0.127: v2(139.59,53.34) 139.4,53.53 139.11,53.53 138.91,53.73 138.91,55.11 140.56,56.76 140.75,56.76 140.94,56.94 JDIMM4.154
DDR_B_DQS6: length 87.9
  TOP w0.102: v2(163.06,113.31) 163.53,112.84 JCPU1.C9
  TOP w0.127: JDIMM3.171 135.84,57.09 133.87,55.12 133.87,53.96 134.07,53.76 134.39,53.76 v2(134.56,53.59)
  IN3 w0.089: 160.12,111.79 160.18,111.85 160.21,111.85 160.46,112.11 160.46,112.51 160.88,112.93 162.66,112.93 163.04,113.31 v2(163.06,113.31)
  IN3 w0.127: 160.12,111.79 159.89,111.56 159.89,111.54 159.18,110.83 159.18,103.67 152.74,97.23 150.63,97.23 142.07,88.67 142.07,86.89 137.37,82.2 137.37,76.53 136.13,75.29 136.13,74.83 132.64,71.34 132.64,65.8 133.35,65.09 133.35,61.42 134.2,60.57 134.2,55.56 133.91,55.27 133.91,53.99 134.14,53.76 134.43,53.76 134.56,53.63 v2(134.56,53.59)
  BOTTOM w0.127: JDIMM4.171 135.84,50.87 135.91,50.94 136.12,50.94 136.21,51.03 136.21,51.13 135.96,51.38 135.57,51.38 135.15,51.81 135.15,53.68 134.97,53.86 134.72,53.86 134.56,53.7 v2(134.56,53.59)
DDR_B_DQS7: length 101.7
  TOP w0.102: v2(163.06,119.31) 163.06,119.27 163.49,118.84 JCPU1.C15
  TOP w0.127: JDIMM3.188 130.74,50.82 130.81,50.89 130.99,50.89 131.11,51.01 131.11,51.13 130.91,51.33 130.4,51.33 129.72,52.01 129.72,52.69 130.03,53.01 130.03,53.65 129.82,53.86 129.36,53.86 129.27,53.77 v2(129.27,53.56)
  IN3 w0.089: 159.89,117.04 159.89,117.06 159.91,117.08 160.2,117.36 161.22,117.36 161.73,117.87 162.18,117.87 162.43,118.13 162.43,118.75 162.68,119 163,119 163.06,119.06 v2(163.06,119.31)
  IN3 w0.127: 159.89,117.04 154.42,111.56 154.42,111.3 154.42,104.42 150.99,100.99 149.31,100.99 133.74,85.42 133.74,78.65 130.08,74.99 130.08,74.22 127.27,71.4 127.27,64.06 128.13,63.19 128.13,62.33 128.69,61.77 128.69,60.27 129.28,59.68 129.28,59.5 128.66,58.88 128.66,58.47 128.88,58.26 129.84,58.26 129.97,58.13 129.97,57.67 129.84,57.54 128.64,57.54 128.38,57.29 128.38,56.73 128.64,56.48 129.51,56.48 129.64,56.35 129.64,55.98 129.51,55.86 128.81,55.86 128.55,55.59 128.55,53.94 128.78,53.71 129.11,53.71 v2(129.27,53.56)
  BOTTOM w0.127: JDIMM4.188 130.74,56.91 130.64,56.81 130.07,56.81 128.52,55.26 128.52,53.96 128.78,53.71 129.11,53.71 v2(129.27,53.56)
DDR_B_DQS#0: length 91.7
  TOP w0.102: v2(195.06,121.31) 194.59,121.78 JCPU1.AP18
  TOP w0.127: v2(187.18,53.58) 187.18,53.68 186.97,53.89 186.7,53.89 186.52,53.71 186.52,51.52 186.17,51.16 186.17,51.03 186.26,50.94 186.41,50.94 186.54,50.81 JDIMM3.10
  IN3 w0.089: 197.79,118.94 197.78,118.93 196.87,118.93 196.65,119.15 196.65,119.55 196.33,119.87 195.78,119.87 195.68,119.98 195.68,120.69 195.36,121.01 195.17,121.01 195.06,121.11 v2(195.06,121.31)
  IN3 w0.127: v2(187.18,53.58) 187.36,53.76 187.52,53.76 187.83,54.07 187.83,57.05 195.46,64.68 195.46,72.87 202.75,80.16 202.75,87.48 203.52,88.24 203.52,98.65 204.28,99.42 204.28,113.56 198.91,118.94 197.79,118.94
  BOTTOM w0.127: v2(187.18,53.58) 187.42,53.82 187.62,53.82 187.88,54.08 187.88,55.35 186.54,56.7 JDIMM4.10
DDR_B_DQS#1: length 86.8
  TOP w0.102: v2(195.06,114.31) 194.59,114.78 JCPU1.AP11
  TOP w0.127: v2(182.24,54.98) 182.24,54.78 182.09,54.62 181.82,54.62 181.49,54.29 181.27,54.29 181.18,54.39 181.18,55.06 181.81,55.69 181.81,56.12 181.59,56.35 181.17,56.35 181.07,56.45 181.07,56.83 181.18,56.93 181.3,56.93 181.44,57.07 JDIMM3.27
  IN3 w0.089: v2(195.06,114.31) 194.87,114.31 194.83,114.35 194.83,114.68 194.92,114.77 195.17,114.77 195.47,114.47 195.47,114.06 195.8,113.74 196.16,113.74 196.18,113.72 196.2,113.72
  IN3 w0.127: v2(182.24,54.98) 182.54,54.69 182.74,54.69 182.92,54.87 182.92,55.08 182.75,55.25 182.75,55.66 182.92,55.83 182.92,57.9 184.38,59.36 184.38,60.62 189.01,65.26 189.01,68.07 189.95,69.01 189.95,69.72 190.26,70.03 190.55,70.03 190.68,70.16 190.68,70.61 190.55,70.74 190.23,70.74 189.95,71.02 189.95,72.68 198.94,81.67 198.94,89.1 199.71,89.87 199.71,100.31 200.51,101.11 200.51,110.91 199.38,112.04 199.04,112.04 197.36,113.72 196.2,113.72
  BOTTOM w0.127: JDIMM4.27 181.44,51.18 181.76,51.49 182.09,51.49 182.97,52.37 182.97,54.49 182.7,54.76 182.47,54.76 v2(182.24,54.98)
DDR_B_DQS#2: length 77.9
  TOP w0.102: v2(195.06,108.31) 194.59,108.78 JCPU1.AP5
  TOP w0.127: v2(176.85,54.76) 176.93,54.67 176.93,54.55 176.81,54.42 176.36,54.42 176.08,54.14 175.91,54.14 175.77,54.29 175.77,54.83 176.16,55.22 176.16,56.18 175.77,56.58 175.77,56.91 176.04,57.18 JDIMM3.45
  IN3 w0.089: 196.45,106.31 196.45,106.32 196.47,106.34 196.47,106.54 196.26,106.74 195.83,106.74 195.48,107.1 195.48,108.8 195.38,108.91 195.05,108.91 194.86,108.71 194.86,108.53 195.06,108.33 v2(195.06,108.31)
  IN3 w0.127: 196.45,106.31 196.45,106 196.65,105.8 196.65,104.99 196.18,104.52 196.18,96.11 195.4,95.34 195.4,83.2 183.23,71.03 183.23,70.56 183.6,70.2 183.6,65.2 180.14,61.74 180.14,60.24 176.87,56.97 176.87,56.16 177.29,55.75 177.29,54.59 177.21,54.52 177.09,54.52 v2(176.85,54.76)
  BOTTOM w0.127: v2(176.85,54.76) 177.11,54.5 177.29,54.5 177.52,54.26 177.52,52.9 176.04,51.42 JDIMM4.45
DDR_B_DQS#3: length 76.6
  TOP w0.102: JCPU1.AJ3 189.59,106.78 v2(190.06,106.31)
  TOP w0.127: v2(171.39,53.98) 171.45,54.04 171.45,54.24 171.37,54.32 171.22,54.32 171.17,54.37 171.04,54.37 170.86,54.2 170.86,53.73 171.26,53.33 171.26,51.52 170.77,51.03 170.77,50.94 170.94,50.77 JDIMM3.62
  IN3 w0.089: v2(190.06,106.31) 190.27,106.52 190.27,106.63 190.56,106.92 191.3,106.92 191.67,106.55 191.67,106.16 191.91,105.92 192.26,105.92 192.66,105.52 192.66,104.07 192.59,104 192.59,103.88 192.61,103.86 192.61,103.85
  IN3 w0.127: v2(171.39,53.98) 171.58,54.17 171.88,54.17 172.26,54.55 172.26,55.92 172.74,56.39 172.74,57.88 173.19,58.33 173.19,59.66 178.56,65.04 178.56,71.74 192.04,85.21 192.04,103 192.61,103.57 192.61,103.85
  BOTTOM w0.127: v2(171.39,53.98) 171.6,54.19 171.98,54.19 172.46,54.67 172.46,56.04 171.88,56.63 171.14,56.63 170.94,56.83 JDIMM4.62
DDR_B_DQS#4: length 81.1
  TOP w0.102: JCPU1.L3 v2(172.06,107.31)
  TOP w0.127: v2(145.32,52.81) 145.51,53 145.74,53 146.06,53.32 146.06,56.3 146.45,56.69 146.45,56.91 146.64,57.09 JDIMM3.135
  IN3 w0.089: v2(172.06,107.31) 172.06,107.2 171.33,106.48 170.79,106.48 170.2,105.89 169.84,105.89 169.45,105.51 169.45,103.83 169.21,103.58 169.2,103.58 169.17,103.58 169.16,103.57
  IN3 w0.127: v2(145.32,52.81) 145.09,53.04 144.87,53.04 144.61,53.29 144.61,54.53 144.83,54.74 144.83,57.13 144.34,57.62 144.34,58.84 143.8,59.38 143.8,65.25 143.39,65.67 143.39,70.12 144.71,71.45 144.71,72.53 145.45,73.27 145.45,78.67 146.95,80.16 147.05,80.16 148.83,81.94 148.83,83.29 150.48,84.94 151.14,84.94 152.51,86.31 152.66,86.31 167.79,101.44 167.79,102.2 169.16,103.57
  BOTTOM w0.127: v2(145.32,52.81) 145.41,52.9 145.41,53.02 145.3,53.14 144.68,53.14 144.42,52.88 144.42,52.3 145.13,51.6 146.11,51.6 146.39,51.31 146.39,51.05 146.54,50.91 146.55,50.91 146.64,50.82 JDIMM4.135
DDR_B_DQS#5: length 87.6
  TOP w0.102: v2(168.06,113.31) 168.53,112.84 JCPU1.H9
  TOP w0.127: v2(139.59,54.1) 139.78,53.91 140.16,53.91 140.41,53.66 140.41,52.32 140.1,52.01 140.1,51.83 140.35,51.58 140.53,51.58 140.65,51.7 141.07,51.7 141.43,51.35 141.43,50.87 141.54,50.76 JDIMM3.152
  IN3 w0.089: 165.14,104.6 165.15,104.61 165.17,104.61 165.49,104.94 165.49,110.58 165.81,110.9 167.21,110.9 167.46,111.15 167.46,112.65 167.72,112.9 168.14,112.9 168.24,113.01 168.24,113.13 v2(168.06,113.31)
  IN3 w0.127: 165.14,104.6 147.62,87.08 147.27,87.08 140.97,80.79 140.97,73.96 138.09,71.08 138.09,62.43 139.5,61.02 139.5,55.74 140.16,55.07 140.16,54.12 139.95,53.91 139.78,53.91 v2(139.59,54.1)
  BOTTOM w0.127: v2(139.59,54.1) 139.59,53.86 139.49,53.76 139.21,53.76 139.14,53.83 139.14,55.02 140.65,56.53 140.85,56.53 141.25,56.93 141.32,56.93 141.54,57.15 JDIMM4.152
DDR_B_DQS#6: length 87.9
  TOP w0.102: v2(163.06,112.31) 163.53,111.84 JCPU1.C8
  TOP w0.127: JDIMM3.169 136.44,57.18 136.07,56.81 135.88,56.81 134.1,55.03 134.1,54.06 134.17,53.99 134.39,53.99 134.56,54.15 v2(134.56,54.27)
  IN3 w0.089: 160.27,111.64 160.29,111.65 160.29,111.66 160.65,112.03 160.65,112.43 160.95,112.73 162.74,112.73 162.89,112.89 163.09,112.89 163.17,112.81 163.17,112.42 v2(163.06,112.31)
  IN3 w0.127: 160.27,111.64 160.11,111.47 160.11,111.45 159.4,110.74 159.4,103.58 152.83,97.02 150.72,97.02 142.29,88.58 142.29,86.81 137.59,82.11 137.59,76.44 136.35,75.2 136.35,74.74 132.85,71.25 132.85,65.89 133.56,65.18 133.56,61.51 134.41,60.66 134.41,55.47 134.12,55.18 134.12,54.08 134.23,53.98 134.35,53.98 134.56,54.18 v2(134.56,54.27)
  BOTTOM w0.127: v2(134.56,54.27) 134.73,54.09 135.07,54.09 135.38,53.78 135.38,51.9 135.67,51.61 136.06,51.61 136.44,51.23 JDIMM4.169
DDR_B_DQS#7: length 101.7
  TOP w0.102: JCPU1.C14 163.53,117.84 v2(163.06,118.31)
  TOP w0.127: v2(129.27,54.32) 129.48,54.1 129.9,54.1 130.26,53.74 130.26,52.92 129.94,52.6 129.94,52.11 130.49,51.56 131,51.56 131.34,51.22 JDIMM3.186
  IN3 w0.089: 160.04,116.89 160.05,116.89 160.05,116.92 160.09,116.96 160.09,116.99 160.26,117.16 160.26,117.16 160.27,117.17 161.3,117.17 161.81,117.68 162.26,117.68 162.62,118.05 162.62,118.67 162.76,118.81 163.14,118.81 163.27,118.68 163.27,118.52 v2(163.06,118.31)
  IN3 w0.127: 160.04,116.89 154.63,111.48 154.63,111.39 154.63,104.33 151.08,100.78 149.4,100.78 133.96,85.33 133.96,78.56 130.3,74.9 130.3,74.13 127.48,71.31 127.48,64.15 128.34,63.28 128.34,62.42 128.9,61.86 128.9,60.36 129.5,59.77 129.5,59.41 128.88,58.79 128.88,58.56 128.97,58.47 129.93,58.47 130.19,58.22 130.19,57.58 129.93,57.33 128.73,57.33 128.6,57.2 128.6,56.82 128.73,56.69 129.6,56.69 129.86,56.44 129.86,55.89 129.6,55.64 128.9,55.64 128.76,55.5 128.76,54.03 128.87,53.92 129.07,53.92 129.27,54.12 v2(129.27,54.32)
  BOTTOM w0.127: v2(129.27,54.32) 129.27,54.12 129.08,53.94 128.87,53.94 128.75,54.06 128.75,55.16 130.17,56.58 130.73,56.58 130.97,56.81 130.97,56.91 131.11,57.05 131.18,57.05 131.34,57.21 JDIMM4.186
DDR_B_MA0: length 88.8
  TOP w0.102: JDIMM3.98 157.74,51.03 157.17,51.6 157.17,53.4 157.4,53.63 157.9,53.63 158.08,53.45 v2(158.08,53.38) ; v2(175.06,111.31) JCPU1.R8
  IN3 w0.089: 181.62,102.63 181.62,102.69 182.3,103.38 182.3,107.73 182.11,107.92 182.11,108.4 181.38,109.14 181.38,109.47 181.16,109.69 179.82,109.69 179.53,109.98 179.53,110.5 179.09,110.93 175.43,110.93 v2(175.06,111.31)
  IN3 w0.178: v2(158.08,53.38) 158.65,52.81 158.65,51.93 158.82,51.75 159.18,51.75 159.36,51.93 159.36,52.79 158.93,53.23 158.93,54.32 159.1,54.5 159.1,57.24 159.75,57.89 159.75,61.91 162.6,64.76 162.6,65.66 163.07,66.14 163.07,69.98 163.94,70.84 163.94,72.77 164.52,73.35 164.52,74.94 176.86,87.28 177.21,87.28 181.62,91.68 181.62,102.63
  BOTTOM w0.102: JDIMM4.98 157.74,56.99 158.58,56.15 158.58,53.89 v2(158.08,53.38)
DDR_B_MA1: length 89.4
  TOP w0.102: JDIMM3.97 158.04,57.01 156.82,55.79 156.82,54.41 156.96,54.27 157.16,54.27 157.3,54.41 157.3,55.61 157.58,55.89 158.05,55.89 v2(158.08,55.92) ; JCPU1.Y5 180.52,108.84 v2(180.06,109.3)
  IN3 w0.089: v2(180.06,109.3) 180.46,108.9 181.07,108.9 181.73,108.24 181.73,107.76 181.89,107.6 181.89,103.64 180.6,102.34 180.6,102.17
  IN3 w0.178: v2(158.08,55.92) 158.09,55.93 158.09,57.67 158.73,58.31 158.73,62.33 161.47,65.07 161.47,65.22 161.31,65.37 161.15,65.37 160.98,65.54 160.98,65.78 161.15,65.95 161.39,65.95 161.6,66.16 161.6,70.18 160.98,70.8 160.98,71.22 162.01,72.25 162.01,73.84 174.52,86.35 174.52,87.48 175.81,88.77 176.09,88.77 176.58,88.28 176.78,88.28 179.76,91.26 179.76,91.47 179.62,91.62 179.41,91.62 176.79,89 176.57,89 176.42,89.15 176.42,89.37 180.6,93.56 180.6,102.17
  BOTTOM w0.102: v2(158.08,55.92) 157.22,55.07 157.22,52.31 158.04,51.5 JDIMM4.97
DDR_B_MA2: length 83.7
  TOP w0.102: JDIMM3.96 158.34,51.13 158.85,51.64 158.85,53.48 v2(159.41,54.04) ; v2(180.06,113.31) JCPU1.Y10
  IN3 w0.089: 182.12,102.81 182.12,102.91 182.49,103.28 182.49,107.81 182.3,108 182.3,108.48 181.61,109.17 181.61,109.5 181.24,109.88 180.78,109.88 180.44,110.21 180.44,111.46 179.71,112.19 179.71,112.96 v2(180.06,113.31)
  IN3 w0.178: 182.12,102.81 182.12,91.47 177.43,86.78 177.06,86.78 175.21,84.93 175.21,84.91 165.91,75.61 165.91,75.15 165.68,74.92 165.23,74.92 165.05,74.74 165.05,74.46 165.23,74.28 165.74,74.28 165.91,74.11 165.91,73.87 165.74,73.7 165.17,73.7 165.02,73.55 165.02,73.15 164.44,72.57 164.44,70.64 163.57,69.77 163.57,65.93 163.13,65.49 163.13,65.21 163.3,65.04 163.3,64.74 160.26,61.7 160.26,57.68 159.61,57.03 159.61,54.8 160.29,54.13 160.29,53.88 160.09,53.68 159.84,53.68 159.49,54.04 v2(159.41,54.04)
  BOTTOM w0.102: JDIMM4.96 158.34,57 159.04,56.3 159.04,54.41 v2(159.41,54.04)
DDR_B_MA3: length 86.7
  TOP w0.102: v2(181,109.31) 181.47,108.84 JCPU1.AA5 ; JDIMM3.95 158.64,56.91 158.52,56.79 158.52,55.08 158.6,55 159.08,55 159.26,54.83 159.26,54.52 158.85,54.12 158.61,54.12 v2(158.08,54.65)
  IN3 w0.089: v2(181,109.31) 181,109.24 181.92,108.32 181.92,107.84 182.11,107.65 182.11,103.5 181.11,102.5 181.11,102.32
  IN3 w0.178: 181.11,102.32 181.11,93.36 179.97,92.22 179.97,92 180.13,91.84 180.35,91.84 180.76,92.26 180.99,92.26 181.11,92.14 181.11,91.88 177.01,87.77 176.65,87.77 162.52,73.65 162.52,73.43 162.68,73.27 162.9,73.27 163.6,73.98 163.85,73.98 164.02,73.81 164.02,73.56 163.19,72.73 162.69,72.73 162.51,72.56 162.51,72.33 162.69,72.15 163.24,72.15 163.42,71.97 163.42,71.03 163.08,70.69 162.84,70.69 162.71,70.81 162.71,71.36 162.41,71.67 162.18,71.67 161.62,71.11 161.62,70.87 162.1,70.39 162.1,65.93 161.87,65.7 161.87,65.55 162.1,65.32 162.1,64.98 159.24,62.12 159.24,58.1 158.6,57.46 158.6,54.7 158.47,54.57 158.16,54.57 v2(158.08,54.65)
  BOTTOM w0.102: JDIMM4.95 158.64,51.43 157.65,52.42 157.65,54.23 v2(158.08,54.65)
DDR_B_MA4: length 86.1
  TOP w0.102: JCPU1.Y7 180.59,110.87 v2(181.05,111.33) ; v2(160.74,55.92) 159.84,55.01 159.84,53.25 159.54,52.95 JDIMM3.92
  IN3 w0.089: 183.14,103.73 183.47,104.06 183.47,107.83 183.36,107.93 182.9,107.93 182.68,108.15 182.68,108.7 182.49,108.89 182.49,109.4 182.17,109.72 181.67,109.72 181.32,110.07 180.86,110.07 180.63,110.3 180.63,110.9 v2(181.05,111.33)
  IN3 w0.178: v2(160.74,55.92) 160.64,56.02 160.64,56.63 161.27,57.26 161.27,61.28 164.58,64.58 164.58,69.37 165.43,70.22 165.43,72.15 165.98,72.7 166.36,72.7 166.91,73.25 166.91,75.18 169.62,77.89 172.17,80.44 172.4,80.44 172.56,80.28 172.56,80.05 170.16,77.65 170.16,77.42 170.32,77.27 170.54,77.27 173.12,79.85 173.12,80.33 173.27,80.48 173.75,80.48 176.95,83.67 176.95,84.86 183.14,91.05 183.14,103.73
  BOTTOM w0.102: v2(160.74,55.92) 160.68,55.92 159.54,57.06 JDIMM4.92
DDR_B_MA5: length 86.2
  TOP w0.102: JDIMM3.91 159.84,56.91 159.65,56.72 159.65,56.47 159.99,56.13 160.24,56.13 160.55,56.44 160.84,56.44 161.16,56.11 161.16,54.88 160.93,54.65 v2(160.74,54.65) ; JCPU1.AA6 181.59,109.77 v2(182.02,109.34)
  IN3 w0.089: v2(182.02,109.34) 182.15,109.34 182.27,109.22 182.27,108.84 182.49,108.62 182.49,108.07 182.68,107.88 182.68,103.19 182.63,103.14 182.63,102.98
  IN3 w0.178: 182.63,102.98 182.63,91.26 177.65,86.28 177.3,86.28 172.92,81.9 172.92,81.68 173.08,81.52 173.3,81.52 176.04,84.26 176.28,84.26 176.44,84.1 176.44,83.87 173.55,80.97 171.99,80.97 166.41,75.39 166.41,73.46 166.15,73.2 165.78,73.2 164.94,72.36 164.94,70.43 164.08,69.57 164.08,65.73 163.88,65.54 163.88,65.23 164.08,65.04 164.08,64.8 160.76,61.49 160.76,57.47 160.12,56.82 160.12,55 160.47,54.65 v2(160.74,54.65)
  BOTTOM w0.102: v2(160.74,54.65) 160.24,54.15 160.24,53.15 159.84,52.75 JDIMM4.91
DDR_B_MA6: length 88.9
  TOP w0.102: JDIMM3.90 160.14,50.97 160.29,51.12 160.88,51.12 161.01,51.25 161.01,51.5 160.88,51.63 160.27,51.63 160.14,51.75 160.14,52.77 v2(160.74,53.38) ; JCPU1.Y6 180.59,109.97 v2(181.07,110.45)
  IN3 w0.089: v2(181.07,110.45) 181.22,110.45 181.76,109.91 182.25,109.91 182.68,109.48 182.68,109.16 182.9,108.93 183.23,108.93 183.49,108.67 183.49,108.07 183.66,107.91 183.66,103.87 183.65,103.86 183.65,103.77
  IN3 w0.178: 183.65,103.77 183.65,90.84 177.45,84.64 177.45,83.47 168.73,74.75 168.49,74.75 168.33,74.91 168.33,75.15 169.9,76.73 169.9,76.95 169.75,77.1 169.53,77.1 167.4,74.98 167.4,73.05 166.56,72.21 166.19,72.21 165.93,71.95 165.93,69.91 165.75,69.74 165.66,69.74 165.48,69.56 165.48,69.28 165.66,69.1 165.75,69.1 165.93,68.92 165.93,68.72 165.75,68.54 165.66,68.54 165.48,68.36 165.48,68.09 165.66,67.91 165.75,67.91 165.93,67.73 165.93,67.53 165.75,67.35 165.66,67.35 165.48,67.17 165.48,66.94 165.66,66.76 165.75,66.76 165.93,66.59 165.93,66 165.78,65.85 165.28,65.85 165.1,65.67 165.1,65.42 165.28,65.24 165.4,65.24 165.56,65.09 165.56,64.84 161.78,61.07 161.78,57.05 161.24,56.5 161.24,53.28 161.11,53.15 160.97,53.15 v2(160.74,53.38)
  BOTTOM w0.102: JDIMM4.90 160.14,57.11 161.45,55.8 161.45,54.08 v2(160.74,53.38)
DDR_B_MA7: length 84.7
  TOP w0.102: JDIMM3.86 161.34,50.99 161.95,51.6 161.95,55.31 162.54,55.9 v2(162.78,55.9) ; v2(182.02,111.27) 181.59,110.84 JCPU1.AA7
  IN3 w0.089: 185.17,105.93 185.49,106.25 185.49,110.64 185.2,110.93 182.87,110.93 182.54,111.27 v2(182.02,111.27)
  IN3 w0.178: v2(162.78,55.9) 163.37,56.48 163.37,58.41 163.71,58.75 163.71,60.27 163.98,60.54 164.21,60.54 167.83,64.16 167.83,71.05 169.62,72.84 169.92,72.84 170.32,73.24 170.32,73.48 170.07,73.73 170.07,73.97 170.24,74.14 170.48,74.14 170.77,73.84 170.92,73.84 171.12,74.04 171.12,74.26 170.85,74.54 170.85,74.76 171,74.91 171.23,74.91 171.5,74.64 171.72,74.64 171.88,74.8 171.88,75.02 171.6,75.29 171.6,75.51 171.76,75.67 171.98,75.67 172.25,75.39 172.48,75.39 172.63,75.55 172.63,75.77 172.36,76.04 172.36,76.27 172.51,76.42 172.73,76.42 173.01,76.15 173.23,76.15 173.39,76.3 173.39,76.52 173.11,76.8 173.11,77.02 173.27,77.18 173.49,77.18 173.76,76.9 173.98,76.9 174.14,77.06 174.14,77.28 173.87,77.55 173.87,77.77 174.02,77.93 174.24,77.93 174.52,77.66 174.74,77.66 175,77.92 175,78.87 178.94,82.82 178.94,83.97 185.17,90.21 185.17,105.93
  BOTTOM w0.102: v2(162.78,55.9) 162.44,55.9 161.34,56.99 JDIMM4.86
DDR_B_MA8: length 88.9
  TOP w0.102: JCPU1.Y8 180.59,111.88 v2(180.13,112.35) ; JDIMM3.89 160.44,57.32 160.91,56.85 160.98,56.85 161.52,56.31 161.52,52.85 v2(160.76,52.08)
  IN3 w0.089: v2(180.13,112.35) 180.63,112.35 181.44,111.53 181.44,110.94 181.71,110.67 182.24,110.67 182.4,110.52 182.4,110.03 182.69,109.74 184.27,109.74 184.48,109.53 184.48,104.01 184.33,103.87
  IN3 w0.178: v2(160.76,52.08) 160.32,52.08 160.15,51.91 160.15,51.07 160.32,50.89 161.59,50.89 161.77,51.07 161.77,56.32 162.35,56.9 162.35,58.83 162.71,59.19 162.71,61.29 166.44,65.02 166.44,71.28 167.9,72.74 167.9,74.08 168.1,74.27 168.26,74.27 168.51,74.03 168.71,74.03 177.95,83.26 177.95,84.42 184.16,90.63 184.16,103.69 184.33,103.87
  BOTTOM w0.102: v2(160.76,52.08) 161.16,52.08 161.34,51.91 161.34,51.32 161.16,51.14 160.58,51.14 160.44,51.01 JDIMM4.89
DDR_B_MA9: length 84.2
  TOP w0.102: v2(162.78,53.36) 163.3,53.87 163.3,56.07 163.02,56.35 162.34,56.35 161.64,57.05 JDIMM3.85 ; v2(181.06,113.31) JCPU1.AA10
  IN3 w0.089: 185.68,104.97 185.68,106.1 185.68,106.11 185.68,111.47 185.45,111.7 181.95,111.7 181.49,112.15 181.49,112.88 v2(181.06,113.31)
  IN3 w0.178: v2(162.78,53.36) 163.32,53.89 163.32,55.69 163.87,56.24 163.87,58.17 164.62,58.91 164.62,60.24 168.33,63.96 168.33,70.72 169.49,71.89 169.67,71.89 177.42,79.63 177.42,80.59 179.49,82.66 179.49,83.8 185.68,89.99 185.68,104.97
  BOTTOM w0.102: JDIMM4.85 161.64,51.01 162.05,51.42 162.05,52.62 v2(162.78,53.36)
DDR_B_MA10: length 92.7
  TOP w0.102: JDIMM3.107 155.04,57.14 154.87,56.97 154.87,53.41 v2(153.73,52.26) ; v2(175.06,112.31) JCPU1.R9
  IN3 w0.089: v2(175.06,112.31) 174.8,112.31 174.68,112.19 174.68,111.15 174.93,110.91 174.99,110.91 175.46,110.44 175.46,110.38 175.9,109.93 178.25,109.93 178.68,109.5 178.68,104.09 177.6,103 177.6,102.81
  IN3 w0.178: v2(153.73,52.26) 153.37,51.9 153.37,49.49 153.55,49.31 154.05,49.31 154.23,49.49 154.23,52.89 154.38,53.05 154.38,56.91 155.03,57.56 155.03,58.82 155.32,59.1 155.32,63.32 156.16,64.16 156.16,70.87 159.06,73.78 159.06,75.02 171.59,87.55 171.59,88.69 173.12,90.22 173.12,90.9 177.6,95.37 177.6,102.81
  BOTTOM w0.102: v2(153.73,52.26) 154.75,53.28 155.09,53.28 155.3,53.07 155.3,51.68 155.04,51.42 JDIMM4.107
DDR_B_MA11: length 84
  TOP w0.102: v2(162.78,54.63) 162.35,54.19 162.35,51.21 161.94,50.81 JDIMM3.84 ; v2(181.12,112.39) 180.67,112.84 JCPU1.Y9
  IN3 w0.089: 184.67,103.77 184.67,109.69 184.43,109.93 183.12,109.93 182.72,110.33 182.72,110.6 182.46,110.87 181.84,110.87 181.63,111.07 181.63,111.75 181.12,112.26 v2(181.12,112.39)
  IN3 w0.178: v2(162.78,54.63) 162.58,54.42 162.43,54.42 162.28,54.57 162.28,56.11 162.86,56.69 162.86,58.62 163.21,58.97 163.21,60.47 163.65,60.92 163.65,61.1 163.59,61.16 163.59,61.42 163.82,61.65 164.07,61.65 164.23,61.49 164.45,61.49 164.61,61.65 164.61,61.87 164.41,62.07 164.41,62.29 164.57,62.45 164.79,62.45 164.99,62.25 165.21,62.25 165.36,62.4 165.36,62.62 165.16,62.82 165.16,63.04 165.32,63.2 165.54,63.2 165.74,63 165.96,63 166.12,63.16 166.12,63.38 165.94,63.55 165.94,63.8 166.12,63.97 166.39,63.97 166.57,63.79 166.76,63.79 167.33,64.37 167.33,70.55 166.98,70.9 166.98,71.11 168.4,72.54 168.4,73.3 168.63,73.53 168.92,73.53 178.44,83.06 178.44,84.2 184.66,90.42 184.66,103.76 184.67,103.77
  BOTTOM w0.102: JDIMM4.84 161.94,57.05 162.31,56.68 162.61,56.68 163.21,56.07 163.21,55.05 v2(162.78,54.63)
DDR_B_MA12: length 83.1
  TOP w0.102: JDIMM3.83 162.24,57.14 162.55,56.83 163.16,56.83 163.88,56.11 163.88,54.64 163.95,54.57 164.16,54.57 v2(164.34,54.75) ; v2(186.06,111.31) 186.53,110.84 JCPU1.AF7
  IN3 w0.089: 186.19,104.84 186.48,105.13 186.48,110.41 186.06,110.84 v2(186.06,111.31)
  IN3 w0.178: v2(164.34,54.75) 164.23,54.75 163.82,55.17 163.82,55.48 164.37,56.04 164.37,57.86 164.59,58.08 165.07,58.08 165.22,58.23 165.22,58.68 165.43,58.89 165.76,58.89 165.88,59.01 165.88,59.45 165.75,59.58 165.3,59.58 165.12,59.75 165.12,60.03 165.3,60.21 165.68,60.21 165.88,60.41 165.88,60.8 168.83,63.75 168.83,64.53 169.06,64.76 169.26,64.76 169.44,64.94 169.44,65.24 169.26,65.42 169.04,65.42 168.83,65.63 168.83,67.39 169.01,67.58 169.01,67.76 168.83,67.94 168.83,68.16 169.01,68.34 169.01,68.54 168.83,68.73 168.83,68.95 169.01,69.13 169.01,69.41 168.83,69.59 168.83,70.52 169.3,70.99 169.53,70.99 169.77,70.75 170.05,70.75 170.21,70.91 170.21,71.72 177.92,79.43 177.92,80.38 179.99,82.45 179.99,83.58 181.94,85.54 182.29,85.54 182.34,85.49 182.59,85.49 182.87,85.77 182.87,86.02 182.74,86.16 182.74,86.34 184.53,88.13 184.81,88.13 184.9,88.04 185.15,88.04 185.36,88.24 185.36,88.49 185.25,88.6 185.25,88.85 185.45,89.04 185.67,89.04 185.8,88.91 186.01,88.91 186.19,89.09 186.19,104.84
  BOTTOM w0.102: v2(164.34,54.75) 163.3,53.71 163.3,52.18 162.96,51.85 162.96,51.59 162.24,50.86 JDIMM4.83
DDR_B_MA13: length 92.5
  TOP w0.102: JCPU1.P9 174.57,112.84 v2(174.1,112.37) ; v2(151.57,53.2) 150.72,54.06 150.72,56.27 151.44,56.99 JDIMM3.119
  IN3 w0.089: v2(174.1,112.37) 173.68,111.95 173.68,109.15 173.97,108.86 174.16,108.86 174.49,108.54 174.49,108.07 174.86,107.71 175.22,107.71 175.47,107.47 175.47,106.32 175.73,106.05 175.73,105.07 176,104.81 176,103.87 174.55,102.42 174.55,102.32
  IN3 w0.178: 174.55,102.32 174.55,98.13 159.87,83.45 159.87,82.46 160.07,82.26 160.4,82.26 160.88,82.74 160.88,83.43 162.43,84.98 162.68,84.98 162.91,84.75 162.91,84.5 161.5,83.09 161.5,82.64 158.89,80.03 158.44,80.03 155.51,77.1 155.32,77.1 154.99,76.77 154.99,73.97 152.65,71.64 152.65,65.39 152.66,65.38 152.66,65.14 152.31,64.79 152.31,64.4 152.16,64.25 151.7,64.25 151.53,64.09 151.53,63.85 151.7,63.69 152.13,63.69 152.31,63.51 152.31,63.26 152.16,63.11 151.74,63.11 151.56,62.93 151.56,62.07 151.74,61.89 152.13,61.89 152.31,61.71 152.31,61.46 151.84,60.99 151.84,58.7 151.1,57.96 151.1,53.1 151.26,52.95 151.41,52.95 151.57,53.11 v2(151.57,53.2)
  BOTTOM w0.102: JDIMM4.119 151.44,51.25 151.17,51.52 151.17,52.8 v2(151.57,53.2)
DDR_B_MA14: length 91.2
  TOP w0.102: JCPU1.AA8 181.61,111.84 v2(182.12,112.35) ; JDIMM3.80 163.14,51.04 162.81,51.37 162.81,52.13 163.24,52.56 163.24,53.12 163.37,53.25 163.68,53.25 163.8,53.12 163.8,52.34 163.51,52.05 163.51,51.87 163.67,51.71 163.85,51.71 v2(164.33,52.18)
  IN3 w0.089: v2(182.12,112.35) 182.57,112.8 186.1,112.8 186.43,112.46 186.43,111.73 186.62,111.54 186.62,110.96 186.83,110.76 187.32,110.76 187.49,110.58 187.49,104 187.19,103.7 187.19,103.7
  IN3 w0.178: 187.19,103.7 187.19,88.66 181.27,82.74 181.13,82.74 180.98,82.6 180.98,82.04 178.91,79.97 178.91,79.01 171.2,71.31 171.2,70.5 170.46,69.76 170.46,63.98 166.88,60.4 166.88,58.48 165.4,57 165.4,54.17 165.86,53.71 165.86,52.06 165.63,51.83 164.68,51.83 v2(164.33,52.18)
  BOTTOM w0.102: JDIMM4.80 163.14,57.05 163.29,56.9 163.43,56.9 164.74,55.59 164.74,52.57 164.36,52.18 v2(164.33,52.18)
DDR_B_MA15: length 80.6
  TOP w0.102: v2(188.06,110.31) 187.59,110.78 JCPU1.AG7 ; v2(166.39,54.47) 166.39,54.45 165.77,53.82 165.74,53.82 164.92,53 164.92,51.93 164.2,51.21 164.1,51.21 163.74,50.85 JDIMM3.78
  IN3 w0.089: v2(188.06,110.31) 187.68,109.93 187.68,104.06 187.69,104.06 187.69,103.61
  IN3 w0.178: 187.69,103.61 187.69,88.46 181.48,82.24 181.48,81.83 180.34,80.69 180.34,80.4 180.54,80.2 180.54,79.95 180.26,79.67 180.01,79.67 179.76,79.91 179.56,79.91 179.41,79.76 179.41,78.81 171.7,71.1 171.7,69.69 171.55,69.53 171.14,69.53 170.97,69.36 170.97,68.92 171.14,68.75 171.55,68.75 171.7,68.59 171.7,65.85 171.52,65.67 171.14,65.67 170.97,65.49 170.97,65.24 171.14,65.06 171.75,65.06 171.93,64.88 171.93,64.74 171.65,64.46 171.14,64.46 170.96,64.28 170.96,63.77 167.39,60.2 167.39,58.29 165.91,56.8 165.91,54.42 166.04,54.29 166.21,54.29 v2(166.39,54.47)
  BOTTOM w0.102: JDIMM4.78 163.74,57.29 165.69,55.34 165.69,55.15 166.39,54.44 v2(166.39,54.47)
DDR_B_RAS#: length 89.2
  TOP w0.102: v2(153.74,54.83) 153.22,54.31 153.22,53.82 152.83,53.43 152.83,51.73 153.48,51.08 153.96,51.08 154.14,50.9 JDIMM3.110 ; v2(175.06,109.31) JCPU1.R6
  IN3 w0.089: 176.59,102.59 176.59,102.79 177.66,103.86 177.66,108.57 177.36,108.87 175.56,108.87 175.13,109.31 v2(175.06,109.31)
  IN3 w0.178: v2(153.74,54.83) 153.69,54.83 153.26,55.26 153.26,56.33 153.37,56.43 153.37,57.34 154.02,57.99 154.02,59.21 154.3,59.5 154.3,63.74 155.14,64.58 155.14,71.29 158.06,74.21 158.06,75.42 160.1,77.47 160.1,78.12 161.2,79.22 161.2,79.52 163.15,81.47 163.47,81.47 163.58,81.35 163.96,81.35 166.9,84.29 166.9,84.49 166.76,84.63 166.56,84.63 163.84,81.92 163.64,81.92 163.49,82.06 163.49,82.27 172.09,90.87 172.09,91.28 176.59,95.78 176.59,95.97 176.4,96.16 176.13,96.16 175.56,95.59 175.34,95.59 175.19,95.74 175.19,95.96 176.59,97.36 176.59,102.59
  BOTTOM w0.102: JDIMM4.110 154.14,56.91 154.33,56.72 154.33,55.39 153.77,54.83 v2(153.74,54.83)
DDR_B_WE#: length 92.1
  TOP w0.102: v2(174.06,109.31) JCPU1.P6 ; JDIMM3.113 153.24,56.99 152.4,56.15 152.4,54.16 152.28,54.04 152.11,54.04 151.99,54.16 151.99,55.69 151.81,55.87 v2(151.57,55.87)
  IN3 w0.089: 175.06,102.4 175.06,102.66 176.49,104.1 176.49,107.51 176.26,107.74 175.82,107.74 175.67,107.9 174.94,107.9 174.68,108.15 174.68,108.61 174.06,109.24 v2(174.06,109.31)
  IN3 w0.178: v2(151.57,55.87) 151.71,56.01 151.71,57.87 152.33,58.49 152.33,60.79 152.81,61.26 152.81,64.58 153.16,64.94 153.16,71.44 156.01,74.28 156.01,76.89 158.02,78.91 158.77,78.91 159.7,79.83 159.7,80.14 162,82.43 162,82.89 167.7,88.6 167.7,88.85 167.47,89.08 167.22,89.08 163.38,85.24 163.13,85.24 162.87,85.5 162.87,85.75 175.06,97.94 175.06,102.4
  BOTTOM w0.102: JDIMM4.113 153.24,50.93 152.47,51.7 152.47,54.97 v2(151.57,55.87)
DDR_CKE0_DIMM2: length 61.2
  TOP w0.102: JCPU1.AD9 184.59,112.78 v2(185.06,112.31)
  IN1 w0.089: v2(185.06,112.31) 185.4,111.79 185.6,111.49 185.6,111.24 185.93,110.91 186.28,110.91 186.62,110.57 186.62,110.07 186.46,109.91 186.46,108.82 186.67,108.6 186.67,104.16 188.78,102.06 188.78,101.94
  IN1 w0.178: v2(166.89,65.73) 167.4,66.25 167.4,67.5 168.2,68.3 168.2,70.95 169.02,71.77 169.02,72.71 173.68,77.37 173.68,77.5 176.97,80.79 177.1,80.79 179.33,83.02 179.5,83.02 188.78,92.3 188.78,101.94
  BOTTOM w0.102: JDIMM2.73 165.24,64.8 166.18,65.73 v2(166.89,65.73)
DDR_CKE1_DIMM2: length 61.9
  TOP w0.102: v2(184.06,112.31) 183.59,112.78 JCPU1.AC9
  IN1 w0.089: v2(184.06,112.31) 183.58,112.79 182.78,112.79 182.57,112.59 182.57,111.95 182.8,111.72 184.18,111.72 184.94,110.95 185.32,110.95 185.68,110.59 185.68,104.61 187.81,102.49 187.81,102.32
  IN1 w0.178: 187.81,102.32 187.81,92.7 179.1,83.99 178.93,83.99 176.7,81.76 176.57,81.76 172.71,77.9 172.71,77.77 167.95,73.01 167.95,72.18 167.09,71.32 167.09,70.51 v2(166.89,70.31)
  BOTTOM w0.102: JDIMM2.74 164.94,71.09 165.22,70.81 165.94,70.81 166.05,70.93 166.05,71.42 166.23,71.6 166.79,71.6 166.96,71.42 166.96,70.38 v2(166.89,70.31)
DDR_CKE2_DIMM4: length 76.4
  TOP w0.102: v2(187.06,113.31) 186.59,113.78 JCPU1.AF10
  IN3 w0.089: v2(187.06,113.31) 186.65,112.9 186.65,112.01 186.98,111.68 187.21,111.68 187.43,111.46 187.43,110.94 187.69,110.68 188.21,110.68 188.49,110.4 188.49,104.18 188.18,103.86 188.18,103.8
  IN3 w0.152: 188.18,103.8 188.18,88.26 181.96,82.04 181.96,81.58 181.05,80.67 181.05,79.76 172.72,71.43 172.72,64.84 167.94,60.06 167.94,59.12 168.08,58.98 168.32,58.98 168.47,58.82 168.47,58.55 168.32,58.4 168.1,58.4 167.94,58.24 167.94,58.13 166.46,56.66 166.46,55.84 v2(166.38,55.76)
  BOTTOM w0.102: v2(166.38,55.76) 166.38,55.72 166.83,55.27 166.83,52.39 166.09,51.65 165.91,51.65 165.24,50.98 JDIMM4.73
DDR_CKE3_DIMM4: length 72.4
  TOP w0.102: JCPU1.AG10 187.59,113.78 v2(188.06,113.31)
  IN3 w0.089: 189.09,104.57 189.09,104.73 189.46,105.09 189.46,110.44 189.21,110.68 188.87,110.68 188.49,111.06 188.49,111.41 188,111.9 187.93,111.9 187.68,112.15 187.68,112.93 v2(188.06,113.31)
  IN3 w0.152: 189.09,104.57 189.09,87.83 184.78,83.51 184.78,82.19 173.63,71.05 173.63,64.46 169.39,60.22 169.39,57.88 167.93,56.42 v2(167.93,56.11)
  BOTTOM w0.102: v2(167.93,56.11) 167.54,56.49 165.49,56.49 164.94,57.04 JDIMM4.74
DDR_CKE4_DIMM1: length 60
  TOP w0.102: v2(166.89,68.78) 166.66,68.78 166.43,69.01 166.43,70.12 165.24,71.31 JDIMM1.73 ; JCPU1.AD8 184.59,111.84 v2(185.1,111.33)
  IN1 w0.089: 188.3,102.11 188.3,102.27 186.48,104.09 186.48,108.52 186.03,108.98 186.03,109.74 186.43,110.15 186.43,110.48 186.21,110.71 185.85,110.71 185.34,111.21 185.21,111.21 v2(185.1,111.33)
  IN1 w0.178: 188.3,102.11 188.3,92.5 179.3,83.51 179.13,83.51 176.9,81.28 176.77,81.28 173.19,77.7 173.19,77.57 168.44,72.81 168.44,71.98 167.72,71.26 167.72,70.27 167.33,69.89 167.33,69.49 167.72,69.1 167.72,68.5 167.53,68.31 167.24,68.31 166.89,68.66 v2(166.89,68.78)
DDR_CKE5_DIMM1: length 60.6
  TOP w0.102: JDIMM1.74 164.94,65.45 166.75,67.26 v2(166.89,67.26) ; JCPU1.AC8 183.59,111.8 v2(183.11,111.32)
  IN1 w0.089: v2(183.11,111.32) 183.41,111.32 183.83,110.9 184.73,110.9 184.87,110.76 185.24,110.76 185.49,110.51 185.49,104.5 187.33,102.67 187.33,102.51
  IN1 w0.178: 187.33,102.51 187.33,92.9 178.9,84.47 178.73,84.47 176.5,82.24 176.37,82.24 172.23,78.1 172.23,77.97 167.47,73.21 167.47,72.38 166.4,71.31 166.4,67.85 166.89,67.37 v2(166.89,67.26)
DDR_CKE6_DIMM3: length 72.7
  TOP w0.102: JCPU1.AG9 187.59,112.78 v2(188.06,112.31) ; v2(167.89,54.75) 167.18,55.46 167.18,55.69 166.13,56.74 165.82,56.74 165.24,57.32 JDIMM3.73
  IN3 w0.089: 189.65,104.66 189.65,110.52 189.29,110.87 188.95,110.87 188.68,111.14 188.68,111.69 v2(188.06,112.31)
  IN3 w0.152: 189.65,104.66 189.55,104.56 189.55,87.64 185.23,83.33 185.23,82 174.88,71.65 174.88,65.06 170.31,60.49 170.31,59.41 169.85,58.95 169.85,57.7 168.4,56.25 168.4,55.26 v2(167.89,54.75)
DDR_CKE7_DIMM3: length 74.3
  TOP w0.102: JCPU1.AF9 186.59,112.78 v2(187.06,112.31) ; v2(166.37,53.18) 166.34,53.18 165.63,52.46 165.63,51.34 164.94,50.65 JDIMM3.74
  IN3 w0.089: v2(187.06,112.31) 187.06,112.11 187.62,111.54 187.62,111.02 187.77,110.87 188.29,110.87 188.68,110.48 188.68,104
  IN3 w0.152: v2(166.37,53.18) 166.92,53.73 166.92,56.47 168.04,57.58 168.44,57.58 168.93,58.07 168.93,60.41 173.18,64.65 173.18,71.24 181.51,79.57 181.51,80.48 182.42,81.39 182.42,81.85 188.63,88.07 188.63,103.95 188.68,104
DDR_CS0_DIMM2#: length 65.2
  TOP w0.102: JCPU1.M7 172.59,110.81 v2(172.06,110.28)
  IN1 w0.089: v2(172.06,110.28) 172.06,110.09 172.19,109.97 172.36,109.97 172.61,110.22 172.61,110.77 172.75,110.91 173.28,110.91 173.46,110.73 173.46,110.17 173.21,109.93 172.78,109.93 172.44,109.58 172.44,104.05 172.24,103.85
  IN1 w0.178: v2(149.91,76.54) 149.91,76.93 149.83,77 149.62,77 149.35,76.73 149.14,76.73 148.97,76.9 148.97,77.68 149.15,77.86 149.24,77.86 149.41,78.03 149.41,78.2 149.57,78.36 149.57,78.74 149.39,78.92 149.39,80.49 149.86,80.96 149.86,81.57 150.04,81.75 150.23,81.75 150.39,81.92 150.39,82.15 150.23,82.32 150.04,82.32 149.86,82.49 149.86,83.1 150.04,83.27 150.44,83.27 152.64,85.47 152.64,85.68 152.49,85.82 152.28,85.82 150.26,83.81 150.06,83.81 149.92,83.95 149.92,84.15 155.22,89.45 155.44,89.45 160.86,94.87 163.91,94.87 172.13,103.09 172.13,103.75 172.24,103.85
  BOTTOM w0.102: JDIMM2.114 152.94,75.52 152.23,76.23 150.22,76.23 v2(149.91,76.54)
DDR_CS1_DIMM2#: length 66.5
  TOP w0.102: v2(171.06,112.31) JCPU1.L9
  IN1 w0.089: v2(171.06,112.31) 170.62,111.87 169.82,111.87 169.49,111.54 169.49,104.08 169.29,103.87 169.11,103.87 168.16,102.93 168.05,102.93
  IN1 w0.178: 168.05,102.93 167.87,102.93 162.81,97.86 159.76,97.86 154.24,92.34 153.25,92.34 151.81,90.9 151.42,90.9 149.88,89.37 148.95,89.37 145.52,85.93 145.52,76.25 147.59,74.17 147.59,73.28 148.48,72.4 148.48,67.51 v2(150.53,65.46)
  BOTTOM w0.102: v2(150.53,65.46) 150.53,65.46 150.71,65.64 151.03,65.64 151.2,65.46 151.2,65.18 150.84,64.81 JDIMM2.121
DDR_CS2_DIMM4#: length 79.2
  TOP w0.102: v2(174.06,107.31) JCPU1.P4
  IN3 w0.089: 171.32,101.79 171.32,101.95 173.49,104.13 173.49,104.58 173.68,104.77 173.68,105.49 173.99,105.79 174.12,105.79 174.45,106.12 174.45,106.92 v2(174.06,107.31)
  IN3 w0.152: 171.32,101.79 171.32,100.79 164.54,94.01 164.54,92.69 155.21,83.36 153.66,83.36 152.43,82.14 152.43,79.43 151.71,78.71 151.71,78.22 150.57,77.08 149.67,77.08 149.27,76.68 149.27,72.9 148.13,71.76 148.13,65.01 147.5,64.38 147.5,58.89 147.84,58.55 147.84,51.96 148.02,51.78 149.25,51.78 149.43,51.96 149.43,52.8 150.1,53.48 v2(150.13,53.48)
  BOTTOM w0.102: JDIMM4.114 152.94,56.79 152.54,56.39 151.51,56.39 151.16,56.04 151.16,54.07 150.56,53.48 v2(150.13,53.48)
DDR_CS3_DIMM4#: length 75.5
  TOP w0.102: v2(174.92,105.37) 175.39,105.84 JCPU1.R2
  IN3 w0.089: v2(174.92,105.37) 174.62,105.08 174.62,104.17 172.69,102.24 172.69,102
  IN3 w0.152: 172.69,102 172.69,100.11 172.57,99.99 172.45,99.99 168.86,96.39 168.86,96.2 168.99,96.07 169.18,96.07 170.94,97.83 171.14,97.83 171.28,97.69 171.28,97.49 155.69,81.9 154.96,81.9 154.68,81.62 154.68,81.21 154.31,80.85 154.31,79.37 153.08,78.14 153.08,74.77 149.5,71.19 149.5,61.2 149.3,61 149.3,60.67 149.5,60.47 149.5,60.19 149.3,59.98 149.3,59.73 149.5,59.53 149.5,59.32 149.21,59.03 149.21,55.28 v2(148.76,54.83)
  BOTTOM w0.102: JDIMM4.121 150.84,50.97 150.35,51.46 149.77,51.46 148.31,52.92 148.31,54.6 148.54,54.83 v2(148.76,54.83)
DDR_CS4_DIMM1#: length 66.8
  TOP w0.102: JDIMM1.114 152.94,66.68 152.79,66.83 152.13,66.83 151.33,67.63 151.33,68.38 150.53,69.18 v2(150.53,69.27) ; JCPU1.M9 v2(172.06,112.31)
  IN1 w0.089: 170.46,103.47 170.62,103.63 170.62,110.49 171.04,110.91 171.25,110.91 171.44,111.1 171.44,111.69 v2(172.06,112.31)
  IN1 w0.178: v2(150.53,69.27) 150.29,69.27 149.93,69.63 149.93,73 149.04,73.88 149.04,74.77 147.46,76.36 147.46,78.22 147.94,78.7 147.94,79.01 147.46,79.49 147.46,80.33 147.94,80.81 147.94,81.64 147.75,81.83 147.24,81.83 146.96,82.11 146.96,85.33 149.55,87.92 150.48,87.92 152.02,89.45 152.41,89.45 153.85,90.89 154.84,90.89 160.28,96.33 163.33,96.33 170.12,103.12 170.12,103.13 170.46,103.47
DDR_CS5_DIMM1#: length 68.6
  TOP w0.102: JDIMM1.121 150.84,74.29 v2(149.97,75.16) ; JCPU1.M10 v2(172.06,113.31)
  IN1 w0.089: 171.63,104.08 171.63,104.53 171.8,104.71 171.8,104.97 171.63,105.14 171.63,105.93 171.32,106.24 171.32,106.57 171.63,106.87 171.63,109.92 171.68,109.97 171.68,111.53 172.05,111.9 173.53,111.9 173.68,112.05 173.68,113.55 173.51,113.73 171.88,113.73 171.78,113.63 171.78,113.48 171.94,113.31 v2(172.06,113.31)
  IN1 w0.178: v2(149.97,75.16) 149.97,75.24 149.5,75.71 149.5,76.06 149.33,76.24 148.95,76.24 148.46,76.72 148.46,77.86 148.91,78.3 148.91,79.45 148.64,79.72 148.64,80.11 148.91,80.38 148.91,80.69 149.38,81.16 149.38,81.95 149.17,82.16 148.79,82.16 148.23,82.71 148.23,84.6 149.6,85.96 149.81,85.96 149.96,85.82 149.96,85.61 148.77,84.42 148.77,82.87 148.94,82.69 149.2,82.69 149.38,82.87 149.38,84.29 155.02,89.93 155.24,89.93 160.66,95.35 163.71,95.35 171.63,103.26 171.63,104.08
DDR_CS6_DIMM3#: length 77.2
  TOP w0.102: v2(151.6,51.8) 152.02,51.8 152.94,50.88 JDIMM3.114 ; JCPU1.P3 v2(174.06,106.31)
  IN3 w0.089: 170.9,102.08 172.68,103.87 172.68,104.54 172.9,104.75 173.2,104.75 173.49,105.04 173.49,105.74 v2(174.06,106.31)
  IN3 w0.152: v2(151.6,51.8) 151.89,51.8 152.07,51.63 152.07,51.16 151.89,50.98 147.53,50.98 147.38,51.14 147.38,58.36 147.04,58.7 147.04,64.68 147.67,65.32 147.67,71.95 148.74,73.01 148.74,76.8 149.93,77.99 149.93,78.09 150.25,78.41 150.76,78.41 151.97,79.62 151.97,82.33 153.47,83.82 155.02,83.82 164.08,92.88 164.08,94.2 170.86,100.98 170.86,102.04 170.9,102.08
DDR_CS7_DIMM3#: length 74.9
  TOP w0.102: JCPU1.P1 v2(174.06,104.31) ; JDIMM3.121 150.84,57.01 150.37,56.54 149.71,56.54 149.27,56.1 v2(148.76,56.1)
  IN3 w0.089: 172.23,101.97 172.23,102.1 174.06,103.92 v2(174.06,104.31)
  IN3 w0.152: 172.23,101.97 172.23,100.41 165.45,93.63 165.45,93.44 165.59,93.3 165.78,93.3 168.33,95.85 168.52,95.85 168.66,95.71 168.66,95.52 168.32,95.18 155.5,82.36 154.77,82.36 154.68,82.45 154.04,82.45 153.35,81.76 153.35,81.29 153.86,80.78 153.86,79.56 152.63,78.33 152.63,77.79 152.17,77.33 152.17,76.47 151.87,76.16 151.87,75.4 152.17,75.1 152.17,74.5 149.05,71.38 149.05,64.11 148.92,63.98 148.52,63.98 148.41,63.87 148.41,63.62 148.56,63.47 148.89,63.47 149.04,63.32 149.04,63.02 148.89,62.86 148.56,62.86 148.41,62.71 148.41,62 148.56,61.85 148.88,61.85 149.03,61.7 149.03,61.39 148.88,61.24 148.56,61.24 148.41,61.09 148.41,59.27 148.75,58.93 148.75,56.11 v2(148.76,56.1)
DDR_HVREF_RST_PCH: length 288.1
  TOP w0.076: 68.55,64.1 68.55,64.66 68.78,64.88 69.19,64.88 69.59,64.48 70.8,64.48 v2(71.27,64)
  TOP w0.102: v2(209.65,88.53) 208.85,89.33 QD9.2 209.4,89.9 CD92.1 ; RC104.2 203.6,111.68 205.13,113.21 206.64,113.21 207.83,112.02 v2(208.15,112.02) ; v2(113.71,52.44) 113.41,52.74 113.41,57.98 113.87,58.43 115.66,58.43 116.56,59.33 116.56,65.97 116.74,66.15 116.74,67.54 118.34,69.14 118.34,70.42 123.29,75.38 123.29,79.9 124.56,81.17 126.36,81.17 127.05,80.48 131.19,80.48 132.88,82.17 QD7.2 ; QD6.5 QD6.2 168.98,45.02 168.15,45.86 168.15,46.14 166.14,48.15 v2(166.14,48.1) ; RH170.2 63.05,62.17 63.81,62.93 v1(64.43,62.93) 67.38,62.93 68.55,64.1
  IN3 w0.089: v2(71.27,64) 71.68,63.59 72.49,63.59 72.9,63.18 72.9,62.45 72.54,62.09 72.26,62.09 71.91,61.74 71.91,61.5
  IN3 w0.127: 71.91,61.5 71.91,59.54 72.31,59.14 77.6,59.14 78.02,58.73 82.64,58.73 83.05,58.32 85,58.32 85.16,58.48 89,58.48 89.28,58.76 92.48,58.76 93.5,57.74 95.06,57.74 96.53,56.26 100.76,56.26 104.07,52.95 113.21,52.95 v2(113.71,52.44) 114.22,52.95 118.92,52.95 121.82,50.05 122.48,50.05 124.87,47.66 147.52,47.66 147.94,47.24 149.09,47.24 150.71,45.62 163.66,45.62 v2(166.14,48.1) 167.68,49.64 167.68,49.64 188.87,49.64 190.47,51.25 191.39,51.25 196.85,56.71 196.85,57.77 200.66,61.58 200.66,66.38 205.69,71.41 205.69,76.82 207.64,78.78 207.64,82.21 208.86,83.43 208.86,84.77 209.65,85.56 v2(209.65,88.53) 208.25,89.93 208.25,93.92 208.71,94.37 208.71,94.97 206.55,97.13 206.55,102.07 207.01,102.53 207.01,103.47 208.15,104.61 v2(208.15,112.02)
  BOTTOM w0.102: UH1.N8 70.94,63.54 71.27,63.87 v2(71.27,64)
DDR_XDP_WAN_SMBCLK: length 311.7
  TOP w0.102: v2(127.2,60.9) 127.35,61.05 127.35,61.69 126.73,62.32 126.73,62.71 126.54,62.9 JDIMM1.202 126.54,65.2 126.73,65.39 126.73,67.86 125.63,68.95 125.4,68.95 v2(125.25,68.8) ; U88.4 177.27,40.49 R502.2 177.47,39 177.85,39.38 177.85,39.64 178.31,40.09 181.1,40.09 181.53,40.53 181.63,40.63 181.63,44.14 181.39,44.38 181.39,44.82 180.74,45.47 180.74,45.58 v2(180.92,45.76) ; JDIMM3.202 126.54,48.95 126.77,48.72 126.77,47.84 126.11,47.18 126.11,46.88 v2(125.86,46.62) ; v2(39.57,88.2) 39.77,88 39.89,88 40.62,88.74 47.65,88.74 53.67,94.76 57.68,94.76 58.05,94.38 58.05,94.2 v2(58.31,93.94)
  IN1 w0.109: v2(180.92,45.76) 180.85,45.83 180.85,45.86 180.08,46.63 173.28,46.63 172.87,46.22 127.58,46.22 126.77,47.03 126.26,47.03 v2(125.86,46.62) ; v2(133.09,127.55) 132.92,127.72 132.23,127.72 131.34,126.84 131.34,120.64 127.61,116.9 127.61,96.86 127.41,96.66 127.41,87.62 126.57,86.78 126.57,69.66 125.91,69 125.7,69 125.45,69 v2(125.25,68.8)
  BOTTOM w0.102: QH4.1 37.39,84.65 37.41,84.79 37.36,84.88 37.36,85.69 38.14,86.48 38.25,86.58 39.12,87.46 39.12,87.75 v2(39.57,88.2) 39.78,88 39.95,88 RH31.1 ; v2(58.31,93.94) 58.09,94.16 58.09,94.37 60.25,96.53 86.08,96.53 87.6,95.01 106.55,95.01 108.96,97.42 121.61,97.42 123.01,96.03 123.01,91.78 123.67,91.12 124.94,91.12 128.8,87.26 128.8,76.46 126.73,74.38 126.73,73.59 126.54,73.4 JDIMM2.202 126.54,71.26 126.73,71.08 126.73,70.96 126.16,70.4 125.28,70.4 124.53,69.65 124.53,69.26 124.82,68.97 125.07,68.97 v2(125.25,68.8) ; v2(125.86,46.62) 126.06,46.83 126.06,47.7 124.28,49.47 124.28,52.66 125.73,54.11 125.73,56.05 126.54,56.86 JDIMM4.202 126.54,59.21 126.73,59.4 126.73,60.01 127.35,60.64 127.35,60.74 v2(127.2,60.9) ; v2(133.09,127.55) 133.25,127.7 133.42,127.7 133.76,128.04 133.76,138.24 131.27,140.73 128.93,140.73 128.01,141.64 126.19,141.64 126.13,141.7 U23.13
