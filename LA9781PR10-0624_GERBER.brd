# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS: length 2.9
  TOP w0.254: U44.19 3.02,148.92 2.79,148.69 v2(2.78,148.69)
  BOTTOM w0.254: v2(2.78,148.69) 3.38,149.29 R852.1 R851.1
PS2_CLK_TS: length 175.6
  TOP w0.102: v2(76.36,91.84) 84.39,91.84 87.54,88.68 98.27,88.68 103.2,83.76 113.15,83.76 115.01,85.61 124.04,85.61 125.18,86.75 125.49,86.75 125.82,87.08 126.56,87.08 130.78,91.31 130.78,99.43 130.5,99.72 JKB1.4 JKB1.3 ; JIO1.116 23.07,68.7 26.39,72.02 26.39,79.36 v2(26.36,79.39)
  IN1 w0.109: v2(76.36,91.84) 76.36,92.46 68.68,100.14 47.48,100.14 46.69,100.93 20.79,100.93 19.68,99.82 19.68,83.2 23.91,78.98 25.96,78.98 v2(26.36,79.39)
PS2_DAT_TS: length 172.7
  TOP w0.102: v2(75.91,92.28) 84.24,92.28 87.63,88.89 98.47,88.89 103.4,83.96 113.07,83.96 114.92,85.81 123.95,85.81 125.09,86.96 125.41,86.96 125.59,87.14 125.74,87.29 126.47,87.29 130.15,90.96 130.15,99.1 129.5,99.75 JKB1.6 JKB1.5 ; v2(25.77,79.4) 26.19,78.98 26.19,72.11 23.38,69.3 JIO1.114
  IN1 w0.109: v2(25.77,79.4) 23.79,79.4 19.94,83.25 19.94,99.71 20.93,100.7 46.18,100.7 47.09,99.78 68.4,99.78 v2(75.91,92.28)
PS_ID: length 277.7
  TOP w0.102: v1(11.2,98.78) 10.87,99.11 PU1.4 9.48,99.11 9.48,98.67 v2(9.35,98.54)
  IN4 w0.109: v2(243.74,39.97) 243.1,39.33 236.35,39.33 235.05,40.63 229.56,40.63 226.29,43.9 221.08,43.9 220.39,44.59 209.37,44.59 208.23,45.73 205.2,45.73 204.36,44.9 199.59,44.9 196.8,42.11 189.29,42.11 188.7,41.52 177.87,41.52 177.54,41.19 172.58,41.19 171.46,40.07 121.65,40.07 120.07,41.64 105.34,41.64 103.46,43.53 83.47,43.53 82.29,44.71 79.47,44.71 79.04,44.28 76.85,44.28 76.64,44.48 72.89,44.48 71.81,45.56 65.96,45.56 65.25,44.84 64.26,44.84 63.55,45.56 63.32,45.56 58.29,50.58 56.64,50.58 54.33,52.89 54.33,53.91 50.56,57.69 50.56,65.44 45.16,70.84 44.97,70.84 43.9,71.91 43.53,71.91 40.69,74.75 39.45,74.75 37.89,76.31 37.89,77.73 35.11,80.51 29.23,80.51 27.96,81.78 21.45,81.78 17.46,85.77 15.8,85.77 14.01,87.56 14.01,91.52 9.35,96.18 v2(9.35,98.54)
  BOTTOM w0.102: v2(243.74,39.97) 243.74,40.09 243.8,40.16 U51.A55
PSATA_PRX_DTX_N0: length 2.4
  BOTTOM w0.102: U26.4 181.35,37.78 181.21,37.92 180.58,37.92 180.38,38.13 180.22,38.13 C418.1
PSATA_PRX_DTX_N0_BP: length 8.6
  TOP w0.102: C394.2 187.51,38.13 186.55,38.13 186.13,38.55 v3(185.81,38.55) 181.99,38.55 181.55,38.11 180.96,38.11 180.95,38.12 180.22,38.12 R1646.2
PSATA_PRX_DTX_N0_C: length 174.2
  TOP w0.102: v2(178.31,37.22) 178.05,37.49 178.05,37.66 178.41,38.02 178.73,38.02 R1646.1
  IN1 w0.117: v2(68.76,78.84) 68.92,78.67 68.92,78.29 68.74,78.11 64.17,78.11 61.54,75.47 61.54,74.78 60.87,74.12 60.39,74.12 58.88,72.61 58.88,65.14 58.16,64.43 58.16,61.21 57.52,60.56 57.52,55.72 58.18,55.06 58.18,51.05 60.54,48.69 60.54,47.49 69.05,38.98 88.28,38.98 89.53,37.73 98.68,37.73 99.38,38.44 101.22,38.44 101.27,38.38 112.14,38.38 113.36,37.17 116.21,37.17 118.47,34.91 156.06,34.91 157.12,33.85 170.49,33.85 171.55,34.91 177.69,34.91 178.31,35.52 v2(178.31,37.22)
  BOTTOM w0.076: UH1.BC8 71.03,76.43 70.77,76.91 70.41,77.27 70.41,77.54 70.31,77.64 70.29,77.62 70.28,77.64
  BOTTOM w0.102: v2(68.76,78.84) 68.85,78.75 68.85,78.4 69.13,78.12 69.79,78.12 70.28,77.64 ; v2(178.31,37.22) 178.05,37.49 178.05,37.66 178.41,38.02 178.73,38.02 R1646.1
PSATA_PRX_DTX_N0_RP: length 2.4
  BOTTOM w0.102: U26.12 186.36,37.78 186.5,37.92 187.08,37.92 187.29,38.13 187.51,38.13 C385.2
PSATA_PRX_DTX_P0: length 2.4
  BOTTOM w0.102: U26.5 181.35,38.28 181.21,38.13 180.67,38.13 180.47,38.34 180.21,38.34 C421.1
PSATA_PRX_DTX_P0_BP: length 8.6
  TOP w0.102: C393.2 187.53,38.34 186.64,38.34 186.21,38.77 185.55,38.77 185.53,38.76 181.9,38.76 181.48,38.34 v3(181.23,38.34) 180.22,38.34 R1645.2
PSATA_PRX_DTX_P0_C: length 174.6
  TOP w0.102: v2(177.66,37.22) 177.83,37.39 177.83,37.75 178.32,38.24 178.76,38.24 178.97,38.44 R1645.1
  IN1 w0.117: v2(69.39,78.83) 69.16,78.6 69.16,78.19 68.84,77.87 64.27,77.87 61.77,75.38 61.77,74.69 60.97,73.88 60.48,73.88 59.11,72.51 59.11,65.04 58.4,64.33 58.4,61.11 57.76,60.47 57.76,55.82 58.42,55.16 58.42,51.15 60.78,48.79 60.78,47.59 69.15,39.22 88.38,39.22 89.63,37.97 98.58,37.97 99.28,38.67 101.32,38.67 101.37,38.62 112.24,38.62 113.46,37.4 116.31,37.4 118.57,35.14 156.16,35.14 157.22,34.08 170.39,34.08 171.45,35.14 177.6,35.14 178.07,35.62 178.07,36.81 v2(177.66,37.22)
  BOTTOM w0.076: 70.43,77.79 70.45,77.78 70.43,77.76 70.58,77.61 70.58,77.34 70.69,77.23 70.78,77.23 70.97,77.42 71.06,77.42 71.22,77.26 71.22,77.15 71.14,77.07 UH1.BE8
  BOTTOM w0.102: v2(69.39,78.83) 69.24,78.83 69.18,78.77 69.18,78.72 69.06,78.6 69.06,78.49 69.22,78.34 69.88,78.34 70.43,77.79 ; R1645.1 178.97,38.44 178.76,38.24 178.32,38.24 177.83,37.75 177.83,37.39 v2(177.66,37.22)
PSATA_PRX_DTX_P0_RP: length 2.4
  BOTTOM w0.102: U26.11 186.36,38.28 186.5,38.13 186.99,38.13 187.2,38.34 187.53,38.34 C386.2
PSATA_PTX_DRX_N0: length 2.4
  BOTTOM w0.102: U26.2 181.4,36.78 181.26,36.63 180.81,36.63 180.62,36.44 180.21,36.44 C422.1
PSATA_PTX_DRX_N0_BP: length 8.6
  TOP w0.102: R1644.2 180.22,36.43 v3(181.91,36.43) 182.3,36.43 182.75,35.98 185.67,35.98 185.69,35.99 186.18,35.99 186.61,36.42 187.51,36.42 C389.2
PSATA_PTX_DRX_N0_C: length 165.6
  TOP w0.102: R1644.1 178.57,36.37 177.6,36.37 v2(177.24,36.73)
  IN1 w0.117: v2(177.24,36.73) 177.24,36.49 177.17,36.42 177.07,36.42 176.89,36.24 176.62,36.24 176.38,36.01 170.96,36.01 169.93,34.97 157.81,34.97 156.77,36 122.23,36 119.97,38.27 113.84,38.27 112.3,39.8 102.43,39.8 102.28,39.94 100.99,39.94 100.86,39.82 98.37,39.82 97.86,39.31 90.27,39.31 89.5,40.08 71.44,40.08 70.67,40.85 70.67,40.93 70.07,41.52 68.09,41.52 63.55,46.06 63.55,47.34 59.41,51.48 59.41,55.47 59.03,55.85 59.03,60.52 59.41,60.9 59.41,61.91 61.52,64.02 61.52,73.21 62.63,74.33 62.63,74.84 63.71,75.91 64.15,75.91 64.26,75.79 64.64,75.79 64.75,75.91 65.1,75.91 65.22,75.79 65.59,75.79 65.71,75.91 66.22,75.91 66.6,75.53 67.69,75.53 68.41,74.82 69.5,74.82 69.79,74.52 70.32,74.52 v2(70.46,74.38)
  BOTTOM w0.089: UH1.AW8 70.8,74.38 v2(70.46,74.38)
  BOTTOM w0.102: v2(177.24,36.73) 177.6,36.37 178.57,36.37 R1644.1
PSATA_PTX_DRX_N0_RP: length 2.4
  BOTTOM w0.102: U26.14 186.36,36.78 186.5,36.63 186.92,36.63 187.12,36.43 187.52,36.43 C384.2
PSATA_PTX_DRX_P0: length 2.4
  BOTTOM w0.102: U26.1 181.4,36.28 181.26,36.42 180.9,36.42 180.71,36.22 180.22,36.22 C423.1
PSATA_PTX_DRX_P0_BP: length 8.6
  TOP w0.102: C390.2 187.53,36.21 186.7,36.21 186.26,35.76 v3(185.95,35.76) 182.66,35.76 182.22,36.2 181.65,36.2 181.63,36.21 180.22,36.21 R1643.2
PSATA_PTX_DRX_P0_C: length 165.6
  TOP w0.102: R1643.1 178.69,36.16 177.4,36.16 v2(177.24,36)
  IN1 w0.117: v2(177.24,36) 176.72,36 176.48,35.77 171.06,35.77 170.03,34.74 157.71,34.74 156.68,35.77 122.13,35.77 119.87,38.03 113.74,38.03 112.21,39.56 102.33,39.56 102.19,39.71 101.09,39.71 100.96,39.58 98.47,39.58 97.96,39.07 90.17,39.07 89.4,39.85 71.34,39.85 70.43,40.75 70.43,40.83 69.98,41.29 67.99,41.29 63.31,45.97 63.31,47.25 59.17,51.39 59.17,55.37 58.79,55.75 58.79,60.61 59.17,61 59.17,62.01 61.28,64.12 61.28,73.31 62.4,74.43 62.4,74.93 63.61,76.14 66.32,76.14 66.7,75.76 67.79,75.76 68.5,75.05 69.6,75.05 69.89,74.76 70.07,74.76 v2(70.25,74.94)
  BOTTOM w0.089: UH1.AY8 70.76,74.94 v2(70.25,74.94)
  BOTTOM w0.102: R1643.1 178.69,36.16 177.4,36.16 v2(177.24,36)
PSATA_PTX_DRX_P0_RP: length 2.4
  BOTTOM w0.102: C383.2 187.52,36.21 187.03,36.21 186.83,36.42 186.5,36.42 186.36,36.28 U26.15
PSID_DISABLE#: length 269.6
  TOP w0.102: PR13.2 10.69,95.67 v2(10.57,95.54)
  IN3 w0.127: v2(204.13,45.58) 204.42,45.58 220.32,61.48 221.67,61.48 222.58,62.39 222.58,63.53 225.02,65.98 225.22,65.98 225.22,66.04 v2(225.21,66.04)
  IN4 w0.109: v2(10.57,95.54) 14.22,91.89 14.22,87.64 15.89,85.98 19.91,85.98 20.31,85.57 21.79,85.57 25.23,82.13 32.56,82.13 33.67,81.02 34.97,81.02 38.1,77.89 38.1,76.4 39.54,74.96 40.78,74.96 43.5,72.24 43.89,72.24 45.07,71.06 45.24,71.06 50.77,65.53 50.77,57.78 54.54,54 54.54,52.99 56.72,50.81 58.37,50.81 63.4,45.78 63.96,45.78 64.54,45.2 65.31,45.2 65.89,45.78 71.88,45.78 72.97,44.69 76.73,44.69 76.94,44.49 78.96,44.49 79.39,44.92 82.46,44.92 83.64,43.74 103.54,43.74 105.42,41.86 120.15,41.86 121.74,40.28 171.37,40.28 172.49,41.4 177.45,41.4 177.78,41.73 188.62,41.73 189.2,42.32 196.71,42.32 199.54,45.15 203.7,45.15 v2(204.13,45.58)
  BOTTOM w0.102: U46.A37 232.39,67.66 232.08,67.35 231.06,67.35 230.91,67.5 227.35,67.5 v1(226.53,66.68) 226.26,66.41 226.26,65.82 226.06,65.62 225.58,65.62 225.22,65.98 225.22,66.04 v2(225.21,66.04)
PWM3: length 70.4
  TOP w0.203: PU500.22 156.55,166.45 157.05,165.95 157.05,165.39 v2(157.17,165.27)
  TOP w0.254: PR523.2 162.13,164.28 163.22,165.36 v2(163.22,165.9) ; PU501.3 201.34,167.96 201.71,167.59 v2(201.98,167.59)
  IN3 w0.254: v2(163.22,165.9) 162.79,165.47 157.38,165.47 v2(157.17,165.27)
  BOTTOM w0.254: v2(201.98,167.59) 202.02,167.55 202.78,167.55 203.44,168.21 203.44,174.85 202.59,175.71 165.23,175.71 163.5,173.98 v1(163.5,168.24) 163.5,166.18 v2(163.22,165.9)
PWR_SRC_ON: length 8.3
  BOTTOM w0.102: v1(99.02,159.5) 100.16,158.36 Q21.3 101.83,158.12 C297.2 102.37,158.14 104.07,159.84 104.33,159.84 R423.1 R422.2
PWRSHARE_EN#: length 6.8
  BOTTOM w0.102: U45.4 296.02,61.54 295.5,61.02 293.8,61.02 R816.1 291.94,61.23 Q55.1 291.28,61.34 290.73,60.8 v1(290.73,60.43)
RED_CRT: length 96.6
  IN4 w0.109: v2(85.44,163.34) 85.93,163.34 87.08,164.49 89.81,164.49 90.53,163.77 92.56,163.77 93.52,162.8 95.06,162.8 104.08,153.78 110.28,153.78 113.55,150.51 113.55,147.58 113.21,147.23 113.21,143.98 113.55,143.63 113.55,141.33 112.01,139.79 112.01,137.26 107.75,132.99 107.75,127.81 108.39,127.17 108.39,126.05 108.08,125.74 108.08,123.99 108.39,123.69 108.39,117.12 106.13,114.86 106.13,113.21 105.53,112.61 105.53,107.5 104.65,106.62 v2(104.32,106.62)
  BOTTOM w0.102: U19.33 99.13,106.54 99.39,106.79 v1(103.64,106.79) 104.14,106.79 v2(104.32,106.62) ; v2(85.44,163.34) 83.89,163.34 82.78,162.22 81.86,162.22 R53.1 C20.1 81.25,160.72 L1.1
RED_CRT_L: length 42.2
  TOP w0.102: v2(77.7,162.19) 78.4,161.49 78.4,158.24 v2(77.95,157.8)
  IN1 w0.109: JCRT1.1 81.55,171.81 81,171.26 78.66,171.26 76.96,169.56 76.96,163.23 76.48,162.75 76.48,157.21 v2(72.36,153.1)
  BOTTOM w0.102: v2(72.36,153.1) 72.36,153.45 73.1,154.19 75.49,154.19 76.47,155.17 v1(76.47,155.96) 76.47,156.57 77.7,157.8 v2(77.95,157.8) ; L1.2 79.36,161.47 C21.1 77.9,161.99 v2(77.7,162.19)
RED_DOCK: length 12.1
  IN3 w0.127: v2(94.92,116.73) 95.15,116.73 95.45,116.42 95.45,115.63 94.38,114.57 v2(94.38,110.12)
  BOTTOM w0.102: v2(94.38,110.12) v1(95.11,109.4) U19.24 ; JDOCK1.53 95.74,117.98 95.38,117.62 95.38,117.18 95.35,117.16 95.35,117.16 95.1,116.9 95.1,116.9 v2(94.92,116.73)
REGCTL_PNP10: length 12.9
  TOP w0.203: v3(115.59,91.91) 115.42,92.09 U31.7
  IN4 w0.254: v2(108.28,86.41) 108.28,87.67 109.64,89.02 112.39,89.02 115.28,91.91 v3(115.59,91.91)
  BOTTOM w0.254: L29.1 107.8,85.55 108.28,86.02 v2(108.28,86.41)
REM_DIODE1_N: length 134.1
  TOP w0.254: v2(239.11,48.1) 238.96,48.25 236.67,48.25 236.32,48.6 234.49,48.6 233.97,49.12 v2(233.83,49.12) ; v2(189.89,120.92) 189.8,121.01 189.33,121.01 C339.1 186.46,120.83 Q26.3
  IN4 w0.254: v2(221.6,69.05) 221.61,69.06 221.61,70.49 215.42,76.69 215.42,83.81 209.09,90.13 209.09,90.73 204.77,95.05 204.77,103.83 207.52,106.57 207.52,110.09 199.44,118.17 199.44,120.94 197.44,122.94 191.84,122.94 191.33,122.43 191.33,121.51 190.74,120.92 v2(189.89,120.92)
  BOTTOM w0.254: C1343.1 234.43,49.12 v2(233.83,49.12) 233.49,49.12 232.82,49.8 232.68,49.8 232.18,50.29 229.27,50.29 226.8,47.82 226.8,46.28 225.73,45.22 225.73,43.83 224.67,42.76 221.65,42.76 216.25,48.16 216.25,55.69 v1(217.14,56.58) 217.47,56.91 217.47,64.02 221.64,68.19 221.64,69.01 v2(221.6,69.05) ; v2(239.11,48.1) 239.04,48.17 U51.B13
REM_DIODE1_N_4021: length 35.1
  TOP w0.254: v2(35.71,104.46) v1(36.33,104.46) 39.91,104.46 40.37,104 51.49,104 55.03,100.46 55.78,100.46 C273.2 55.94,100.62 Q16.3
  BOTTOM w0.254: U29.23 36.15,96.59 36.9,97.35 C270.2 37.08,97.9 37.08,99.42 35.71,100.79 v2(35.71,104.46)
REM_DIODE1_P: length 131.8
  TOP w0.254: v2(189.92,121.52) 189.39,121.52 C339.2 188.58,121.74 Q26.1 187.01,121.38 Q26.2
  IN4 w0.254: v2(222.19,69.05) 222.12,69.12 222.12,70.7 215.92,76.9 215.92,84.02 209.6,90.34 209.6,90.95 205.28,95.26 205.28,103.62 208.02,106.36 208.02,110.3 199.95,118.38 199.95,121.15 197.65,123.45 191.63,123.45 190.82,122.64 190.82,121.72 190.62,121.52 v2(189.92,121.52)
  BOTTOM w0.254: v2(222.19,69.05) 222.15,69.01 222.15,67.98 217.98,63.81 217.98,56.7 216.76,55.48 216.76,48.37 221.86,43.27 224.45,43.27 225.22,44.04 225.22,45.43 226.29,46.5 226.29,48.03 229.06,50.8 232.39,50.8 232.89,50.31 233.03,50.31 233.66,49.67 235.02,49.67 235.38,49.31 C1343.2 236.09,49.09 236.76,48.42 U51.A13
REM_DIODE1_P_4021: length 34.6
  TOP w0.254: Q16.2 58.49,99.97 Q16.1 56.2,99.97 C273.1 55.65,99.95 54.82,99.95 51.28,103.49 40.16,103.49 39.7,103.95 36.37,103.95 v2(36.3,103.87)
  BOTTOM w0.254: v2(36.3,103.87) 36.22,103.8 36.22,101.03 37.59,99.66 37.59,97.96 C270.1 37.82,97.49 v1(37.1,96.77) 36.65,96.31 U29.24
REM_DIODE2_N: length 64.9
  TOP w0.254: v2(239.7,48.09) 239.7,48.16 239.07,48.78 237.8,48.78 236.96,49.62 236.24,49.62 v2(235.99,49.87) ; Q17.3 184.82,45.58 186.64,45.58 C340.2 186.89,45.86 187.1,45.66 187.6,45.66 188.09,45.17 v1(198.27,45.17) 198.7,45.17 199.11,44.77 204,44.77 205.43,46.19 209.73,46.19 212.06,43.85 218.82,43.85 220.96,45.99 225.75,45.99 227.02,44.72 227.99,44.72 v2(228.01,44.74)
  IN3 w0.254: v2(228.01,44.74) 228.01,44.99 228.87,45.84 228.87,47.37 231.21,49.72 234.34,49.72 234.49,49.87 v2(235.99,49.87)
  BOTTOM w0.254: U51.B14 239.21,48.67 239.7,48.17 v2(239.7,48.09) ; v2(235.99,49.87) 235.63,50.23 C1350.1
REM_DIODE2_N_4021: length 6.7
  BOTTOM w0.254: U29.26 v1(38.61,94.28) 39.37,94.28 C294.1 C291.2 43.15,94.5 Q27.3
REM_DIODE2_P: length 65
  TOP w0.254: Q17.1 183.45,44.45 Q17.2 185.35,45.15 v1(185.76,45.15) 186.71,45.15 C340.1 186.89,44.95 187.1,45.15 187.39,45.15 187.88,44.67 198.49,44.67 198.9,44.26 204.21,44.26 205.64,45.68 209.52,45.68 211.85,43.35 219.04,43.35 221.17,45.48 225.54,45.48 226.81,44.21 227.96,44.21 v2(228.01,44.16) ; v2(233.81,50.23) 233.96,50.23 235.08,49.11 236.75,49.11 v2(236.88,48.98)
  IN3 w0.254: v2(228.01,44.16) 227.86,44.16 227.48,44.54 227.48,45.17 228.36,46.05 228.36,47.58 231,50.23 v2(233.81,50.23)
  BOTTOM w0.254: U51.A14 236.95,48.92 v2(236.88,48.98) ; C1350.2 v2(233.81,50.23)
REM_DIODE2_P_4021: length 8.6
  BOTTOM w0.254: Q27.1 44.92,93.78 Q27.2 v1(42.09,93.78) 40.8,93.78 C291.1 C294.2 39.41,93.78 U29.27
REM_DIODE3_N: length 49.9
  TOP w0.254: v2(236.7,50.23) 236.55,50.38 234.95,50.38 v2(234.47,50.86) 233.86,50.86 233.2,51.52 230.5,51.52 224.74,57.29 219.01,57.29 212.32,63.98 212.32,65.69 212.24,65.77 v2(212.24,65.77)
  BOTTOM w0.254: v2(236.7,50.23) 236.7,49.85 237.13,49.42 U51.A15 ; C1351.1 v2(234.47,50.86) ; v2(212.24,65.77) 209.52,65.77 209.13,66.15 206.87,66.15 206.3,66.73 206.3,70.43 203.56,73.17 203.25,73.17 C272.2 202.66,72.58 Q14.3
REM_DIODE3_P: length 54
  TOP w0.254: v2(212.24,66.36) 212.37,66.36 212.83,65.9 212.83,64.19 219.22,57.8 224.95,57.8 230.71,52.03 233.41,52.03 234.07,51.37 234.87,51.37 v2(235.38,50.86) 235.41,50.89 237.57,50.89 238.08,50.38 238.84,50.38 v2(239.12,50.1)
  BOTTOM w0.254: Q14.1 200.62,73.88 Q14.2 C272.1 203.25,73.67 203.77,73.67 205.06,72.38 206.81,70.64 206.81,66.94 207.08,66.66 v1(209.35,66.66) 209.73,66.28 212.16,66.28 v2(212.24,66.36) ; U51.B16 238.69,49.67 v2(239.12,50.1) ; C1351.2 v2(235.38,50.86)
REM_DIODE4_N: length 136.3
  IN4 w0.254: v2(225.03,69.44) 225.11,69.51 225.11,70.54 226.85,72.28 226.85,74.05 225.78,75.12 225.78,82.72 226.85,83.78 226.85,86.8 222.17,91.47 222.17,94.72 218.08,98.81 218.08,100.34 212.34,106.08 212.34,115.3 210.59,117.05 210.59,137.84 212.2,139.45 212.2,149.57 209.06,152.72 208.04,152.72 v2(208,152.68)
  BOTTOM w0.254: v2(225.03,69.44) 225.07,69.4 225.07,67.81 223.75,66.49 223.75,64.12 226.21,61.65 226.21,57.08 228.24,55.06 231.28,55.06 233.65,52.69 234.29,52.69 C1346.1 234.77,52.67 235.4,52.67 236.8,51.26 236.8,50.87 237.43,50.24 237.54,50.12 237.54,49.97 U51.A16 ; Q15.3 196.65,152.21 198.37,152.21 199.16,153 203.77,153 204.25,152.51 C288.2 205.41,152.51 205.61,152.72 207.96,152.72 v2(208,152.68)
REM_DIODE4_P: length 137.4
  IN4 w0.254: v2(225.61,69.44) 225.61,70.33 227.35,72.07 227.35,74.26 226.29,75.33 226.29,82.51 227.35,83.57 227.35,87.01 222.68,91.68 222.68,94.93 218.59,99.02 218.59,100.55 212.85,106.29 212.85,115.51 211.1,117.26 211.1,137.63 212.71,139.24 212.71,149.78 209.27,153.23 208.04,153.23 v2(208,153.26)
  BOTTOM w0.254: Q15.1 196.72,153.43 Q15.2 198.22,152.78 198.87,153.43 C288.1 205.41,153.43 205.61,153.23 207.96,153.23 v2(208,153.26) ; v2(225.61,69.44) 225.58,69.4 225.58,67.6 224.26,66.27 224.26,64.33 226.72,61.86 226.72,57.29 228.45,55.56 231.49,55.56 233.86,53.2 234.39,53.2 C1346.2 234.72,53.18 235.61,53.18 237.31,51.47 237.31,51.08 237.78,50.6 238.22,50.17 U51.B17
RES_BIAS: length 3
  TOP w0.102: v1(117.12,95.39) 116.97,95.24 R562.1 116.03,95.09 116.03,95.03 115.08,94.09 U31.12
RESET_OUT#: length 438.1
  TOP w0.102: RH103.1 RH85.1 56.79,67.82 55.77,68.85 54.86,68.85 53.96,69.75 53.96,72.15 53.31,72.79 53.31,74.59 52.6,75.3 52.36,75.3 52.04,75.61 52.04,75.96 52.17,76.09 52.17,78.88 51.69,79.36 51.69,79.79 51.99,80.1 51.99,81.06 51.41,81.65 51.41,82.26 51.92,82.77 51.92,85.1 v2(52.07,85.26) ; v2(257.1,48.3) 256.74,48.3 255.09,49.95 255.09,50.65 254.18,51.56 254.18,54.12 255.15,55.09 255.15,63.2 253.19,65.16 253.19,68.47 248.56,73.09 248.56,75.97 244.92,79.62 244.92,80.43 241.81,83.53 235.24,83.53 228.32,90.45 225.45,90.45 v1(224.64,91.26) 220.91,94.99 220.91,95 219.51,96.41 v2(219.34,96.41)
  IN1 w0.109: v2(52.07,85.26) 52.07,83.33 49.02,80.28 49.02,74.33 51.92,71.44 52.04,71.44 53.24,70.24 53.24,60.19 52.4,59.35 52.4,47.6 64.25,35.76 65.21,35.76 67.65,33.31 91.03,33.31 92.05,34.33 109.22,34.33 111.1,32.46 116.89,32.46 117.2,32.15 154.6,32.15 157.2,29.55 176.65,29.55 178.31,31.21 192.15,31.21 199.43,38.48 204.21,38.48 205.68,39.94 219.36,39.94 219.98,39.33 228.89,39.33 229.32,38.89 246.76,38.89 247.24,39.37 250.59,39.37 251.73,40.5 254.43,40.5 257.78,43.85 257.78,47.61 v2(257.1,48.3)
  IN3 w0.127: v2(246.39,48.51) 246.79,48.11 247.28,48.11 249.53,50.36 253.01,50.36 254.74,48.63 256.77,48.63 v2(257.1,48.3)
  BOTTOM w0.102: RC73.1 188.84,99.41 191.74,96.51 200.15,96.51 202.49,94.17 211.13,94.17 213.32,95.14 215.12,96.41 v2(219.34,96.41) ; RH27.1 53.39,85.79 52.98,85.38 52.2,85.38 v2(52.07,85.26) ; R843.2 255.32,49.97 255.32,49.29 254.67,48.64 Q52.2 256.15,48.31 256.16,48.3 v2(257.1,48.3) ; U51.B39 247.37,48.17 247.3,48.1 246.8,48.1 246.38,48.51 v2(246.39,48.51)
RESET_OUT#_R: length 3.4
  BOTTOM w0.102: JXDP2.46 50.53,85.95 50.88,86.3 v1(51.5,86.3) 52.09,86.3 RH27.2
REXT: length 3.6
  BOTTOM w0.102: U629.34 32.92,117.48 32.9,117.46 31.6,117.46 R96.2 31.16,116.46 v1(30.75,116.04)
REXT3: length 2.4
  TOP w0.102: U9.27 26.6,158.27 26.26,158.61 v1(26.26,158.89) 26.26,159.4 26.14,159.53 R74.2
RF_+1.05VSP: length 4.1
  TOP w0.102: PR305.1 40.56,67.48 v2(40.79,67.71)
  BOTTOM w0.102: PU300.5 40.09,67.02 v2(40.79,67.71) 41.04,67.71 41.57,68.24 v1(42.54,68.24)
RGB_PNL_DET#: length 13
  TOP w0.102: R340.2 121.64,168.59 122.15,168.09 v1(122.15,164.68) 122.15,158.87 121.99,158.71 JEDP1.18
RSMRST#: length 8.2
  BOTTOM w0.102: 59.97,56.33 59.49,56.81 59.49,57.6 U18.3 ; 59.97,56.33 U12.2 ; 59.97,56.33 59.93,56.33 59.1,55.5 R1622.1 59.08,53.79 R1633.1 v1(58.19,51.54)
RSMRST#_XDP: length 2.7
  BOTTOM w0.102: JXDP2.39 41.89,84.45 RH26.2
RUN_ON: length 304.6
  TOP w0.102: v2(38.2,70.75) 38.2,69.33 R762.1 ; v2(245.08,68.03) 245.41,68.36 245.58,68.36 246.12,68.91 246.12,70.07 245.06,71.13 245.06,71.59 243.56,73.09 243.56,76.14 242.67,77.03 v2(240.89,77.03) ; JIO1.36 v2(20.62,92.7)
  IN3 w0.127: v2(20.62,92.7) 21.22,92.1 22.41,92.1 26.41,88.1 26.41,84.38 26.97,83.82 26.97,82.79 30.2,79.57 34.6,79.57 36.93,77.24 36.93,72.02 v2(38.2,70.75) 38.2,69.69 40.64,67.25 41.82,67.25 42.42,66.64 42.42,64.51 43.09,63.84 43.09,62.36 45.11,60.34 45.11,58 54.29,48.82 57.47,48.82 60.61,45.67 61.89,45.67 63.97,43.59 75.39,43.59 76.04,42.94 99.69,42.94 v2(99.97,42.66) 101.52,41.11 120.77,41.11 122.29,39.59 144.39,39.59 147.39,36.59 166.94,36.59 168.38,38.02 172.76,38.02 174.4,39.66 187.4,39.66 188.67,40.93 192.39,40.93 197.85,46.39 204.09,46.39 208.51,50.81 208.51,51.32 224.79,67.6 229.72,67.6 231.04,68.92 233.35,68.92 233.72,68.56 242.35,68.56 242.72,68.19 244.93,68.19 v2(245.08,68.03)
  BOTTOM w0.102: v2(99.97,42.66) 98.83,41.52 v4(98.83,36.16) 98.83,32.84 99.69,31.98 101.2,31.98 101.7,31.48 PR406.1 ; RP4.2 v2(240.89,77.03) ; U46.A11 244.96,68.16 v2(245.08,68.03)
RUN_ON_ENABLE#: length 338.3
  TOP w0.102: QC1.2 208.6,107.11 209.96,105.75 209.96,104.78 206.45,101.27 206.45,98.9 v1(204.89,97.34) 203.78,96.23 203.78,86.04 201.37,83.63 201.37,73.71 204.56,70.52 204.56,65.43 205.1,64.88 205.1,61.76 215.47,51.4 218.78,51.4 223.24,46.94 225.96,46.94 227.31,45.58 228.27,45.58 228.67,45.17 228.67,42.61 227.33,41.26 227.33,39.79 227.91,39.21 v2(227.91,38.9) ; v2(38.86,74.16) 38.45,73.75 R909.2 38.53,73.34 Q304.5 40,73.34 40.13,73.22 40.13,72.82 40,72.69 Q304.6 ; Q70.2 47.61,78.41 v2(47.5,78.3)
  IN1 w0.109: v2(227.91,38.9) 227.69,39.12 219.89,39.12 219.28,39.73 205.76,39.73 204.3,38.27 199.52,38.27 192.24,30.99 178.4,30.99 176.74,29.33 157.12,29.33 154.52,31.93 117.12,31.93 116.81,32.24 110.93,32.24 109.05,34.12 93.47,34.12 92.4,33.06 67.61,33.06 65.12,35.55 64.16,35.55 52.07,47.64 52.07,59.55 53.01,60.49 53.01,69.41 52.58,69.84 52.12,69.84 51.28,70.68 51.28,71.47 48.49,74.26 48.49,77.31 v2(47.5,78.3)
  BOTTOM w0.102: v2(47.5,78.3) 47.5,77 43.62,73.13 39.74,73.13 38.86,74 v2(38.86,74.16) 38.91,74.21 38.91,76.29 38.73,76.47 38.73,78.19 35.26,81.66 Q45.2
RUNPWROK: length 374.6
  TOP w0.102: RC88.2 207.36,103.44 v1(207.9,103.98) v2(208.66,104.74) ; v2(243,50.1) 242.39,50.71 242.39,53.91 242.59,54.12 242.59,56.55 240.66,58.48 238.28,58.48 237.39,57.6 v2(237.39,57.21)
  IN1 w0.109: v2(208.66,104.74) 208.75,104.65 211.3,104.65 214.99,100.96 214.99,96.58 219.55,92.02 219.55,86.23 222.32,83.45 226.59,83.45 232.18,77.86 238.94,77.86 239.3,77.5 239.3,75.55 239.77,75.07 246.51,75.07 v2(247.67,76.24)
  IN3 w0.127: v2(237.39,57.21) 237.44,57.16 242.36,57.16 244.23,59.03 245.94,59.03 247.74,60.83 247.74,64.02 249.11,65.39 249.11,75.06 247.93,76.24 v2(247.67,76.24) 245.24,78.68 242.21,78.68 242.04,78.85 240.44,78.85 240.03,78.45 227.66,78.45 226.08,76.87 225.73,76.87 222.07,73.22 221.18,73.22 217.91,69.94 217.91,66.46 205.94,54.5 201.09,54.5 191.84,45.25 185.45,45.25 184.06,43.87 177.09,43.87 176.38,43.16 169.28,43.16 167.5,41.38 166.47,41.38 165.63,40.54 147.66,40.54 145.63,42.57 123.96,42.57 122.41,44.12 112.21,44.12 110.71,45.62 101.51,45.62 100.27,46.86 98.64,46.86 97.94,47.56 94.5,47.56 94.31,47.37 92.04,47.37 90.63,48.78 80.26,48.78 79.98,48.5 76.72,48.5 75.73,49.49 69.13,49.49 65.96,52.66 65.96,53.94 65.73,54.17 61.97,54.17 60.83,55.31 57.12,55.31 56.26,56.17 53.57,56.17 49.8,59.94 49.8,69.65 47.28,72.16 47.28,75.56 39.09,83.76 v2(37.96,83.76)
  BOTTOM w0.102: v2(247.67,76.24) 248.08,76.24 248.74,75.58 248.74,74.21 248.26,73.72 246.45,73.72 244.39,71.66 U46.A4 ; Q45.1 34.52,84.72 R799.2 34.59,84.77 35.81,83.55 37.76,83.55 v2(37.96,83.76) ; U51.B26 243.05,50.15 v2(243,50.1) ; U50.2 v2(237.39,57.21)
RUNPWROK_AND: length 11.8
  TOP w0.102: 203.35,107.79 RC28.2 RC46.2 RC16.2 RC14.1 202.6,105.87 UC2.4 ; 203.35,107.79 v1(204.25,108.69) 206.59,108.69 207.14,109.23 207.25,109.23 QC2.1 ; 203.35,107.79 RC20.2
RUNPWROK_R: length 16.5
  TOP w0.102: UC2.1 205.37,104.57 204.8,104 204.8,103.47 RC47.2 RC88.1 205.76,103.49 206.44,104.17 v2(206.72,104.17) ; RC103.1 RC104.1 204.52,111.98 205.1,112.56 CC138.1 205.33,111.66 v1(205.55,111.44) 206.43,111.44 QC2.2 206.67,110.95 v2(206.27,110.55)
  BOTTOM w0.102: v2(206.27,110.55) 206.06,110.34 206.06,104.83 v2(206.72,104.17)
S3_1.35V: length 3.2
  BOTTOM w0.102: PR208.2 153.47,23.47 v1(153.77,23.77)
  BOTTOM w0.203: 152.17,23.05 151.98,22.86 PU200.7
  BOTTOM w0.254: PR208.2 153.17,22.79 152.92,23.05 152.17,23.05
S5_1.35V: length 7.2
  TOP w0.254: v2(152.63,22.54) 152.63,20.38 v1(153.19,19.83) v2(153.64,19.37)
  BOTTOM w0.203: v2(152.63,22.54) 152.55,22.46 PU200.8
  BOTTOM w0.254: PR240.1 PR206.2 PC215.1 v2(153.64,19.37)
SATA_ACT#: length 47.5
  TOP w0.102: v2(30.91,85.79) 30.77,85.93 Q74.4
  IN2 w0.127: v2(65.35,73.6) 65.12,73.6 62.51,70.98 59.87,70.98 59,71.84 57.92,71.84 57.12,72.64 57.12,73.72 51.81,79.03 45.46,79.03 41.27,83.22 36.93,83.22 35.66,84.49 32.2,84.49 v2(30.91,85.79)
  BOTTOM w0.102: v2(30.91,85.79) 30.91,86.3 v1(30.85,86.36) ; UH1.AP3 68.64,72.31 68.18,72.31 67.95,72.53 67.55,72.53 66.99,73.09 66.15,73.09 65.64,73.6 v2(65.35,73.6)
SATA_COMP: length 3.3
  TOP w0.381: v2(69.77,75.86) 70.2,75.86 v1(70.37,76.02) 70.59,76.24 RH57.1
  BOTTOM w0.254: UH1.AY5 69.77,74.71 v2(69.77,75.86)
SATA_IREF: length 1.2
  TOP w0.381: v2(69.77,76.45) 69.77,77 RH51.2
  BOTTOM w0.254: v2(69.77,76.45) 69.22,76.45 UH1.BD4
SATA_LED: length 14.9
  TOP w0.102: v2(23.52,75.12) 23.27,75.38 21.23,75.38 20.56,74.7 JIO1.96 ; v2(26.01,83.34) 26.26,83.59 R934.2
  BOTTOM w0.102: v2(23.52,75.12) 23.8,75.4 23.8,78.98 25.55,80.73 25.55,82.49 v1(25.68,82.61) 26.01,82.94 v2(26.01,83.34)
SATA_ODD_PRX_DTX_N1: length 3.6
  TOP w0.102: JODD1.5 25.43,36.55 25.96,36.02 27.09,36.02 C432.1
SATA_ODD_PRX_DTX_N1_C: length 89.4
  TOP w0.102: C432.2 28.69,36.06 28.87,36.06 31.44,38.63 31.81,38.63 34.99,41.81 40.27,41.81 49.52,51.05 49.52,67.06 48.42,68.15 48.42,70.3 48.07,70.65 48.07,72.52 49.24,73.69 49.24,82.49 50.51,83.76 50.94,83.76 v2(51.13,83.95)
  IN3 w0.127: v2(51.13,83.95) 51.32,83.76 52.86,83.76 53.06,83.96 54.94,83.96 55.57,84.59 60.91,84.59 63.03,82.47 63.29,82.47 v2(63.57,82.76)
  BOTTOM w0.076: 71.91,78.21 71.91,78.19 71.88,78.17 71.88,77.73 72.17,77.44 72.17,77.11 71.84,76.39 UH1.BC10
  BOTTOM w0.102: v2(63.57,82.76) 63.64,82.69 64.26,82.69 66.53,80.42 70.66,80.42 71.42,79.66 71.42,79.16 71.91,78.68 71.91,78.21
SATA_ODD_PRX_DTX_P1: length 3.5
  TOP w0.102: C430.1 27.15,35.81 25.96,35.81 25.43,35.28 JODD1.6
SATA_ODD_PRX_DTX_P1_C: length 89.4
  TOP w0.102: v2(51.13,83.33) 50.91,83.54 50.6,83.54 49.45,82.4 49.45,73.6 48.28,72.43 48.28,70.74 48.64,70.38 48.64,68.24 49.73,67.15 49.73,50.96 40.36,41.59 35.08,41.59 31.9,38.41 31.53,38.41 28.96,35.85 28.72,35.85 C430.2
  IN3 w0.127: v2(51.13,83.33) 51.31,83.51 52.96,83.51 53.17,83.71 55.05,83.71 55.68,84.34 60.81,84.34 62.93,82.22 63.28,82.22 v2(63.57,81.93)
  BOTTOM w0.076: 71.69,78.21 71.69,78.2 71.72,78.18 71.72,77.46 71.77,77.41 71.95,77.41 72,77.36 72,77.15 71.92,77.07 UH1.BE10
  BOTTOM w0.102: 71.69,78.21 71.69,78.59 71.2,79.07 71.2,79.57 70.57,80.2 66.44,80.2 65.45,81.19 65.31,81.19 65.08,81.42 65.08,81.56 64.87,81.78 64.73,81.78 64.5,82 64.5,82.14 64.17,82.47 63.87,82.47 63.74,82.35 63.36,82.35 63.27,82.26 63.27,82.13 63.47,81.93 v2(63.57,81.93)
SATA_ODD_PTX_DRX_N1: length 3.5
  TOP w0.102: C434.1 27.17,39.59 25.94,39.59 25.43,39.09 JODD1.3
SATA_ODD_PTX_DRX_N1_C: length 88.7
  TOP w0.102: C434.2 28.71,39.64 31.93,39.64 34.72,42.43 39.95,42.43 48.89,51.37 48.89,66.76 47.75,67.91 47.75,70.07 47.38,70.43 47.38,72.7 48.59,73.9 48.59,79.82 47.06,81.34 47.06,82.84 47.17,82.94 47.32,82.94 v2(47.52,82.74)
  IN3 w0.089: 69.29,76.89 69.31,76.89 69.35,76.92 69.83,76.92 70.28,76.47 70.28,75.53 70.69,75.12 70.69,74.87 70.97,74.59 71.23,74.59 v2(71.44,74.38)
  IN3 w0.127: v2(47.52,82.74) 47.66,82.88 47.67,82.87 48.61,82.87 49.23,82.26 53.01,82.26 53.55,82.8 55.54,82.8 55.69,82.64 57.33,82.64 57.71,82.26 61.59,82.26 62.83,81.02 64.82,81.02 68.95,76.89 69.29,76.89
  BOTTOM w0.089: v2(71.44,74.38) 71.49,74.38 71.71,74.16 71.93,73.94 UH1.AV10
SATA_ODD_PTX_DRX_P1: length 3.6
  TOP w0.102: JODD1.2 25.43,40.36 25.99,39.81 27.07,39.81 C433.1
SATA_ODD_PTX_DRX_P1_C: length 88.7
  TOP w0.102: v2(47.52,83.38) 47.31,83.16 47.08,83.16 46.85,82.93 46.85,81.25 48.37,79.73 48.37,73.99 47.17,72.78 47.17,70.35 47.53,69.98 47.53,67.82 48.68,66.67 48.68,51.46 39.86,42.65 34.63,42.65 31.84,39.86 28.71,39.86 C433.2
  IN3 w0.089: 69.29,77.14 69.3,77.14 69.34,77.1 69.9,77.1 70.46,76.54 70.46,75.6 70.86,75.2 70.86,74.94 71.04,74.77 71.24,74.77 v2(71.44,74.97)
  IN3 w0.127: 69.29,77.14 69.05,77.14 64.92,81.27 62.94,81.27 61.7,82.51 57.81,82.51 57.43,82.89 55.8,82.89 55.65,83.05 53.44,83.05 52.91,82.51 49.33,82.51 48.72,83.12 47.78,83.12 47.77,83.13 v2(47.52,83.38)
  BOTTOM w0.089: UH1.AW10 71.5,74.97 v2(71.44,74.97)
SATA_PRX_DKTX_N2: length 4.6
  BOTTOM w0.102: JDOCK1.56 96.24,127.57 96.1,127.71 96.1,128.94 95.9,129.14 v3(95.9,129.88) 95.9,130.72 C698.2
SATA_PRX_DKTX_N2_C: length 73.4
  IN3 w0.127: v2(94.18,128.26) 94.42,128.49 94.42,128.75 94.24,128.92 92.27,128.92 91.64,128.29 91.64,127.24 90.98,126.58 90.98,118.19 91.36,117.81 91.36,113.88 90.83,113.35 90.83,109.92 74.09,93.18 74.09,87.56 73.35,86.83 73.17,86.83 70.81,84.47 70.81,81.19 71.58,80.42 71.58,79.24 71.26,78.92 70.95,78.92 v2(70.81,78.78)
  BOTTOM w0.076: UH1.BB9 71.44,75.94 71.69,76.53 71.69,76.82 71.56,76.95 71.56,77.39 71.04,77.91 71.05,77.92 71.05,77.94 71.04,77.94
  BOTTOM w0.102: v2(70.81,78.78) 70.65,78.61 70.65,78.34 71.04,77.94 ; C698.1 95.99,132.21 95.99,132.52 95.72,132.79 94.96,132.79 94.4,132.23 v3(94.4,130.1) 94.4,128.47 v2(94.18,128.26)
SATA_PRX_DKTX_P2: length 4.6
  BOTTOM w0.102: C697.2 95.69,130.72 95.69,130.16 95.67,130.15 95.67,129.62 95.69,129.6 95.69,129.05 95.88,128.85 95.88,127.72 95.74,127.58 JDOCK1.54
SATA_PRX_DKTX_P2_C: length 73.4
  IN3 w0.127: v2(70.81,79.41) 70.81,79.33 70.98,79.16 71.15,79.16 71.33,79.34 71.33,80.32 70.57,81.09 70.57,84.58 73.07,87.08 73.25,87.08 73.84,87.67 73.84,93.28 90.58,110.02 90.58,113.45 91.11,113.98 91.11,117.71 90.73,118.09 90.73,126.69 91.39,127.34 91.39,128.39 92.17,129.17 94.34,129.17 94.66,128.85 94.66,128.41 v2(94.82,128.26)
  BOTTOM w0.076: 70.89,77.79 70.9,77.78 70.93,77.78 71.4,77.32 71.4,76.88 71.53,76.75 71.53,76.68 71.46,76.62 UH1.BD9
  BOTTOM w0.102: v2(70.81,79.41) 70.64,79.41 70.43,79.21 70.43,78.25 70.89,77.79 ; v2(94.82,128.26) 94.61,128.46 94.61,129.82 94.63,129.83 94.63,130.36 94.61,130.38 94.61,132.14 95.05,132.58 95.63,132.58 95.78,132.43 95.78,132.11 95.63,131.97 C697.1
SATA_PRX_DTX_N0: length 14.4
  TOP w0.102: C394.1 189.11,38.12 189.3,38.12 v2(189.48,37.94) 189.67,38.12 192.28,38.12 195.68,41.52 197.89,41.52 197.9,41.5 198.44,41.5 198.45,41.52 198.63,41.52 199.15,40.99 JSATA1.5
  BOTTOM w0.102: C394.1 189.01,38.02 189.39,38.02 v2(189.48,37.94)
SATA_PRX_DTX_N3: length 20.3
  TOP w0.102: JESA1.9 12.79,169.19 12.79,166.73 v3(11.45,165.39) 10.12,164.06 10.12,160.62 9.17,159.67 9.15,159.67 9.08,159.59 8.77,159.29 8.77,159.27 5.24,155.74 5.24,155.22 v2(5.08,155.05) 5.27,154.86 5.27,154.53 C673.2
  BOTTOM w0.102: C680.2 5.26,154.48 5.26,154.87 v2(5.08,155.05)
SATA_PRX_DTX_N5: length 3.1
  TOP w0.102: C414.1 69.65,34.58 69.65,34.39 69.59,34.32 69.59,34.05 69.06,33.53 JSATA2.5
SATA_PRX_DTX_N5_C: length 85.9
  TOP w0.102: C414.2 69.56,36.07 69.56,36.28 69.19,36.65 66.53,36.65 65.73,37.46 61.54,37.46 51.17,47.83 51.17,74.04 51.52,74.4 51.73,74.4 v2(51.92,74.59)
  IN1 w0.117: v2(51.92,74.59) 52.1,74.4 52.92,74.4 54.38,75.86 55.73,75.86 57.53,77.66 57.53,78.63 57.73,78.83 57.73,78.86 58.11,79.24 58.14,79.24 63.06,84.16 66.52,84.16 66.99,84.64 71.57,84.64 v2(71.81,84.87)
  BOTTOM w0.076: 73.56,78.11 73.56,78.09 73.53,78.07 73.53,77.63 73.75,77.23 73.75,76.9 73.54,76.61 73.54,76.24 UH1.BC14
  BOTTOM w0.102: 73.56,78.11 73.56,78.47 73.48,78.55 73.48,79.49 73.64,79.65 73.64,82.19 72.96,82.87 72.96,84.32 72.44,84.84 71.84,84.84 v2(71.81,84.87)
SATA_PRX_DTX_P0: length 14.8
  TOP w0.102: JSATA1.6 199.15,42.26 198.63,41.73 v3(198.17,41.73) 195.59,41.73 192.19,38.34 189.67,38.34 v2(189.48,38.52) 189.3,38.34 189.11,38.34 C393.1
  BOTTOM w0.102: v2(189.48,38.52) 189.2,38.24 188.9,38.24 188.77,38.37 C393.1
SATA_PRX_DTX_P3: length 20.3
  TOP w0.102: JESA1.10 13,169.19 13,166.64 11.8,165.44 11.8,165.42 11.43,165.04 11.41,165.04 10.34,163.97 10.34,160.53 v3(9.12,159.32) 5.46,155.65 5.46,155.26 v2(5.66,155.05) 5.49,154.88 5.49,154.52 C674.2
  BOTTOM w0.102: C677.2 5.48,154.48 5.48,154.87 v2(5.66,155.05)
SATA_PRX_DTX_P5: length 3.1
  TOP w0.102: 70.33,32.2 70.33,33.54 69.8,34.07 69.8,34.23 69.87,34.3 69.87,34.58 C412.1
SATA_PRX_DTX_P5_C: length 85.8
  TOP w0.102: v2(51.92,74) 51.74,74.18 51.61,74.18 51.38,73.95 51.38,47.92 61.63,37.67 65.82,37.67 66.62,36.87 69.27,36.87 69.77,36.37 69.77,35.92 69.87,35.83 C412.2
  IN1 w0.117: v2(71.81,84.04) 71.45,84.4 67.09,84.4 66.62,83.93 63.16,83.93 58.23,79 58.21,79 57.96,78.76 57.96,78.73 57.77,78.53 57.77,77.56 55.82,75.62 54.48,75.62 53.02,74.16 52.08,74.16 v2(51.92,74)
  BOTTOM w0.076: 73.34,78.11 73.34,78.09 73.37,78.07 73.37,77.59 73.42,77.48 73.42,77.42 73.27,77.26 73.27,77.07 73.35,76.99 73.4,76.99 UH1.BE14
  BOTTOM w0.102: v2(71.81,84.04) 71.75,83.97 71.64,83.97 71.5,84.11 71.5,84.36 71.6,84.46 71.97,84.46 72.14,84.63 72.35,84.63 72.74,84.23 72.74,82.78 73.42,82.1 73.42,79.74 73.27,79.58 73.27,78.46 73.34,78.38 73.34,78.11
SATA_PTX_DKRX_N2: length 4.6
  BOTTOM w0.102: C700.1 97.81,130.72 v3(97.81,129.85) 97.81,128.99 97.6,128.78 97.6,127.74 97.74,127.6 JDOCK1.62
SATA_PTX_DKRX_N2_C: length 73.6
  IN3 w0.089: v2(73.4,75.4) 73.63,75.63 73.63,75.8 73.6,75.83 73.6,75.85
  IN3 w0.127: 73.6,75.85 73.6,75.9 72.19,77.3 72.19,83.78 73.23,84.82 73.23,85.84 74.6,87.22 74.6,92.95 91.9,110.25 91.9,113.68 91.88,113.7 91.88,126.2 93.02,127.34 93.02,128.1 v2(92.89,128.23)
  BOTTOM w0.102: UH1.AY13 73.18,75.4 v2(73.4,75.4) ; v2(92.89,128.23) 93.06,128.41 93.06,129.17 93.43,129.54 93.43,132.49 94.57,133.63 95.82,133.63 95.83,133.64 96.37,133.64 96.38,133.63 97.11,133.63 97.81,132.93 97.81,132.3 C700.2
SATA_PTX_DKRX_P2: length 4.6
  BOTTOM w0.102: C699.1 97.59,130.72 97.59,130.12 97.58,130.11 97.58,129.58 97.59,129.57 97.59,129.08 97.38,128.87 97.38,127.75 97.24,127.61 JDOCK1.60
SATA_PTX_DKRX_P2_C: length 73.6
  IN3 w0.089: v2(73.4,74.79) 73.81,75.2 73.81,75.8 73.85,75.83 73.85,75.85
  IN3 w0.127: 73.85,75.85 73.85,76 72.44,77.41 72.44,83.68 73.48,84.72 73.48,85.74 74.85,87.11 74.85,92.85 92.15,110.15 92.15,113.78 92.12,113.81 92.12,126.1 93.27,127.24 93.27,128.02 v2(93.48,128.23)
  BOTTOM w0.102: v2(93.48,128.23) 93.28,128.44 93.28,129.08 93.65,129.45 93.65,132.4 94.66,133.41 v3(96.1,133.41) 97.02,133.41 97.59,132.84 97.59,132.3 C699.2 ; v2(73.4,74.79) 73.16,74.79 UH1.AW13
SATA_PTX_DRX_N0: length 13.8
  TOP w0.102: C389.1 189.13,36.41 189.28,36.41 v2(189.48,36.61) 189.67,36.43 190.64,36.43 191.46,37.25 193.83,37.25 194.5,37.92 v3(197.92,37.92) 198.63,37.92 199.15,38.45 JSATA1.3
  BOTTOM w0.102: C389.1 189.15,36.39 189.25,36.39 v2(189.48,36.61)
SATA_PTX_DRX_N3: length 19.5
  TOP w0.102: JESA1.7 9.19,169.19 9.19,160.97 v3(5.5,157.28) 4.2,155.98 4.2,155.96 3.83,155.59 3.81,155.59 3.58,155.36 3.58,155.23 v2(3.76,155.05) 3.57,154.87 3.57,154.53 C672.2
  BOTTOM w0.102: v2(3.76,155.05) 3.58,154.88 3.58,154.47 C678.2
SATA_PTX_DRX_N5: length 3.1
  TOP w0.102: JSATA2.3 66.52,33.47 65.99,33.99 65.99,34.28 66.06,34.34 66.06,34.58 C411.1
SATA_PTX_DRX_N5_C: length 85.8
  TOP w0.102: C411.2 66.07,35.83 65.96,35.93 65.96,36.34 65.54,36.76 61.36,36.76 50.56,47.56 v3(50.56,49.54) 50.56,70.92 50.29,71.18 50.29,80.33 50.51,80.55 50.79,80.55 50.95,80.39 v2(50.95,80.3)
  IN3 w0.089: v2(74.32,72.5) 74.32,72.57 74.17,72.72 74,72.72 73.65,72.38 73.28,72.38 72.82,71.92 68.86,71.92 68.43,72.35 68.43,74.56 68.02,74.97 68.02,76.34 66.6,77.76 66.45,77.76 66.41,77.73 66.39,77.73
  IN3 w0.127: v2(50.95,80.3) 51.2,80.55 52.57,80.55 53.62,81.6 55.4,81.6 55.65,81.34 61.22,81.34 64.83,77.73 66.39,77.73
  BOTTOM w0.102: UH1.AP15 74.03,72.15 74.32,72.44 v2(74.32,72.5)
SATA_PTX_DRX_P0: length 13.7
  TOP w0.102: JSATA1.2 199.15,37.18 198.63,37.71 198.19,37.71 198.18,37.69 197.65,37.69 197.64,37.71 194.59,37.71 193.92,37.03 191.55,37.03 190.73,36.21 189.67,36.21 v2(189.48,36.03) 189.32,36.2 189.09,36.2 C390.1
  BOTTOM w0.102: v2(189.48,36.03) 189.34,36.17 189.06,36.17 C390.1
SATA_PTX_DRX_P3: length 19.5
  TOP w0.102: JESA1.6 8.98,169.19 8.98,161.06 5.54,157.63 5.53,157.63 5.15,157.25 5.15,157.24 v3(3.85,155.94) 3.36,155.45 3.36,155.27 v2(3.15,155.05) 3.36,154.85 3.36,154.53 C671.2
  BOTTOM w0.102: v2(3.15,155.05) 3.36,154.84 3.36,154.48 C679.2
SATA_PTX_DRX_P5: length 3.1
  TOP w0.102: 65.25,32.2 65.25,33.47 65.78,33.99 65.78,34.37 65.84,34.43 65.84,34.58 C413.1
SATA_PTX_DRX_P5_C: length 85.8
  TOP w0.102: v2(50.95,80.94) 50.78,80.76 50.42,80.76 50.07,80.42 50.07,71.09 50.34,70.83 50.34,49.82 50.33,49.81 50.33,49.28 50.34,49.26 50.34,47.47 61.27,36.54 65.45,36.54 65.75,36.25 65.75,36.07 C413.2
  IN3 w0.089: 66.39,77.98 66.41,77.98 66.45,77.94 66.67,77.94 67.45,77.17 67.45,77.16 68.2,76.41 68.2,75.04 68.6,74.64 68.6,72.43 68.93,72.1 72.75,72.1 73.2,72.56 73.58,72.56 73.92,72.9 74.23,72.9 74.34,73.01 v2(74.34,73.11)
  IN3 w0.127: v2(50.95,80.94) 51.09,80.8 52.47,80.8 53.52,81.85 55.5,81.85 55.76,81.59 61.32,81.59 64.94,77.98 66.39,77.98
  BOTTOM w0.102: UH1.AR15 73.98,72.75 v2(74.34,73.11)
SATA_REPEATER_EN: length 2.1
  BOTTOM w0.102: U26.7 183.37,41.25 C24.2
SATA_SIDE_LED: length 12.5
  TOP w0.102: R943.2 27.91,82.56 25.83,82.56 v1(24.93,81.66) 24.13,80.86 24.13,78.37 23.16,77.41 21,77.41 20.7,77.1 JIO1.88
SB#: length 5.9
  BOTTOM w0.102: U2.8 278.24,83.51 278.05,83.33 R1626.2 278.46,82.08 v1(278.46,80.71) 278.46,78.83 Q338.2
SCLK: length 4.7
  TOP w0.203: PU500.1 157.35,171.26 157.52,171.44 158.11,171.44
  TOP w0.254: PR508.2 v2(160.07,172.53) v1(159.52,172.53) 158.43,171.44 158.11,171.44
  BOTTOM w0.254: PR508.2 v2(160.07,172.53)
SDA: length 5
  TOP w0.203: PU500.31 158.8,169.95
  TOP w0.254: 158.8,169.95 158.99,169.95 159.79,170.75 v2(160.02,170.75) PR505.2
  BOTTOM w0.102: v2(160.02,170.75) v1(160.02,169.46)
  BOTTOM w0.254: PR505.2 v2(160.02,170.75)
SEL: length 13
  IN1 w0.109: v2(279.74,86.82) 279.26,86.82 277.47,85.03 277.47,82.29 v2(276.12,80.94)
  BOTTOM w0.102: v2(279.74,86.82) U2.4 279.74,85.78 280.4,85.12 R1614.1 R1613.2 ; v1(275.86,81.53) 275.86,81.2 v2(276.12,80.94) 276.79,80.27 Q338.1
SIO_14M: length 6.1
  TOP w0.102: v2(83.78,60.51) 83.82,60.47 v1(83.82,58.45) 83.82,58.23 86.1,55.94 RH157.2
  BOTTOM w0.102: UH1.F38 83.43,60.51 v2(83.78,60.51)
SIO_A20GATE: length 251.6
  TOP w0.076: 68.78,76.62 69.19,76.21 69.19,75.55 69.87,74.87 69.87,74.28 70.31,73.85 71.22,73.85 71.8,73.27 71.8,72.91 v2(71.42,72.53)
  TOP w0.102: RH215.1 68.03,80.06 68.03,78.46 68.3,78.19 v1(68.3,77.6) 68.3,77.1 68.78,76.62
  IN1 w0.109: v2(249.43,44.16) 249.73,44.46 249.73,45.83 249.37,46.19 245.97,46.19 244.93,47.23 243.43,47.23 242.49,48.17 242.49,50.23 242.09,50.64 239.06,50.64 237.87,49.44 236.65,49.44 235.72,48.51 233.79,48.51 233.04,49.26 218.43,49.26 215.55,46.39 200.49,46.39 193.32,39.22 189.14,39.22 187.81,37.88 186.64,37.88 186.31,37.55 184.33,37.55 182.81,39.07 177.62,39.07 176.79,39.91 174.95,39.91 173.26,38.23 122.66,38.23 120,40.89 114.05,40.89 113.21,41.73 103.74,41.73 103.47,42 99.26,42 98.58,42.69 95.06,42.69 94.32,41.95 81.05,41.95 80.31,42.69 77.14,42.69 75.64,44.18 72.95,44.18 72.09,45.04 69.98,45.04 66.78,48.25 66.78,49.26 66.27,49.77 64.57,49.77 61.65,52.69 61.65,55.46 60.65,56.46 60.65,57.9 62.83,60.08 62.83,70.06 64.62,71.84 67.03,71.84 67.64,72.45 67.64,73.67 68.4,74.44 69.42,74.44 69.92,73.93 71.37,73.93 71.91,73.39 71.91,73.01 v2(71.42,72.53)
  BOTTOM w0.102: UH1.AN10 71.54,72.41 v2(71.42,72.53) ; U51.A45 249.18,43.92 v2(249.43,44.16)
SIO_EXT_SCI#: length 277.4
  TOP w0.102: v2(63.42,80.56) 63.78,80.2 63.78,79.16 64.13,78.81 RPH10.6 65.45,78.81 RH195.1
  IN1 w0.109: v2(63.42,80.56) 63.22,80.36 63.22,80.35 61.07,78.19 59.31,78.19 57.15,76.04 57.15,75.23 55.63,73.71 55.63,72.79 54.33,71.49 54.33,65.9 54.89,65.34 54.89,63.21 54.25,62.57 54.25,46.94 64.6,36.6 67.82,36.6 69.24,35.18 81.32,35.18 81.54,34.96 109.52,34.96 110.31,34.18 112.02,34.18 112.17,34.32 115.96,34.32 117.24,33.03 154.61,33.03 157.35,30.29 174.85,30.29 176.43,31.87 186,31.87 188,33.87 193.74,33.87 199.07,39.2 203.9,39.2 205.28,40.58 219.62,40.58 220.16,40.04 232.27,40.04 233.16,39.15 246.73,39.15 247.15,39.58 250.5,39.58 251.64,40.72 254.24,40.72 256.61,43.09 256.61,47.28 v2(257.05,47.71)
  BOTTOM w0.102: v2(257.05,47.71) 254.28,47.71 254.05,47.94 254.05,49.39 253.06,50.38 253.06,51.91 252.58,52.39 249.93,52.39 v1(249.67,52.12) 249.29,51.75 249.29,50.38 248.83,49.92 U51.A33
SIO_EXT_SMI#: length 254.6
  IN1 w0.109: v2(55.8,60.9) 55.83,60.9 56.26,60.47 56.26,49.88 61.14,45 61.14,43.2 65.13,39.21 66.39,39.21 69.57,36.02 81.72,36.02 81.84,35.9 103.78,35.9 104.9,37.02 107.75,37.02 108.86,35.9 115.83,35.9 117.87,33.86 155.15,33.86 156.82,32.2 170.53,32.2 171.93,33.59 187.01,33.59 187.79,34.38 193.24,34.38 198.58,39.72 202.11,39.72 203.39,41 219.97,41 220.36,40.6 223.42,40.6 v2(223.93,41.11) ; v2(51.92,63.92) 51.1,64.73 51.1,65.18 48.75,67.53 48.75,68.34 41.92,75.16 39.95,75.16 38.61,76.51 38.61,77.49 37.18,78.91 37.18,80.58 38.15,81.54 v2(38.15,82.32)
  BOTTOM w0.076: UH1.M1 66.78,63.28 66.57,63.08 66.27,63.08
  BOTTOM w0.102: 66.27,63.08 64.04,63.08 63.66,62.7 63.32,62.7 62.99,62.37 62.99,62.09 62.76,61.85 61.28,61.85 60.97,61.53 60.35,61.53 60.16,61.35 RPH7.3 59.68,61.35 59.38,61.05 59.38,60.82 59.21,60.64 59.08,60.52 58.14,60.52 58.01,60.64 57.76,60.9 v2(55.8,60.9) 54.94,60.9 v2(51.92,63.92) ; v2(223.93,41.11) v1(224.66,41.11) 225.54,41.11 226.38,41.95 227.45,41.95 229.49,43.98 231.18,43.98 231.51,44.31 236.19,44.31 236.8,44.92 U51.A6 ; RH10.1 39.83,82.87 39.47,82.51 38.34,82.51 v2(38.15,82.32)
SIO_EXT_WAKE#: length 212.2
  TOP w0.102: v2(66.7,66.84) 66.31,66.46 64.27,66.46 63.02,65.22 RH210.1 61.82,65.67 60.35,65.67 60.02,65.34 RH24.1
  IN1 w0.109: v2(217.85,53.86) 214.65,50.66 200.4,50.66 192.25,42.51 186.02,42.51 186.01,42.52 186,42.52 185.83,42.7 166.46,42.7 165.73,41.97 122.9,41.97 120.7,44.16 115.73,44.16 115.53,44.35 111.84,48.04 110.54,48.04 110.3,47.8 98.89,47.8 98.47,48.22 92.47,48.22 90.84,46.59 85.66,46.59 83.35,48.9 79.02,48.9 77.5,50.41 77.5,50.82 75.39,52.93 75.39,53.71 74.62,54.48 74.62,55 74.36,55.25 74.36,58.07 76.84,60.55 76.84,63.24 76.01,64.07 76.01,66.55 75.65,66.92 73.18,66.92 72.67,67.42 69.5,67.42 69.39,67.31 67.76,67.31 67.28,66.84 v2(66.7,66.84)
  BOTTOM w0.102: R797.1 225.65,73.34 225.07,72.76 225.07,70.87 223.26,69.07 223.26,67.81 219.05,63.59 v1(219.05,58.75) 219.05,56.3 217.85,55.11 v2(217.85,53.86) ; UH1.Y1 67.72,66.63 66.91,66.63 v2(66.7,66.84)
SIO_PWRBTN#: length 237.9
  TOP w0.102: RH259.1 58.93,60.8 57.3,60.8 56.51,61.58 55.14,61.58 54.96,61.41 v1(52.7,61.41) 52.27,61.41 v2(51.89,61.79) ; v2(243.99,42.23) 243.99,42.22 245.31,40.9 245.31,37.44 245.62,37.14 v2(245.62,36.68)
  IN1 w0.109: v2(51.89,61.79) 51.09,60.99 51.09,48.32 64.07,35.34 65.03,35.34 67.52,32.85 92.49,32.85 93.55,33.91 108.96,33.91 110.84,32.03 116.72,32.03 117.03,31.72 154.43,31.72 157.03,29.12 176.83,29.12 178.49,30.78 192.33,30.78 199.6,38.06 204.39,38.06 205.8,39.47 219.24,39.47 221.11,37.6 227.77,37.6 228.07,37.3 233.94,37.3 235.01,36.23 240.84,36.23 241.76,37.15 245.15,37.15 v2(245.62,36.68)
  BOTTOM w0.102: v2(243.99,42.23) 244.05,42.17 U51.B58
SIO_PWRBTN#_R: length 299.7
  TOP w0.102: v2(67.21,62.55) 67.18,62.52 64.9,62.52 63.68,61.3 63.24,61.3 63.04,61.51 60.6,61.51 RH259.2 59.31,60.21 57.6,60.21 56.43,61.38 55.23,61.38 54.18,60.33 v1(54.18,59.58) 54.18,59.3 53.21,58.33 v2(53.21,58.13) ; v2(212.14,118.89) 212.7,119.44 RC6.1
  IN3 w0.127: v2(39.63,83.88) 40.44,83.88 44.27,80.05 44.98,80.05 48.03,77 52.09,77 52.98,76.11 52.98,75.55 52.6,75.17 52.6,73.2 52.31,72.91 51.08,72.91 50.49,72.33 50.49,60.85 v2(53.21,58.13) 53.8,57.54 57.03,57.54 57.58,58.09 61.52,58.09 62.6,59.17 63.88,59.17 64.69,58.36 64.69,56.2 66.66,54.23 66.66,52.95 69.42,50.19 76.02,50.19 77.01,49.2 79.69,49.2 79.97,49.48 90.92,49.48 92.33,48.07 93.97,48.07 94.16,48.26 98.23,48.26 98.93,47.56 100.56,47.56 101.8,46.32 111,46.32 112.5,44.82 123.18,44.82 124.73,43.27 145.92,43.27 147.95,41.24 165.34,41.24 166.18,42.08 167.16,42.08 169.88,44.79 176.59,44.79 177.09,45.3 183.82,45.3 184.47,45.95 189.49,45.95 191.74,48.2 193.8,48.2 200.83,55.23 205.31,55.23 211.44,61.36 211.44,63.3 216.89,68.75 216.89,79.46 219.91,82.49 219.91,92.88 216.71,96.08 216.71,101.78 213.08,105.41 213.08,106.68 212.75,107.01 212.75,118.22 212.11,118.86 v2(212.14,118.89)
  BOTTOM w0.089: UH1.K1 67.81,62.47 67.29,62.47 v2(67.21,62.55)
  BOTTOM w0.102: RH28.1 40.28,84.54 v2(39.63,83.88)
SIO_RCIN#: length 232.5
  TOP w0.076: 68.83,74.55 69.18,74.55 69.54,74.18 69.54,73.53 v2(69.62,73.46)
  TOP w0.102: RPH10.7 66.04,79.31 66.71,78.64 v1(66.71,78.03) 66.71,77.24 67.46,76.49 67.46,75.57 68.49,74.55 68.83,74.55
  IN1 w0.109: v2(69.62,73.46) 69.48,73.31 68.79,73.31 67.12,71.63 64.7,71.63 63.04,69.97 63.04,59.99 62.15,59.1 62.15,55.84 61.86,55.55 61.86,53.44 64.05,51.25 65.08,51.25 66.99,49.35 66.99,48.34 70.07,45.25 72.18,45.25 73.04,44.4 75.73,44.4 77.22,42.9 80.4,42.9 81.13,42.16 94.24,42.16 94.97,42.9 98.66,42.9 99.35,42.21 103.61,42.21 103.88,41.94 113.3,41.94 113.43,41.82 114.14,41.1 120.1,41.1 122.66,38.55 173.2,38.55 174.78,40.12 176.95,40.12 177.78,39.28 182.97,39.28 183.3,38.95 188.45,38.95 188.92,39.43 193.24,39.43 200.4,46.6 210.79,46.6 211.75,47.56 216.05,47.56 218.26,49.77 235.08,49.77 236.64,51.34 243.53,51.34 v2(244.5,52.31)
  BOTTOM w0.102: U51.A27 244.3,52.11 v2(244.5,52.31) ; UH1.AT6 69.75,73.33 v2(69.62,73.46)
SIO_SLP_A#: length 333.5
  TOP w0.102: v2(64.46,50.47) 64.46,50.76 64.05,51.18 UH2.1 63.6,51.19 63.6,51.55 62.36,52.79 62.36,56.22 PR303.1 62.22,57.4 62.22,58.23 62.52,58.53 62.69,58.53 63.78,59.63 66.19,59.63 v2(66.55,59.98) ; R877.1 98.19,40.78 95.53,43.45 95.53,45.97 95.57,46.01 v2(95.57,46.09)
  IN3 w0.127: v2(13.13,123.18) 13.13,121.66 17.64,117.15 17.64,114.43 30.45,101.61 30.45,98.72 32.33,96.84 32.33,90.25 31.92,89.83 31.92,83.33 33.85,81.39 35.36,81.39 41.59,75.16 41.59,73.29 44.06,70.83 44.06,65.14 44.69,64.5 44.69,63.02 46.71,61.01 46.71,58.66 54.65,50.72 60.08,50.72 60.94,49.86 63.27,49.86 63.88,50.47 v2(64.46,50.47) 65.19,49.75 65.19,48.95 65.9,48.24 66.58,48.24 68.31,46.51 70.11,46.51 70.52,46.1 75.69,46.1 76.13,45.66 79.21,45.66 79.45,45.42 93.31,45.42 93.56,45.67 95.15,45.67 v2(95.57,46.09) 95.57,46.07 96.01,45.63 99.86,45.63 101.82,43.68 107.62,43.68 108.33,42.96 121.86,42.96 123.41,41.42 145.15,41.42 148.15,38.42 166.18,38.42 167.93,40.17 168.43,40.17 168.8,40.54 169.22,40.54 170.68,42 176.86,42 177.57,42.71 184.54,42.71 185.89,44.06 192.28,44.06 201.56,53.34 206.56,53.34 220.8,67.58 220.8,69.41 224.76,73.37 225.83,73.37 229.67,77.2 235.99,77.2 236.24,76.95 238.02,76.95 238.35,76.62 239.15,76.62 239.43,76.34 240.16,76.34 240.84,75.65 240.84,74.03 240.56,73.75 240.56,72.99 240.32,72.75 v2(240.13,72.75)
  BOTTOM w0.076: 67.23,60.29 67.51,60.57 67.92,60.57 68.05,60.69 68.32,60.69 68.43,60.8 UH1.F3
  BOTTOM w0.089: 67.23,60.29 66.93,59.98 v2(66.55,59.98)
  BOTTOM w0.102: v2(13.13,123.18) 13.36,122.94 JAPS1.6 16.27,122.94 v4(16.61,122.61) ; U46.B63 239.73,73.73 239.62,73.62 239.62,73.26 v2(240.13,72.75)
SIO_SLP_LAN#: length 232.2
  TOP w0.102: RH80.2 70.79,55.72 71.37,56.31 71.37,58.26 70.36,59.27 70.36,60.03 69.96,60.43 v2(69.68,60.43) ; U63.3 101.95,73.89 101.95,72.66 102.08,72.53 102.13,72.53 104.11,70.55 v1(108.81,70.55) v2(116.43,70.55) 116.89,70.09 116.89,68.26 116.33,67.7 116.33,66.32 116.15,66.14 116.15,59.5 115.67,59.02 113.87,59.02 113,58.15 113,52.54 v2(112.9,52.44)
  IN1 w0.109: v2(244.42,70.96) 244.27,70.96 242.75,69.43 241.28,69.43 240.77,69.94 237.71,69.94 236.26,68.49 233.55,68.49 232.55,67.5 220.78,67.5 219.85,66.57 214.03,66.57 212.73,65.27 211.89,65.27 211.72,65.44 204.34,65.44 203.91,65.01 200.43,65.01 199.44,64.02 198.02,64.02 197.48,63.48 188.18,63.48 186.74,62.04 174.47,62.04 173.05,60.62 158.49,60.62 157.17,59.3 155.62,59.3 155.53,59.2 148.66,59.2 147.17,60.69 144.35,60.69 143.46,61.58 124,61.58 117.19,68.39 117.19,69.79 v2(116.43,70.55)
  IN3 w0.127: v2(69.68,60.43) 69.99,60.43 70.33,60.08 70.33,59.55 71.21,58.67 77.41,58.67 77.82,58.26 82.45,58.26 83.56,57.14 87.48,57.14 88.2,57.86 90.49,57.86 90.92,57.43 92.47,57.43 94.11,55.79 99.31,55.79 99.8,55.31 99.8,54.9 102.26,52.44 v2(112.9,52.44)
  BOTTOM w0.102: U46.A5 244.22,71.16 v2(244.42,70.96) ; UH1.G5 69.38,60.68 69.65,60.41 v2(69.68,60.43)
SIO_SLP_S3#: length 368.6
  TOP w0.102: R781.1 41.57,67.78 v2(41.64,67.7) ; v2(250.2,51.96) 250.58,52.33 250.58,55.22 250.11,55.68 250.11,57.19 249.71,57.6 249.71,64.62 247.67,66.66 244.52,66.66 244.07,67.12 244.07,68.42 243.38,69.11 243.38,70.52 242.37,71.54 241.71,71.54 v2(241.02,72.23) ; JIO1.34 20.71,93.3 v2(21.28,92.72)
  IN1 w0.109: v2(67.19,61.52) 67,61.33 67,59.04 66.9,58.94 66.9,55.19 67.66,54.42 67.66,51.65 69.25,50.07 69.25,49.09 70.29,48.05 74.16,48.05 74.75,47.46 77.04,47.46 78.02,46.48 81.25,46.48 83.04,44.69 93.07,44.69 93.88,45.5 96.59,45.5 v2(97.2,46.11) 97.43,45.89 106.43,45.89 106.76,45.56 111.02,45.56 114.38,42.2 120.27,42.2 122.2,40.28 172.04,40.28 172.04,40.28 172.58,40.28 172.58,40.28 172.7,40.28 172.7,40.28 173.24,40.28 173.24,40.28 173.66,40.28 174.39,41.01 177.26,41.01 178.12,40.15 183.31,40.15 183.59,39.87 187.4,39.87 187.88,40.35 192.91,40.35 200.02,47.46 210.46,47.46 211.4,48.4 215.15,48.4 218.23,51.47 226.64,51.47 227.41,50.71 231.39,50.71 232.87,52.19 241.76,52.19 242.52,52.95 242.52,53.57 242.9,53.95 243.52,53.95 244.1,53.37 245.72,53.37 246.01,53.66 246.54,53.66 246.97,53.23 248.93,53.23 v2(250.2,51.96)
  IN3 w0.127: v2(21.28,92.72) 22.4,92.72 26.64,88.48 26.64,84.57 31.42,79.79 34.7,79.79 37.16,77.34 37.16,73.75 40.22,70.69 40.22,69.13 v2(41.64,67.7) ; v2(54.76,69.86) 53.73,68.83 53.73,62.13 54.51,61.35 54.94,61.35 56.92,63.34 58.08,63.34 58.72,62.7 63.55,62.7 63.68,62.83 65.99,62.83 67.19,61.63 v2(67.19,61.52)
  BOTTOM w0.102: v2(241.02,72.23) 240.69,72.56 240.69,73.08 240.61,73.16 240.61,73.6 240.73,73.71 U46.B65 ; JAPS1.2 13.49,120.94 13.08,120.54 13.08,119.98 13.49,119.57 16.86,119.57 19.43,117.01 19.43,114.97 21.92,112.48 v4(21.92,109.4) 21.92,104.03 22.58,103.37 22.58,97.65 23.11,97.12 23.11,94.81 21.28,92.98 v2(21.28,92.72) ; v2(54.76,69.86) 53.54,71.08 51.15,71.08 50.44,70.36 50.44,68.71 49.63,67.91 48.02,67.91 47.75,68.17 43.15,68.17 42.68,67.7 v2(41.64,67.7) ; v2(97.2,46.11) 98.27,45.05 98.27,33.11 99.92,31.47 99.92,30.92 PR403.1 ; UH1.H1 67.33,61.66 v2(67.19,61.52)
