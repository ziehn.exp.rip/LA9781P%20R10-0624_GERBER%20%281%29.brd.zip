# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 21.2
  TOP w0.102: R571.2 v1(45.13,156.58)
  TOP w0.508: R574.2 v3(55.35,155.59) ; v3(46.46,155.59) R571.2 ; R573.2 v3(47.73,155.59) ; R572.2 v3(54.08,155.59)
  IN4 w0.508: v3(46.46,155.59) v3(47.73,155.59) 48.56,154.75 53.24,154.75 v3(54.08,155.59) v3(55.35,155.59)
  BOTTOM w0.508: C485.2 60.28,155.24 59.66,154.62 56.31,154.62 v3(55.35,155.59)
V1N: length 6.3
  TOP w0.254: v2(159.51,161.28) 159.69,161.1 159.69,160.52 PR516.1
  BOTTOM w0.254: PR546.2 158.57,163.59 v1(158.98,163.18) 159.51,162.65 v2(159.51,161.28)
V2N: length 11.6
  TOP w0.254: PR518.1 160.04,160.54 160.04,161.1 v2(160.22,161.28)
  BOTTOM w0.254: v2(160.22,161.28) v1(160.22,162.03) 160.22,163.08 159.13,164.17 158.09,164.17 157.76,164.5 153.49,164.5 152.63,163.64 PR556.2
V3N: length 2.1
  BOTTOM w0.254: PR557.2 153.54,163.59 153.97,164.02 v1(154.38,164.02) 154.86,164.02 PR547.2
VCC_PGOOD: length 3.6
  TOP w0.203: PU500.3 156.55,172.11
  TOP w0.254: PR522.2 158.47,173.44 157.91,172.89 157.33,172.89 v1(156.96,172.52) 156.55,172.11
VCCPWRGOOD_0_R: length 15.8
  TOP w0.102: RC130.1 200.43,146.85 200.43,145.5 RC25.2 200.91,144.67 v1(200.04,143.79) 198.42,142.18 197.89,142.18 196.76,141.05 193.73,141.05 192.25,139.57 192.25,139.26 192.06,139.06 192.06,138.31 JCPU1.AL34
VCCSENSE: length 79.4
  TOP w0.254: RC66.2 v2(199.74,146.57) RC67.2 ; PC520.1 148.21,171.16 PR536.1 v1(149.77,171.16) 150.34,171.16 PC544.1 151.3,170.19 PC542.2 150.4,169.3 v2(149.69,168.59)
  IN2 w0.305: v2(199.74,146.57) 199.52,146.34 199.52,145.23 196.99,142.71 166.45,142.71 155.18,153.99 152.03,153.99 150.34,155.67 150.34,157.27 149.63,157.99 149.63,166.45 150.37,167.19 150.37,167.92 v2(149.69,168.59)
VCCSENSE_R: length 11.8
  TOP w0.254: JCPU1.AL35 191.28,139.15 191.28,139.57 193.44,141.73 196.37,141.73 v1(197.69,143.05) 198.33,143.05 199.49,144.22 199.49,144.64 RC67.1
VDD_1.35V: length 5.3
  TOP w0.508: v3(151.99,20.38) 151.99,19.37 151.61,18.99 v1(150.54,18.99) 149.33,17.77 v3(149.33,16.83)
VDD_PWRGD: length 2.6
  BOTTOM w0.254: R389.2 30.31,94.43 31.45,93.28 U29.13
VSSSENSE: length 78.1
  TOP w0.203: 153.04,168.56 153.23,168.56 153.42,168.75 PU500.13
  TOP w0.254: RC68.2 v2(198.86,146.57) RC70.1 ; v2(152.42,169.43) 151.47,169.43 PC544.2 151.63,168.96 152.09,168.96 152.21,168.85 v1(152.45,168.85) 152.74,168.55 153.04,168.55 153.04,168.56
  IN2 w0.305: v2(198.86,146.57) 199.11,146.32 199.11,145.4 196.82,143.12 166.62,143.12 155.35,154.39 152.2,154.39 150.75,155.84 150.75,157.44 150.04,158.15 150.04,166.28 150.93,167.17 150.93,168.44 151.89,169.41 152.4,169.41 v2(152.42,169.43)
  BOTTOM w0.254: PC546.2 152.93,169.61 152.75,169.43 v2(152.42,169.43)
VSSSENSE_R: length 11.7
  TOP w0.254: JCPU1.AK35 190.59,138.88 190.9,139.18 190.9,139.73 193.28,142.11 196.14,142.11 197.52,143.5 198.18,143.5 v1(198.68,144) 199.11,144.42 199.11,144.64 RC68.1
3301_ACAV_IN_NB: length 2.4
  BOTTOM w0.254: PU1001.24 261.97,35.11 v1(262.22,35.36) 262.48,35.62 PR1019.1
3301_DC_IN_SS: length 3.6
  BOTTOM w0.102: PR1010.2 266.47,28.85 v1(266.77,28.55)
  BOTTOM w0.254: PU1001.34 265.31,30.18 265.83,29.66 PR1010.2
3301_PWRSRC: length 5.3
  BOTTOM w0.102: PR1029.1 255.98,31.33 254.27,31.33 v1(253.74,31.85)
  BOTTOM w0.254: PU1001.15 257.28,31.68 257.15,31.81 PR1029.1
24737_BST_CHG_MODE#: length 36.7
  IN1 w0.109: v2(252.74,15.56) 251.77,16.53 242.93,16.53 237.15,22.31 v2(237.15,23.38)
  BOTTOM w0.102: PQ707.2 253.08,15.22 v2(252.74,15.56) 252.55,15.75 PR718.1
  BOTTOM w0.254: v2(237.15,23.38) 237.15,24.4 235.9,25.64 v1(234.39,25.64) 233.61,25.64 232.9,24.93 232.9,24.5 232.69,24.28 231.96,24.28 PR757.2 231.14,24.83 230.66,25.31 230.66,25.88 229.94,26.59 228.48,26.59 228.29,26.79 PU700.11
+ADDR_XEN: length 3.1
  BOTTOM w0.254: 38.1,90.97 37.79,91.28 U29.32
  BOTTOM w0.508: 38.1,90.97 38.1,90.34 v1(38.58,89.85) R393.1
+BL_PWR_SRC: length 2.1
  BOTTOM w0.508: Q21.6 98.26,155.28 98.67,154.87 v2(98.67,154.6) ; v2(99.34,154.58) 99.34,155.39 Q21.5
  vias: v2(96.2,158.59) v2(96.2,157.95) v2(96.79,157.95) v2(97.37,157.95) v2(127.65,157.9) v2(127.65,157.28) v2(128.18,157.58) v2(128.78,157.65) v4(96.79,158.85)
+CAMERA_VDD: length 0.6
  BOTTOM w0.102: v3(28.48,114.11) v1(28.48,114.73)
  vias: v3(5.18,124.27) v3(5.15,123.64)
+CAP_LDO: length 11.2
  TOP w0.508: v2(229.72,68.24) 229.79,68.31 229.79,70.12 230.73,71.06 232.71,71.06 232.92,71.26 v2(234.29,71.26)
  BOTTOM w0.102: v1(227.33,68.56) 227.65,68.24 v2(229.72,68.24)
  BOTTOM w0.254: U46.B46 233.88,70.91 234.24,71.26 v2(234.29,71.26)
  BOTTOM w0.508: v2(229.72,68.24) 230.29,68.81 C714.1
+CHAGER_SRC:
  vias: v1(213.92,33.39) v3(212.32,33.49) v3(212.32,32.86) v3(212.32,32.22) v3(212.95,33.08) v3(215.67,31.26) v3(216.38,31.26) v3(217.07,31.26) v3(217.73,31.26) v3(218.44,31.28)
+CHG_VCC: length 4.3
  BOTTOM w0.102: PR775.2 223.66,33.49 v1(223.95,33.49)
  BOTTOM w0.508: PR775.2 222.22,35.47 222.91,36.16 PD701.1
+COINCELL: length 3
  BOTTOM w0.102: PR1.1 v1(50.09,98.69)
  BOTTOM w0.508: PR1.1 50.15,99.82 JRTC1.1
+CRT_VCC: length 6.6
  TOP w0.381: R52.1 v2(85.75,166.69) 85.7,166.74 R47.1
  TOP w0.508: R50.1 v2(90.12,166.69) ; R48.1 91.67,166.32 91.73,166.26 v3(91.73,165.76)
  BOTTOM w0.102: v2(90.27,168.47) 90.27,169.08 v4(90.78,169.58)
  BOTTOM w0.508: U6.3 90.59,168.14 v2(90.27,168.47) 89.69,167.88 C14.1
+DC1_PWR_SRC: length 3.4
  BOTTOM w0.203: PU101.12 38.52,38.36 38.74,38.58 PC117.1
  BOTTOM w0.508: v3(40.28,39.59) 40.14,39.59 39.26,38.7 PC117.1
  vias: v1(39.58,32.18) v3(30.96,54.8) v3(31.6,55.06) v3(31.6,54.42) v3(31.6,53.79) v3(32.23,55.06) v3(32.23,54.42) v3(32.23,53.79) v3(32.87,55.06) v3(32.87,54.42) v3(32.87,53.79) v3(39.11,33.39) v3(39.14,34.02) v3(39.44,34.58) v3(39.98,35.14) v3(40.36,35.73)
+DC_IN: length 348.5
  TOP w0.508: PC9.2 23.95,63.35 PR16.1 23.95,61.3 v3(24.05,61.2) 23.76,60.91 PQ8.3 ; v3(239.88,13.32) 241.43,11.77 259.07,11.77 267.28,19.99 267.28,23.94 v3(266.7,24.52)
  IN2 w0.508: v3(24.05,61.2) 24.46,60.8 25.91,60.8 27.51,62.4 27.51,65.72 29.95,68.16 34.24,68.16 35.6,66.8 36.74,66.8 37.31,66.23 38.33,66.23 41.22,63.34 42.29,63.34 47.04,58.59 47.04,55.13 46.05,54.14 46.05,53.35 47.32,52.08 47.32,49.85 46.35,48.88 46.35,46.76 55.56,37.55 76.25,37.55 78.71,40.02 89.94,40.02 90.51,39.45 93.18,39.45 97.38,35.24 110.39,35.24 110.72,35.57 116.99,35.57 118.54,34.02 174.78,34.02 175.96,32.84 178.04,32.84 179.5,31.38 185.8,31.38 186.43,30.75 195.3,30.75 199.41,34.86 206.04,34.86 206.5,35.32 219.08,35.32 221.77,32.63 229.96,32.63 233.36,29.22 236.96,29.22 239.22,26.96 239.22,13.98 v3(239.88,13.32)
  IN3 w0.508: v3(24.05,61.2) 24.05,63.44 25.47,64.86 25.47,67.93 22.99,70.42 20.87,70.42 14.5,76.79 14.5,82.21 13.08,83.63 v3(6.48,83.63)
  BOTTOM w0.102: v4(241.37,12.9) 240.96,13.32 v3(239.88,13.32) 239.32,12.76 v4(239.32,12.37) ; v3(266.7,24.52) v4(267.4,24.52)
  BOTTOM w0.508: v3(239.88,13.32) 239.11,14.09 PR736.1 ; v3(266.7,24.52) 266.41,24.23 PR1011.1
+DC_IN_SS: length 323.6
  TOP w0.508: v3(42.68,69.55) 42.51,69.37 42.51,64.54 47.61,59.44 47.61,53.9 v3(47.04,53.33) ; v3(234.85,28.31) 234.42,28.31 233.12,29.6 233.12,31.45 231.79,32.78 226.46,32.78 224.97,34.26 v3(224.97,34.6)
  IN1 w0.508: v3(234.85,28.31) 234.85,28.18 235.41,27.62 238.97,27.62 239.52,28.17 246.48,28.17 247.03,27.62 259.28,27.62 259.79,28.13 265.61,28.13 267.13,29.66 v3(268.02,29.66)
  IN4 w0.508: v3(47.04,53.33) 47.09,53.28 47.09,53.24 49.07,51.26 49.07,45 51.52,42.55 51.8,42.55 55.61,38.74 57.03,38.74 60.94,34.82 66.64,34.82 67.71,33.75 75.13,33.75 75.52,33.36 80.42,33.36 80.96,32.82 96.45,32.82 98.36,34.73 103.15,34.73 103.32,34.9 110.33,34.9 111.06,35.64 116.79,35.64 118.87,33.55 168.2,33.55 168.79,34.15 173.21,34.15 173.92,33.44 189.6,33.44 191.51,35.36 191.51,36.25 192.71,37.44 199.46,37.44 200.5,38.47 204.26,38.47 205.22,39.43 208.04,39.43 209.49,40.88 218.4,40.88 224.69,34.6 v3(224.97,34.6) ; v3(1.62,70.8) 1.62,67.12 5.56,63.18 8.58,63.18 9.47,64.07 9.47,66.74 10.41,67.68 13.36,67.68 14.48,66.56 22.25,66.56 22.97,67.29 24.14,67.29 25.96,65.47 v3(28.7,65.47)
  BOTTOM w0.508: v3(28.7,65.47) 28.7,66.89 29.95,68.14 34.39,68.14 36.85,70.6 37.11,70.6 38.45,71.95 40.29,71.95 v3(42.68,69.55) ; v3(224.97,34.6) 224.97,35.26 PD701.3 ; PR1010.1 v3(268.02,29.66)
  vias: v1(5.28,73.74)
+DCIN_JACK:
  vias: v2(8.36,79.06) v2(8.38,78.4) v2(8.99,79.06) v2(8.99,78.42) v2(9.63,79.06) v2(9.63,78.42) v2(10.26,79.06) v2(10.26,78.42) v2(10.26,77.79) v2(10.39,77.15) v2(10.39,76.52) v2(10.39,75.88) v2(10.39,75.25) v2(10.39,74.61) v2(10.9,78.42) v2(10.9,77.79) v2(11.02,76.52) v2(11.02,75.88) v2(11.02,75.25) v2(11.02,74.61) v2(11.05,77.13) v2(11.66,75.88) v2(11.66,75.25) v2(11.66,74.61) v4(22.13,73.71) v4(22.57,75.73) v4(22.67,70.99)
+DIMM1_VREF_CA: length 64.3
  TOP w0.102: RD7.1 v1(148.31,75.93)
  TOP w0.254: v2(148.87,62.43) 149.34,62.9 JDIMM1.126
  TOP w0.508: v2(146.53,76.57) CD16.1 CD15.1 RD7.1
  IN1 w0.508: v2(148.87,62.43) 146.96,62.43 145.73,63.66 125.69,63.66 122.63,66.72 122.63,69.13 v2(121.92,69.84)
  IN4 w0.508: v2(146.53,76.57) 136.68,76.57 132.54,72.43 129.21,72.43 126.97,70.19 124.92,70.19 124.56,69.84 v2(121.92,69.84)
+DIMM1_VREF_DQ: length 13.9
  TOP w0.102: v1(197.37,66.65) 196.96,67.06 RD1.2
  TOP w0.356: JDIMM1.1 189.24,71.46 189.47,71.23 190.32,71.23
  TOP w0.508: 190.32,71.23 190.74,71.65 CD6.1 CD1.1 RD2.2 RD1.2
+DIMM2_VREF_CA: length 7.2
  BOTTOM w0.356: JDIMM2.126 149.34,74.23
  BOTTOM w0.508: 149.34,74.23 148.31,75.26 v1(148.31,76) CD42.1 CD41.1 RD16.1
+DIMM2_VREF_DQ: length 13.3
  BOTTOM w0.102: CD24.1 195.86,65.23 197.05,66.42 v1(197.41,66.42)
  BOTTOM w0.356: JDIMM2.1 189.24,63.01 189.76,62.49
  BOTTOM w0.508: 189.76,62.49 190.21,62.04 RD15.2 RD14.2 CD23.1 CD24.1
+DIMM3_VREF_CA: length 7.5
  TOP w0.356: 148.64,47.49 149.34,48.19 JDIMM3.126
  TOP w0.508: RD25.1 CD63.1 CD64.1 146.73,45.86 v1(147.52,46.65) 148.36,47.49 148.64,47.49
+DIMM3_VREF_DQ: length 13.6
  TOP w0.102: RD24.2 196.85,64.82 197.22,65.19 v1(197.41,65.19)
  TOP w0.356: JDIMM3.1 189.24,59.04 189.53,59.34
  TOP w0.508: 189.53,59.34 191.65,61.46 196.71,61.46 RD23.2 CD49.1 CD45.1 RD24.2
+DIMM4_VREF_CA: length 86
  IN1 w0.508: v3(123.67,64.58) 123.72,64.53 123.72,64.45 126.16,62.01 143.61,62.01 144.52,61.1 148.23,61.1 148.84,60.49 v2(148.84,60.48)
  IN3 w0.508: v3(123.67,64.58) 123.87,64.38 123.87,55.83 v3(123.89,55.82)
  BOTTOM w0.254: v2(148.84,60.48) 149.1,60.48 149.48,60.09 149.48,59.22 149.34,59.08 JDIMM4.126
  BOTTOM w0.508: v3(123.89,55.82) 123.89,55.74 123.09,54.94 123.09,53.53 123.24,53.38 123.24,45.23 122.35,44.34 122.35,39.64 124.33,37.66 137.09,37.66 v1(138.89,39.45) 145.3,45.86 RD34.1 CD86.1 CD85.1
+DIMM4_VREF_DQ: length 8.5
  BOTTOM w0.102: RD32.2 185.16,45.53 v1(185.02,45.39)
  BOTTOM w0.356: JDIMM4.1 189.24,48.92 189.46,48.71 189.46,48.04
  BOTTOM w0.508: RD32.2 RD33.2 CD67.1 CD68.1 188.7,46.37 189.46,47.13 189.46,48.04
+DOCK_PWR_BAR: length 131.6
  TOP w0.508: v3(130.71,116.4) PR1001.1
  IN2 w0.508: v3(229.06,34.35) 232.66,34.35 233.22,33.8 235.05,33.8 237.23,31.61 239.69,31.61 242.28,29.02 251.69,29.02 251.98,29.31 254.2,29.31 255.15,30.26 267.24,30.26 267.55,30.57 v3(268.02,30.57)
  IN3 w0.508: v3(188.87,27.17) 187.3,25.59 171.83,25.59 171.07,24.83 165.38,24.83 165.3,24.91 160.48,24.91 157.45,21.88 157.45,18.05 159.05,16.45 v3(160.88,16.45)
  BOTTOM w0.508: C703.1 81.34,114.17 v3(81.43,114.26) ; v3(268.02,30.57) PR1007.1 ; v3(188.87,27.17) 188.87,27.22 189.84,28.18 192.53,28.18 200.23,35.88 221.13,35.88 222.28,37.03 223.61,37.03 v3(223.9,36.74) 223.97,36.81 PD701.2 225.46,36.81 226.72,35.55 228.32,35.55 229.06,34.81 v3(229.06,34.35)
  vias: v1(161.71,21.3) v3(8.99,58.36) v3(9.75,58.36) v3(10.13,59.75) v3(10.64,58.36) v3(11.02,59.75) v3(11.53,58.36) v3(11.78,59.75) v3(12.42,58.36) v3(12.55,59.75) v3(13.18,58.36) v3(13.31,59.75) v3(13.94,58.36) v3(14.2,59.75) v3(120.93,119.67) v3(120.85,117.97) v3(122.02,115.56) v3(122.29,116.21) v3(122.45,120.23) v3(122.74,115.6) v3(122.86,120.92) v3(123.01,116.21) v3(123.42,115.58) v3(123.49,120.21) v3(123.75,116.18) v3(124.12,115.61) v3(124.48,116.15) v3(124.59,120.03) v3(160.88,15.69) v3(160.88,14.8) v3(161.64,16.45) v3(161.64,15.69) v3(161.64,14.8) v3(162.41,16.45) v3(162.41,15.69) v3(162.41,14.8) v3(163.17,16.45) v3(163.17,15.69) v3(163.17,14.8)
+DP_VCC: length 0.6
  BOTTOM w0.102: v2(291.84,139.19) 291.84,139.64 v4(291.72,139.76)
+EDPVDD:
  vias: v1(123.46,153.59) v3(114.91,166.64) v3(114.91,165.98) v3(115.54,166.56) v3(115.54,165.9) v3(121.51,154.12) v3(122.15,154.12) v3(122.66,153.66) v3(123.11,154.19)
+LCDVDD: length 1.4
  BOTTOM w0.102: v2(92,158.74) 91.62,158.74 v4(91.44,158.92)
  BOTTOM w0.508: v2(92.02,158.03) 92.09,157.96 C298.1
  vias: v2(91.15,159.46) v2(91.77,159.45) v3(94.84,169.1) v3(95.48,169.1) v3(96.11,169.1) v3(96.75,169.1)
+LOM_VCT:
  vias: v1(114.26,130.72)
+MXM_PWR:
  vias: v1(18.08,133.83) v3(20.04,134.56) v3(20.04,133.92) v3(20.04,133.29) v3(20.04,132.65) v3(20.37,132.09) v3(20.75,134.56) v3(20.75,133.92) v3(20.75,133.29) v3(20.75,132.65)
+MXM_PWR_R: length 19.5
  TOP w0.508: v3(6.83,134.53) 6.83,135.94 6.14,136.63 6.14,139.88 8.02,141.77 8.02,144.84 8.41,145.23 R2180.1
  BOTTOM w0.381: U59.4 3.54,137.34 3.17,136.97 3.17,136.49 3.2,136.46
  BOTTOM w0.508: 3.2,136.46 v1(3.2,135.83) 3.91,135.12 3.91,135.14 3.94,135.12 PC6.2 6.37,135.12 6.45,135.19 PR14.2 7.26,134.96 v3(6.83,134.53)
+MXM_PWR_SRC:
  vias: v3(24.48,137.86) v3(24.48,137.22) v3(24.48,136.59) v3(24.48,135.95) v3(25.12,137.86) v3(25.12,137.22) v3(25.12,136.59) v3(25.12,135.95) v3(25.68,136.26) v4(18.3,137.25)
+MXM_PWR_SRC_A0: length 2.3
  TOP w0.381: U60.7 14.57,144.53 R2187.2
  TOP w0.508: R2187.2 R2185.1
+MXM_PWR_SRC_A1: length 2.4
  TOP w0.381: U60.8 13.5,145.18 13.77,145.45 R2186.2 R2184.1
+MXM_PWR_SRC_R: length 14.2
  TOP w0.508: v3(7.72,136.69) 6.96,137.45 6.96,139.57 8.66,141.28 R2181.1
  BOTTOM w0.381: U59.5 4.32,137.99 4.75,137.55 4.75,136.79
  BOTTOM w0.508: v3(7.72,136.69) 7.67,136.69 7.26,136.28 PR24.2 7.21,136.03 PC6.1 v1(5.1,136.03) 4.75,136.39 4.75,136.79
+MXM_SRC_EN#: length 5.3
  TOP w0.102: v1(13.85,131.78) 14.27,132.19 C774.1
  TOP w0.508: Q186.4 14.83,135.45 14.27,134.89 R940.2 ; R940.2 14.4,134.18 R944.1 ; R940.2 C774.1
+NBDOCK_DC_IN_SS: length 261
  TOP w0.508: v3(254.37,18.07) 255.01,18.07 258.19,21.25 258.19,36.44 v3(257.2,37.43)
  IN4 w0.508: v3(254.37,18.07) 253.56,18.87 240.02,18.87 228.45,30.44 224.08,30.44 217.47,37.05 211.33,37.05 210.87,37.5 v3(210.87,37.79)
  BOTTOM w0.203: JDOCK1.41 91.74,117.03
  BOTTOM w0.508: v3(210.87,37.79) 210.46,38.19 v1(210.46,57.02) 210.46,62.7 214.01,66.25 214.78,66.25 216.84,68.31 216.84,70.93 216.33,71.44 215.37,71.44 211.53,75.27 210.59,75.27 207.57,78.3 206.7,78.3 205.92,79.08 198.45,79.08 192.41,85.13 189.45,85.13 186.4,88.18 180.75,88.18 178.66,86.09 169.65,86.09 165.69,90.06 153.94,90.06 152.98,89.09 149.13,89.09 147.18,91.05 135.39,91.05 126.34,100.09 124.71,100.09 123.84,100.95 118.8,100.95 114.89,104.86 113.21,104.86 112.83,105.25 112.83,105.86 111.05,107.63 107.75,107.63 106.2,109.18 99.13,109.18 91.74,116.58 91.74,117.03 ; PR1024.2 257.4,37.22 v3(257.2,37.43) ; PQ1070.1 v3(254.37,18.07)
+PCH_DCPRTC: length 1.9
  TOP w0.508: v2(73.74,64.31) 73.84,64.21 74.34,64.21 CH54.1
  BOTTOM w0.254: UH1.P14 73.39,63.97 73.74,64.31 73.74,64.31 v2(73.74,64.31) 74.08,63.97 UH1.P16
+PCH_USB_DCPSUS1: length 3.8
  TOP w0.381: RH234.2 74.6,67.55 73.86,66.82 CH39.1 72.95,66.82 72.39,66.26 72.39,65.96 v2(72.37,65.95)
  BOTTOM w0.254: v2(72.37,65.95) 72.37,66.09 72.73,66.45 UH1.Y12
+PCH_USB_DCPSUS2: length 4.8
  TOP w0.254: v2(82.42,65.96) 82.78,65.96 v1(82.93,66.1) 83.28,66.45 84.4,66.45 CH58.1 85.57,67.63 RH239.2
  BOTTOM w0.254: v2(82.42,65.96) 82.42,66.06 82.12,66.36 UH1.Y35
+PCH_USB_DCPSUS3: length 2.3
  TOP w0.508: CH41.1 RH236.1
  BOTTOM w0.254: UH1.AJ28 78.89,69.91 v2(78.61,70.19) 78.33,69.91 UH1.AJ26
  vias: v1(79.37,71.6)
+PCH_VCC: length 7.8
  BOTTOM w0.305: 87.78,72.88 87.13,72.23 UH1.AP45
  BOTTOM w0.508: 87.78,72.88 v1(88.85,73.94) 89.49,74.59 89.49,74.85 90.06,75.42 CH64.1 90.07,75.6 90.67,76.2 CH63.1 90.67,76.48 92.02,76.48 LH2.2
+PCH_VCCCFUSE: length 17.2
  TOP w0.102: v1(78.48,55.18) CH66.1
  TOP w0.508: v2(76.76,55.23) 77.39,55.23 CH66.1 77.44,54.79 77.65,54.58 RH243.2 RH242.2
  IN2 w0.508: v2(76.76,55.23) 77.01,55.23 77.37,55.59 77.37,58.38 76.55,59.2 76.55,60.03 76.99,60.47 76.99,63.26 75.96,64.29 v2(75.36,64.29)
  BOTTOM w0.254: UH1.P18 74.98,63.97 75.3,64.29 v2(75.36,64.29)
  BOTTOM w0.305: UH1.P20 75.77,64 75.47,64.29 v2(75.36,64.29)
+PCH_VCCCLK: length 12.8
  TOP w0.254: v2(80.24,66.94) 80.29,66.94 80.29,66.99 80.24,66.99 80.24,66.97 80.21,66.99 79.75,66.99 CH69.1
  TOP w0.305: v2(82.37,68.55) v1(82.87,69.05) 85.16,69.05 85.66,68.55 CH70.1
  TOP w0.508: CH70.1 CH68.1 87.3,68.55 87.9,69.15 RH244.2 ; CH71.1 81.72,68.08 v2(81.72,68.55) ; CH67.1 80.65,68.51 v2(80.24,68.92)
  BOTTOM w0.254: UH1.AD34 81.6,68.14 81.6,68.43 v2(81.72,68.55) ; UH1.AA32 80.64,67.25 80.34,66.94 v2(80.24,66.94) ; UH1.AD36 82.71,68.2 v2(82.37,68.55) 82.37,68.31 UH1.AD35 ; UH1.AA30 79.83,67.27 80.16,66.94 v2(80.24,66.94) ; v2(80.24,66.94) 80.57,66.61 UH1.Y32
+PCH_VCCCLK3_3: length 5.5
  TOP w0.381: CH72.1 80.85,65.39 80.41,64.96 v2(80.24,64.96)
  TOP w0.508: CH74.1 81.08,65.25 CH72.1
  BOTTOM w0.254: UH1.V32 80.75,65.84 80.75,65.4 UH1.U32 80.31,64.96 v2(80.24,64.96) ; v2(79.87,63.1) 79.61,63.36 UH1.M29 ; UH1.M26 78.57,63.36 v2(78.9,63.04) 78.87,63.01 78.69,63.01 78.45,62.76 UH1.L26 ; v2(79.88,62.5) 79.65,62.5 UH1.L29
  vias: v1(79.4,60.42)
+PCH_VCCDSW: length 6
  TOP w0.076: RH232.2 69.04,65.72 69.29,65.47 v1(72.1,65.47) 73.66,65.47 v2(73.76,65.57)
  BOTTOM w0.254: v2(73.76,65.57) 73.68,65.57 73.4,65.29 UH1.U14
+PCH_VCCDSW3_3: length 412.5
  TOP w0.381: CC156.1 202.49,104.41 203,103.9 RC18.1 ; RC47.1 203.93,103.51 UC2.5
  TOP w0.508: RH80.1 70.76,54.14 70.38,53.76 v3(70.38,53.45) ; RC18.1 RC47.1 203.86,103.06 204.14,102.78 v3(206.42,102.78) ; v3(62.89,53.68) 62.89,53.4 65.15,51.14 66.72,51.14 69.54,48.32 70.26,48.32 70.97,49.04 v3(71.3,49.04) 71.3,49.11 71.73,49.54 RH217.2 ; RH216.2 v2(73.25,48.91) ; v2(58.22,57.62) 58.7,57.62 RH112.1 ; v3(57.61,61.33) 58.27,61.33 58.6,61.66 RH78.1
  IN1 w0.508: v3(23.47,114.19) 23.44,114.19 22.6,115.02 20.45,115.02 19.86,114.44 11.2,114.44 9.57,116.07 9.57,120.21 v3(9.63,120.26) ; v3(222.17,38.04) 227.91,38.04 228.24,37.71 234.11,37.71 235.18,36.64 240.64,36.64 241.56,37.56 246.81,37.56 247.5,36.87 247.5,36.74 v3(247.55,36.69) ; v3(70.38,53.45) 70.38,50.48 71.3,49.57 v3(71.3,49.04) ; v3(45.44,85.36) 46.53,86.45 51.79,86.45 55.45,82.79 56.29,82.79 56.87,82.21 v3(56.87,82.06)
  IN2 w0.508: 57.96,57.62 v2(58.22,57.62) ; 57.96,57.62 57.68,57.62 57.33,57.98 57.33,61.05 v3(57.61,61.33) ; 57.96,57.62 56.41,56.07 54.96,56.07 54.48,55.59 54.48,53.56 55.9,52.13 61.39,52.13 62.89,53.63 v3(62.89,53.68) ; v3(70.38,53.45) 70.38,53.68 71.6,54.9 75.77,54.9 v2(75.87,55) ; v2(73.25,48.91) 73.2,48.91 73.56,48.55 78.87,48.55 79.73,47.69 84.88,47.69 85.89,46.67 93.39,46.67 94.72,45.35 108.36,45.35 109.22,44.49 109.22,44.01 111.43,41.8 118.47,41.8 120.25,40.02 123.87,40.02 125.04,38.85 173.58,38.85 174.57,39.84 177.46,39.84 177.9,39.4 192.82,39.4 193.65,40.22 203.81,40.22 v3(204.01,40.42) ; v3(206.42,102.78) 205.84,102.2 205.84,79.39 203.58,77.13 203.58,72.2 204.37,71.41 204.37,67.37 v3(207.75,64)
  IN3 w0.508: v3(23.47,114.19) 23.8,114.19 39.18,98.81 39.18,92.2 41.96,89.42 41.96,89.04 45.44,85.56 v3(45.44,85.36)
  IN4 w0.508: v3(57.61,61.33) 57.81,61.33 58.27,61.79 58.27,63.34 56.72,64.88 56.72,65.81 57.38,66.46 57.38,72.31 57.76,72.69 57.76,81.65 57.35,82.06 v3(56.87,82.06)
  BOTTOM w0.254: UH1.A16 74.28,56.45 75.16,55.58 75.16,55.18 CH44.1 ; JAPS1.3 12.77,121.44 12.13,120.8
  BOTTOM w0.457: v2(75.87,55) 75.34,55 CH44.1
  BOTTOM w0.508: R835.1 v3(247.55,36.69) ; v3(207.75,64) v4(207.75,47.66) 204.57,44.49 204.57,43.12 204.01,42.56 v3(204.01,40.42) 207.95,36.49 220.62,36.49 v3(222.17,38.04) ; 12.13,120.8 11.58,120.26 v3(9.63,120.26) ; v3(71.3,49.04) 71.84,49.58 RH238.2 RH237.2 73.76,49.31 73.35,48.91 v2(73.25,48.91)
+PCH_VCCDSW_R: length 1.9
  TOP w0.089: v1(67.7,64.77) 67.54,64.94 RH232.1
  TOP w0.102: CH40.1 67.54,66.61 RH232.1
+PCH_VCCSST: length 2.2
  TOP w0.508: v2(73.75,67.6) 73.56,67.6 73.51,67.55 72.64,67.55 72.59,67.6 72.58,67.6 72.35,67.83 CH46.1
  BOTTOM w0.254: UH1.AA14 73.42,67.27 v2(73.75,67.6)
+PECI_VREF: length 5.8
  BOTTOM w0.254: 248.23,41.87 247.94,42.17 U51.B51
  BOTTOM w0.508: 248.23,41.87 248.23,40.68 248.92,39.99 v1(249.72,39.99) 250.9,39.99 C740.1 R866.1
+PWR_SRC: length 192.1
  TOP w0.508: PQ4.3 40.01,80.24 38.62,78.85 38.62,76.43 38.96,76.09 R933.1 39.93,76.09 v3(40.31,75.71) ; PQ4.3 40.01,83.25 40.47,83.72 PC7.1 ; PQ4.3 38.57,83.49 PR15.1 ; v3(204.82,33.59) 204.82,34.66 205.56,35.4 211.56,35.4 215.01,31.94 229.8,31.94 232.26,29.49 232.26,27.34 233.09,26.51 233.83,26.51 234.36,27.04 v3(235.1,27.04) ; PC1001.1 131.04,113.6 v3(130.53,114.11)
  IN2 w0.508: v3(27.28,79.13) 28.07,79.92 35.1,79.92 38.02,77 38.02,76.47 38.78,75.71 v3(40.31,75.71)
  IN3 w0.508: v3(29.82,59.32) 29.82,61.77 31.44,63.4 31.44,65.39 30.94,65.9 30.94,72.35 27.74,75.55 27.74,78.68 v3(27.28,79.13)
  IN4 w0.508: v3(254.1,32.65) 253.02,32.65 251.84,31.47 250.17,31.47 249.89,31.75 248.42,31.75 247.98,31.32 246.1,31.32 245.52,30.74 242.89,30.74 239.99,27.84 235.9,27.84 v3(235.1,27.04)
  BOTTOM w0.508: PR1029.2 254.67,31.81 254.1,32.39 v3(254.1,32.65)
  BOTTOM w2.667: 106.15,8.83 106.15,12.51 112.48,18.84 118.65,18.84 124.6,12.89 167.74,12.89 169.77,14.92 175.11,14.92
  vias: v3(1.88,60.54) v3(2.49,60.82) v3(2.49,60.19) v3(2.49,59.53) v3(2.49,58.89) v3(2.51,58.26) v3(3.12,60.82) v3(3.12,60.19) v3(3.12,59.53) v3(3.12,58.89) v3(3.15,58.26) v3(3.76,60.8) v3(3.76,60.16) v3(3.76,59.5) v3(3.76,58.87) v3(3.78,58.23) v3(4.39,60.8) v3(4.39,60.16) v3(4.39,59.5) v3(4.39,58.87) v3(4.42,58.23) v3(5.05,58.23) v3(5.69,58.23) v3(6.32,58.23) v3(7.47,106.41) v3(7.62,107.05) v3(7.72,105.73) v3(8.1,104.97) v3(8.43,107.15) v3(8.36,106.49) v3(8.74,105.73) v3(9.12,106.49) v3(9.12,104.84) v3(9.19,107.15) v3(9.5,105.73) v3(9.88,106.49) v3(9.96,107.15) v3(10.01,104.84) v3(10.39,105.73) v3(10.72,107.15) v3(10.64,106.49) v3(11.02,104.97) v3(28.42,60.69) v3(28.4,60.06) v3(28.45,59.35) v3(28.45,58.69) v3(29.13,59.35) v3(29.13,58.66) v3(29.82,58.64) v3(31.34,8.83) v3(31.72,8.32) v3(32.1,7.81) v3(32.49,7.3) v3(67.59,104.41) v3(67.69,102.88) v3(68.12,103.54) v3(68.15,105.17) v3(68.73,102.83) v3(68.83,104.41) v3(69.32,103.69) v3(69.47,105.07) v3(69.72,102.91) v3(70,104.41) v3(70.33,103.62) v3(70.61,105.09) v3(70.99,102.88) v3(71.07,104.36) v3(71.6,105.09) v3(71.68,103.59) v3(72.06,104.23) v3(72.06,102.88) v3(103.33,7.46) v3(103.35,8.95) v3(103.35,8.19) v3(104.11,8.95) v3(104.11,8.19) v3(104.11,7.43) v3(109.14,155.59) v3(109.63,156.22) v3(109.78,155.59) v3(110.13,156.66) v3(122.9,107.67) v3(123.53,107.57) v3(124.14,108.31) v3(124.17,107.62) v3(124.38,110.17) v3(124.38,109.54) v3(124.39,108.89) v3(124.78,108.34) v3(124.8,107.62) v3(125.4,107.93) v3(125.47,108.57) v3(126.12,108.59) v3(133.3,153.58) v3(133.77,154.05) v3(133.86,153.2) v3(134.34,153.68) v3(140.18,29.4) v3(140.82,29.4) v3(141.45,29.4) v3(142.09,29.4) v3(142.85,29.4) v3(165.58,172.28) v3(165.9,172.85) v3(166.22,172.28) v3(166.53,172.85) v3(166.85,172.28) v3(167.17,172.85) v3(167.49,172.28) v3(167.8,172.85) v3(168.12,172.28) v3(168.44,172.85) v3(168.76,172.28) v3(169.09,172.86) v3(169.39,172.28) v3(169.39,171.59) v3(169.72,172.86) v3(170.03,171.59) v3(170.05,172.28) v3(170.36,172.86) v3(170.69,172.28) v3(170.66,171.59) v3(176.88,15.81) v3(176.88,15.18) v3(176.88,14.42) v3(176.88,13.65) v3(177.65,15.81) v3(177.65,15.18) v3(177.65,14.42) v3(177.65,13.65) v3(178.41,15.81) v3(178.41,15.18) v3(178.41,14.42) v3(178.41,13.65) v3(204.06,33.59) v3(204.06,32.96) v3(204.06,32.32) v3(204.82,32.96) v3(204.82,32.32) v3(204.82,31.69) v3(204.82,31.05) v3(205.46,31.69) v3(205.46,31.05) v4(24.79,59.87)
+PWR_SRC_MXM: length 2.9
  TOP w0.508: R940.1 13.36,136.26 13.82,136.72
  vias: v1(15.7,118.61) v3(13.79,138.75) v3(13.94,140.02) v3(14.58,140.02) v3(15.21,140.02) v3(15.47,116.78) v3(15.47,116.14) v3(15.8,117.44) v3(15.85,140.02) v3(16.1,116.78) v3(16.1,116.14) v3(16.1,115.51) v3(16.48,140.02) v3(16.48,138.75) v3(16.74,116.78) v3(16.74,116.14) v3(16.74,115.51) v3(17.12,140.02) v3(17.12,138.75)
+PWR_SRC_S: length 6.7
  TOP w0.102: v4(43.67,79.74) 43.45,79.97 PQ4.1
  TOP w0.508: PQ4.1 PC8.1 40.97,76.11 R930.1
+RSVD_VCC3P3_2: length 3.6
  TOP w0.102: R554.2 116.48,87.57 115.92,88.13 v1(115.92,88.28) 115.92,88.95 115.19,89.69 U31.1
+RTC_CELL: length 384.5
  TOP w0.305: v3(20.7,62.27) 20.57,62.27 20.14,62.7 JIO1.136
  TOP w0.508: v3(31.39,96.51) 31.39,96.53 33.76,98.9 v3(33.76,98.97) ; v3(207.42,41.92) 209.62,41.92 215.14,36.41 222.29,36.41 223.25,37.38 226.96,37.38 227.3,37.03 v3(227.3,36.96) ; v3(242.42,36.59) 242.42,35.43 243.05,34.8 v3(243.05,34.1) ; v3(51.64,101.66) 49.17,99.2 42.52,99.2 41.68,100.04 v3(41.68,100.24) ; v3(69.57,51.75) 69.87,51.45 RH5.1 68.45,50.61 66.34,52.72 66.34,53.61 RH44.1 RH42.1
  IN1 w0.508: v2(67.89,56.43) 68.18,56.13 68.18,55.83 69.75,54.27 69.75,51.93 v3(69.57,51.75) ; v3(33.76,98.97) 40.41,98.97 v3(41.68,100.24)
  IN2 w0.508: v3(31.39,96.51) 30.91,96.03 24.81,96.03 23.34,94.55 23.34,89.93 22.45,89.04 22.45,82.87 23.6,81.73 25.25,81.73 25.75,82.23 30.66,82.23 v3(31.88,81.01) 34.82,81.01 36.08,82.27 36.9,82.27 38.72,80.46 41.81,80.46 45.49,76.77 48.18,76.77 51.26,73.7 51.26,60.29 50.9,59.93 50.9,50.3 51.39,49.82 51.39,47.71 55.6,43.5 57.91,43.5 58.05,43.36 59.19,43.36 62.15,46.32 63.12,46.32 63.85,47.05 64.82,47.05 66.27,48.5 66.78,48.5 69.57,51.3 69.57,51.5 ; v3(207.42,41.92) 206.25,43.09 195.65,43.09 194,41.44 178.1,41.44 177.37,40.7 120.7,40.7 118.97,42.43 113.38,42.43 108.86,46.95 94.05,46.95 92.52,48.49 79.82,48.49 79.15,49.16 73.89,49.16 73.33,49.72 71.35,49.72 69.57,51.5 ; v3(20.7,62.27) 20.22,62.27 19.81,62.68 19.81,64.43 20.32,64.94 22.38,64.94 22.93,64.38 24.08,64.38 25.12,65.42 25.12,67.48 28.85,71.21 28.85,73.47 v3(27.86,74.46) ; 69.57,51.5 v3(69.57,51.75)
  IN3 w0.508: v3(242.42,36.59) 242.42,38.1 241.18,39.35 238,39.35 236.46,37.81 v3(236.07,37.81) 236.07,38.67 v3(234.88,39.86) 234.61,39.86 232.46,37.71 228.05,37.71 v3(227.3,36.96)
  BOTTOM w0.089: 69.8,57.49 69.77,57.49 69.77,57.82 70.3,58.35 UH1.A6
  BOTTOM w0.254: v2(67.89,56.43) 67.92,56.45 68.91,56.45 69.8,57.34 69.8,57.49 ; 31.36,95.56 32.13,94.78 U29.16
  BOTTOM w0.305: CH55.1 71.14,52.85 71.14,54.09 RH43.1
  BOTTOM w0.381: v3(41.68,100.24) C287.1 41.74,100.96 U10.5
  BOTTOM w0.508: v3(27.86,74.46) 27.95,74.55 v4(27.95,77.47) 27.95,77.73 31.23,81.01 v3(31.88,81.01) ; v3(234.88,39.86) 234.88,39.91 234.47,40.32 R880.1 ; v3(69.57,51.75) 69.57,52.18 70.15,52.77 RH67.2 CH55.1 CH56.1 CH57.1 ; R819.1 236.4,38.14 v3(236.07,37.81) 236.07,37.22 R810.1 ; R870.1 v3(243.05,34.1) ; v3(31.39,96.51) 30.45,96.51 C274.1 30.58,96.33 31.36,95.56 ; R390.2 v3(33.76,98.97) ; v3(51.64,101.66) 51.6,101.7 PD1.1 50.58,101.74 PC2.1 ; v3(242.42,36.59) 242.34,36.67 242.34,37.15 R1985.1
+RTC_CELL_VBAT: length 6.7
  TOP w0.508: v3(240.41,38.19) 240.99,38.77 v2(240.99,42.23)
  BOTTOM w0.254: v2(240.99,42.23) 241.05,42.17 U51.B64
  BOTTOM w0.508: R1985.2 C1353.1 240.46,38.24 v3(240.41,38.19)
+SA_DIMM1_VREFDQ: length 50.6
  TOP w0.508: v2(198.07,66.99) 197.94,67.12 v1(197.94,67.84) 197.89,67.89 197.89,68.97 RD1.1 ; v3(174.24,45.66) 173.89,45.3 RD43.1 RD41.2 RD44.2
  IN2 w0.508: v3(174.24,45.66) 174.24,49.9 175.03,50.69 189.79,50.69 192.43,53.33 192.43,58.08 197.74,63.39 197.74,64.76 198.5,65.52 198.5,66.56 v2(198.07,66.99)
  BOTTOM w0.508: RD14.1 197.28,62.93 197.86,63.51 197.86,64.86 198.65,65.65 198.65,66.41 v2(198.07,66.99)
+SA_DIMM_VREFDQ: length 199.3
  TOP w0.305: v2(166.09,119.3) 166.59,119.8 JCPU1.F16
  TOP w0.432: QD6.1 169.08,46.27 RD9.1
  TOP w0.508: v3(206.6,51.22) 206.6,49.57 203.94,46.9 188.21,46.9 187.65,47.46 169.89,47.46 169.53,47.1 RD9.1 ; v2(199.05,114.04) 199.05,114.03 199.55,113.53 v1(201.69,113.53) 202.2,114.03 208.15,114.03 210.36,111.82 210.36,104.61 206.86,101.11 206.86,98.41 204.32,95.87 204.32,85.69 201.95,83.32 201.95,73.7 204.98,70.68 204.98,66.64 206.53,65.09 v3(206.53,63.46)
  IN4 w0.254: 167.54,113.02 167.54,115.89 166.84,116.59 166.84,118.55 v2(166.09,119.3) 167.01,119.3 167.62,118.7 167.62,116.64 168.53,115.72 168.53,114.04 168.76,113.81 183.31,113.81 183.56,114.06 183.56,114.59 183.77,114.8 198.29,114.8 v2(199.05,114.04) 198.83,113.83 183.92,113.83 183.54,113.45 183.54,113.07 183.32,112.85 180.93,112.85 180.91,112.83 167.73,112.83 167.54,113.02
  BOTTOM w0.508: v3(206.6,51.22) 207.14,51.75 207.14,62.42 206.53,63.03 v3(206.53,63.46)
+SA_DIMM_VREFDQ_Q: length 3.6
  TOP w0.432: CD89.1 172.15,45.67 QD6.6 170.73,45.67 170.45,45.96 RD9.2
  TOP w0.508: CD89.1 172.19,44.84 RD41.1
+SB_DIMM2_VREFDQ: length 48.4
  TOP w0.508: RD50.2 RD49.1 RD48.2 168.82,42.02 v3(168.83,42.04) ; v2(187.22,48.07) 187.91,48.07 188.45,47.52 191.3,47.52 192.75,48.97 192.75,51.42 194.38,53.06 197.84,53.06 198.56,53.79 198.56,56.99 198.45,57.1 198.45,60.31 197.76,61 RD23.1
  BOTTOM w0.508: v2(187.22,48.07) 186.24,47.09 184.64,47.09 184.25,46.7 RD32.1 183.86,46.37 183.45,46.77 172.92,46.77 v1(170.55,44.4) 170.55,44.17 168.83,42.46 v3(168.83,42.04)
+SB_DIMM_VREFDQ: length 185.9
  TOP w0.305: JCPU1.F13 166.53,116.84 v2(166.06,117.31)
  TOP w0.508: QD6.4 170.28,44.37 169.78,43.88 RD11.1 169.78,41.96 167.38,39.56 v2(166.62,39.56)
  IN3 w0.508: v2(137.87,107.35) 141.3,103.92 141.3,97.35 129.64,85.69 129.64,82.74 127.76,80.86 127.38,80.86 126.21,79.69 126.21,74.79 126.03,74.61 126.03,73.55 123.67,71.19 123.67,70.3 122.4,69.03 122.4,67.22 122.99,66.64 122.99,56.92 v2(123.18,56.73)
  IN4 w0.254: 166.06,117.04 165.83,116.81 160.73,116.81 161.71,117.79 165.58,117.79 v2(166.06,117.31) 166.06,117.04
  IN4 w0.508: 160.73,116.81 160.05,116.13 160.05,104.06 156.82,100.83 144.8,100.83 140.21,105.42 139.8,105.42 v2(137.87,107.35)
  BOTTOM w0.508: v2(166.62,39.56) 165.56,40.63 143.51,40.63 v1(139.77,36.89) 124.05,36.89 121.74,39.21 121.74,44.62 122.63,45.5 122.63,53.07 122.27,53.43 122.27,56.14 122.86,56.73 v2(123.18,56.73)
+SB_DIMM_VREFDQ_Q: length 3.4
  TOP w0.508: RD11.2 168.02,42.91 RD48.1 CD91.1 168.06,44.37 QD6.3
+SDC_IN: length 312.2
  TOP w0.406: PU701.3 50.14,38.23 50.3,38.06 51,38.06 PC701.1
  TOP w0.508: 31.98,69.71 29.13,72.56 27.5,72.56 23.24,68.29 21.95,68.29 v3(21.59,67.93) ; 31.98,69.71 32.21,69.71 33.6,68.31 34.47,68.31 35.58,67.2 35.58,66.71 36.27,66.03 v3(36.47,66.03) ; 31.98,69.71 31.06,69.71 30.44,69.09 PC700.1 ; PC701.1 51.93,38.46 52.22,38.75 v3(52.22,39.82)
  IN1 w0.508: v3(36.47,66.03) 36.47,66.13 37.24,66.89 39.8,66.89 42.14,64.55 42.14,63.67 46.4,59.4 46.4,54.98 45.36,53.94 45.36,50.9 v3(45.1,50.64)
  IN3 w0.508: v3(7.77,64.17) 7.67,64.28 7.67,66.51 9.02,67.86 12.65,67.86 13.66,66.84 20.52,66.84 21.59,67.91 v3(21.59,67.93)
  IN4 w0.508: v3(260.45,24.37) 259.46,23.38 239.8,23.38 237.34,25.85 235.38,25.85 234.03,27.19 234.03,28.88 234.38,29.22 v3(234.38,29.91) 234.07,30.21 231.58,30.21 230.36,31.43 224.48,31.43 217.42,38.49 210.51,38.49 209.4,37.38 206.36,37.38 204.86,35.88 201.4,35.88 200.61,35.09 194.58,35.09 191.18,31.7 121.5,31.7 121.31,31.89 109.39,31.89 108.98,32.3 102.74,32.3 99.13,28.69 94.16,28.69 91.86,30.99 75.36,30.99 74.23,32.12 66.8,32.12 65.86,33.06 60.44,33.06 56.42,37.08 54.96,37.08 v3(52.22,39.82) 51.98,39.82 46.8,45 46.8,48.93 v3(45.1,50.64)
  BOTTOM w0.508: v3(234.38,29.91) 234.59,30.12 234.59,31.58 234.16,32.01 234.16,32.96 233.32,33.8 PR762.1 ; PR1015.1 v3(260.45,24.37)
  vias: v1(2.82,63.87)
+SIM_PWR: length 53.9
  TOP w0.508: v3(263.2,62.2) 261.69,60.69 261.69,41.03 263.19,39.54 263.19,37.12 264.55,35.76 264.55,25.93 263.35,24.73 263.35,21.93 v3(261.11,19.7)
  BOTTOM w0.102: v1(259.75,21.31) 260.36,20.7 C645.1
  BOTTOM w0.508: v3(261.11,19.7) 261.09,19.72 C645.1 261.1,20.69 C643.1 C616.1 263.44,20.37 JSIM1.1 ; JMINI1.8 v3(263.2,62.2)
+SM_VREF: length 120.5
  TOP w0.381: v2(193.06,106.31) 192.59,106.78 JCPU1.AM3
  TOP w0.508: v2(147.42,81.15) 147.04,81.53 147.04,82.17 QD7.3 147.05,82.59 RD10.1
  IN1 w0.508: v2(207.69,67.55) 208.69,68.54 208.69,69.13 213.16,73.6 213.16,81.14 v2(213.43,81.42)
  IN4 w0.508: v2(213.43,81.42) 213,81.85 213,83.63 195.35,101.28 195.35,103.14 194.79,103.7
  BOTTOM w0.508: v2(147.42,81.15) 147.48,81.15 150.11,83.78 165.95,83.78 168.79,80.94 178.32,80.94 180.76,78.5 183.75,78.5 187.31,74.94 203.77,74.94 208.12,70.59 v1(208.12,69.67) 208.12,67.98 v2(207.69,67.55)
+SM_VREF_DIMM: length 95.9
  TOP w0.102: v2(146.53,78.83) v1(145.57,78.83)
  TOP w0.508: RD7.2 148.82,78.63 RD47.2 RD45.2 RD46.1 v2(146.53,78.83) ; RD25.2 v2(144.5,43.75) 134.67,43.75 128.93,38.01 123.24,38.01 121.03,40.22 121.03,48.65 123.04,50.66 123.04,54.7 123.44,55.11 124.36,55.11 v2(124.64,55.39)
  IN3 w0.508: v2(124.64,55.39) 124.64,55.82 124.53,55.92 124.53,66.03 123.14,67.43 123.14,68.74 124.41,70.02 v2(124.41,70.68)
  IN4 w0.508: v2(124.41,70.68) 124.41,70.78 125.68,72.05 127.33,72.05 134.11,78.83 v2(146.53,78.83)
  BOTTOM w0.508: v2(144.5,43.75) 145.69,44.95 RD34.2 ; RD16.2 v2(146.53,78.83)
+SM_VREF_Q: length 9.2
  TOP w0.508: CD90.1 145.96,83.63 QD7.1 146.66,84.33 148.64,84.33 148.98,83.99 RD10.2 148.98,83.33 148.39,82.73 v1(148.39,82.14) 148.39,81.09 147.7,80.4 RD45.1
+SW_LX: length 30
  IN2 w1.524: 124.59,139.43 125.26,138.76 133.13,138.76 135.18,140.81 135.18,147.59 137.43,149.84 140.64,149.84 141.72,150.91 144.21,150.91
  BOTTOM w0.203: U23.17 124.53,141.63 124.64,141.52 124.64,141.31 v2(124.81,141.14)
  vias: v1(146.2,150.53) v3(144.98,151.93) v3(145.52,152.39) v3(147.29,151.91)
+SWR_V12: length 35.3
  IN2 w1.524: 125.04,155.11 130.01,155.11 131.84,153.28 131.84,151.27 132.66,150.44 ; 132.66,150.44 134.92,150.44 136.57,152.1 139.09,152.1 140.66,153.67 144,153.67 ; 132.66,150.44 132.24,150.03 132.24,146.48 129.07,143.31
  BOTTOM w0.203: 124.13,149.18 U23.43 ; v2(127.84,143.17) 127.71,143.3 U23.11 ; U23.15 125.33,141.59 125.8,141.11
  vias: v1(148.09,154.15) v2(126.31,140.98) v3(124.89,153.33) v3(124.87,152.67) v3(125.45,152.95) v3(126.19,140.07) v3(127.89,140.73) v3(145.26,153.73) v3(145.9,153.73) v3(146.53,153.73)
+TRM_CT1: length 3.5
  BOTTOM w0.102: C479.1 55.81,145.67 v1(56.55,144.93)
  BOTTOM w0.508: C479.1 55.35,147.65
+TRM_CT2: length 3.4
  BOTTOM w0.102: C480.1 53.44,145.67 v1(52.89,145.12)
  BOTTOM w0.508: C480.1 T156.4
+TRM_CT3: length 3.4
  BOTTOM w0.102: v1(48.9,145.01) 48.24,145.67 C484.1
  BOTTOM w0.508: C484.1 T156.9
+TRM_CT4: length 3.3
  BOTTOM w0.102: C486.1 45.69,145.67 v1(45.28,145.26)
  BOTTOM w0.508: C486.1 T156.10
+UIM_VPP: length 45.2
  TOP w0.102: v2(268.5,24.32) 268.5,36.79 267.59,37.71 267.59,53.76 263.09,58.26 v2(262.81,58.26)
  BOTTOM w0.102: v2(268.5,24.32) 268.35,24.32 267.03,23 266.57,23 v1(266.32,22.75) 265.96,22.39 265.96,21.25 C630.1 265.54,20.56 JSIM1.6 ; JMINI1.16 262.35,59 262.81,58.53 v2(262.81,58.26)
+USB1_REPEATER_VDD: length 24.4
  BOTTOM w0.102: v2(275.69,66.18) 275.69,65.75 v1(275.07,65.13)
  BOTTOM w0.254: U625.1 269.61,76.88 269.44,77.05 268.07,77.05 267.49,77.64 267.49,78.8 C450.1 ; U625.13 272.11,71.94 272.49,71.57 273.8,71.57 273.98,71.39 274.55,71.39 C453.1
  BOTTOM w0.508: R21.1 R15.1 R16.1 R18.1 267.99,81.17 v3(267.66,80.84) ; R23.1 v2(273.66,66.18) ; v3(266.47,80.05) 266.47,79.85 R94.1 C450.1 268.07,79.79 267.77,80.1 267.38,80.1 v3(266.93,80.56) ; R25.1 v2(271.63,66.18) ; Q90.1 v3(264.51,79.59) ; C453.1 274.52,71.57 273.96,72.12 v2(273.94,72.12) ; R24.1 v2(272.64,66.18) ; R22.1 v2(274.67,66.18) ; R12.1 v2(275.69,66.18)
  vias: v3(261.62,78.17) v3(262.33,78.19)
+UTLGND: length 4.3
  TOP w0.102: v2(125.4,140.86) 125.4,141.52 R1989.1 v1(123.46,141.97)
  BOTTOM w0.102: v2(125.4,140.86) 125.22,141.03 125.22,141.31 124.93,141.61 U23.16
+V_DDR_REF: length 48.3
  TOP w0.508: RD2.1 198.07,69.88 v3(198.51,69.43) ; v3(198.6,64.63) 198.23,64.26 RD24.1
  BOTTOM w0.203: PU200.4 150.37,25.61 PC209.1
  BOTTOM w0.508: 197.04,45.4 196.4,44.77 186.43,44.77 186.03,45.17 RD33.1
  BOTTOM w1.016: 187.93,30.87 189.09,30.87 190.64,32.43 190.64,35.21 197.04,41.61 197.04,59.56
  vias: v3(151,26.84) v3(151,26.15) v3(186.64,30.11) v3(187.4,30.11) v4(199.19,68.47)
+VCHGR: length 68.4
  IN3 w0.254: v3(191.87,27.12) 191.87,27.4 198.21,33.74 199.99,33.74 200.85,34.61 213.25,34.61 213.95,33.91 218.65,33.91 220.25,35.51 231.42,35.51 232.66,34.26 232.66,26.55 241.47,17.74 v2(242.35,17.74)
  BOTTOM w0.254: PQ1083.3 243.14,16.96 v2(242.35,17.74)
  vias: v3(189.71,26.48) v3(189.71,25.85) v3(189.71,25.21) v3(189.71,24.58) v3(190.37,26.48) v3(190.37,25.85) v3(190.35,25.21) v3(190.35,24.58) v3(191.11,27.12) v3(191.11,26.48) v3(191.11,25.85) v3(191.11,25.21) v3(191.11,24.58) v3(191.87,26.48) v3(191.87,25.85) v3(191.87,25.21) v3(191.87,24.58) v3(194.03,17.72) v3(194.03,17.08) v3(194.03,16.45) v3(194.03,15.81) v3(194,15.18) v3(194.64,15.18) v3(194.66,17.72) v3(194.66,17.08) v3(194.66,16.45) v3(194.66,15.81) v3(195.3,17.72) v3(195.3,17.08) v3(195.3,16.45) v3(195.3,15.81) v3(195.27,15.18) v3(195.93,16.45) v3(195.93,15.81) v3(195.91,15.18) v4(195.54,13.84)
+VCOMP_OUT: length 3.2
  TOP w0.279: v2(167.1,125.52) 167.02,125.52 166.69,125.84 JCPU1.F22
  BOTTOM w0.102: v4(166.61,125.84) 166.77,125.84 v2(167.1,125.52)
  BOTTOM w0.508: RC1.1 RC2.1 167.28,125.33 v2(167.1,125.52)
+VDISPLAY_VCC: length 1.3
  TOP w0.508: R460.1 v2(40.23,162.68) ; R461.1 v2(39.34,162.68)
  vias: v3(38.3,166.61) v3(38.73,167.09) v3(39.22,166.61) v4(38.44,165.72)
+VR_CAP: length 3.4
  BOTTOM w0.102: v2(232.33,48.4) 231,48.4 v1(230.66,48.74)
  BOTTOM w0.254: v2(239.72,47.05) 239.72,47.13 239.29,47.56 238.81,47.56 238.71,47.67 U51.B12
+VTR_ADC: length 4.6
  BOTTOM w0.254: U51.A58 v1(242.3,39.42) 242.3,39.17 243.05,38.42 C757.1 C736.1 R845.2
A_ON: length 223
  TOP w0.102: v2(96.01,41.21) 96.44,41.64 96.9,41.64 97.51,41.03 97.51,40.5 R878.1 ; v2(242.01,50.1) 241.88,50.22 241.88,51.93 241.53,52.29 241.53,53.96 242.01,54.45 242.01,56.53 v2(240.54,58) ; v2(75.03,42.71) 74.65,43.09 74.27,43.09 73.79,42.61 64.39,42.61 63.22,41.44 62.64,41.44 61.67,42.41 v1(61.67,42.79) 61.45,43 61.45,55.77 PR315.2
  IN1 w0.109: v2(75.03,42.71) 77.04,40.7 90.22,40.7 90.96,39.97 94.76,39.97 v2(96.01,41.21)
  IN1 w0.117: v2(96.01,41.21) 96.47,40.75 102.6,40.75 102.87,40.48 112.69,40.48 113.56,39.61 119.5,39.61 122.48,36.64 175.11,36.64 176.29,37.82 179.11,37.82 181.75,35.18 190.51,35.18 191.86,36.53 193.19,36.53 200.55,43.88 203.61,43.88 204.94,45.21 220.59,45.21 221.64,46.26 229.55,46.26 230.03,46.73 233.01,46.73 233.45,46.3 235.8,46.3 236.59,45.5 237.36,45.5 237.64,45.78 237.64,46.54 238.73,47.63 240.96,47.63 241.55,48.23 241.55,49.82 241.83,50.1 v2(242.01,50.1)
  BOTTOM w0.102: v2(240.54,58) 240.89,57.65 R432.2 ; U51.B24 242.05,50.14 v2(242.01,50.1)
A_ON_R: length 4
  TOP w0.102: v1(98.46,41.82) 99.11,41.17 R877.2
  TOP w0.203: R877.2 R878.2 99.29,39.64 U40.3
A_PRE0: length 4.3
  BOTTOM w0.102: R42.2 R88.1 184.89,41.67 184.89,40.45 184.37,39.93 U26.9
A_PRE1: length 4.6
  BOTTOM w0.102: R40.2 R89.1 185.35,32.97 185.35,34.28 185.1,34.53 184.63,34.53 184.37,34.79 U26.17
AC_DIS: length 317.1
  TOP w0.102: v2(242.13,67.81) 242.13,67.5 242.49,67.15 242.49,66.41 242.72,66.18 242.72,65.33 244.16,63.89 244.59,63.89 246.32,62.17 246.56,62.17 247.14,61.58 247.14,55.44 248.32,54.26 248.32,50.66 248.44,50.54 248.44,47.79 249.02,47.21 249.43,47.21 249.78,46.85 250.32,46.85 251.05,46.11 251.05,44.85 249.65,43.45 248.74,43.45 248.06,42.76 248.06,40.92 251,37.98 251,32.89 v2(250.49,32.37) ; PQ8.5 24.69,59.96 24.1,59.37 24.1,58.79 24.74,58.15 v1(26.41,58.15) 27.46,58.15 27.79,58.48 27.79,60.44 27.61,60.62 27.61,62.68 26.62,63.67 26.62,66.61 v2(26.67,66.66)
  IN4 w0.109: v2(250.49,32.37) 248.16,32.37 247.72,31.94 245.84,31.94 245.27,31.36 234.2,31.36 234.06,31.51 231.34,31.51 230.68,32.17 224.97,32.17 217.92,39.22 210.34,39.22 209.15,38.03 206.07,38.03 204.68,36.64 201.2,36.64 200.33,35.76 194.28,35.76 193.6,35.08 192.61,35.08 190.16,32.63 172.58,32.63 172.05,33.16 169.07,33.16 168.68,32.77 109.68,32.77 108.57,33.88 103.32,33.88 103.05,33.61 98.57,33.61 96.94,31.97 80.32,31.97 79.7,32.58 75.2,32.58 74.81,32.98 67.27,32.98 66.36,33.89 60.78,33.89 56.76,37.91 55.34,37.91 51.48,41.77 51.2,41.77 47.63,45.34 47.63,50.93 45.45,53.11 45.45,59.75 42.17,63.03 33.97,63.03 30.67,66.33 29.46,66.33 29.12,66.66 v2(26.67,66.66)
  BOTTOM w0.102: v2(242.13,67.81) 242.17,67.78 242.69,67.78 U46.B12 ; v2(250.49,32.37) 250.49,31.76 248.38,29.66 PR1030.2
AC_PRESENT: length 208.5
  TOP w0.102: v2(227.68,51.32) 228.25,51.32 233.64,45.94 235.08,45.94 235.72,45.3 237.53,45.3 237.8,45.57 240.25,45.57 240.92,44.9 241.18,44.9 242.58,43.5 245.21,43.5 245.92,42.79 245.92,41.97 247.45,40.45 v2(247.45,38.88)
  IN1 w0.109: v2(69.89,59.87) 71.35,58.41 71.35,55.66 72.54,54.47 72.54,51.97 75.82,48.68 76.72,48.68 78.29,47.11 82.32,47.11 82.99,46.43 82.99,45.62 83.5,45.11 92.89,45.11 94.52,46.75 97.86,46.75 98.28,46.33 106.59,46.33 106.94,45.98 111.22,45.98 114.53,42.67 120.41,42.67 122.37,40.7 171.87,40.7 171.87,40.71 173.42,40.71 173.42,40.7 173.49,40.7 174.21,41.43 185.3,41.43 185.53,41.2 185.54,41.2 193.13,41.2 200.56,48.63 215.05,48.63 218.22,51.8 227.2,51.8 v2(227.68,51.32)
  BOTTOM w0.102: v2(247.45,38.88) 247.5,38.82 247.5,38.29 R835.2 247.39,38.24 246.68,38.95 245.44,38.95 245.13,39.26 244.52,39.26 v1(244.3,39.48) U51.A54 ; v2(69.89,59.87) 70.07,59.87 UH1.E6
ACAV_DOCK_SRC#: length 282.8
  IN4 w0.254: v2(261.29,22.92) 261.15,22.78 257.97,22.78 255.18,19.99 243.07,19.99 242.01,21.04 238.53,21.04 228.65,30.93 224.28,30.93 217.39,37.81 211.66,37.81 v2(211.63,37.78)
  BOTTOM w0.254: JDOCK1.42 91.74,129.8 92.86,130.92 92.86,132.87 94.3,134.3 113.45,134.3 115.94,131.81 118.87,131.81 120.73,133.67 126.64,133.67 130.29,130.02 130.29,128.72 132.13,126.88 132.13,118.09 133.09,117.13 133.09,109.18 136.57,105.7 140.12,105.7 145.59,111.18 153.08,111.18 158.16,106.1 158.16,101.51 161.9,97.78 188.86,97.78 191.42,95.21 197.07,95.21 202.78,89.5 207.85,89.5 212.88,84.47 212.88,81.16 214.4,79.64 214.4,75.85 220.45,69.81 220.45,68.67 219.74,67.96 218.34,67.96 215.92,65.55 214.32,65.55 213.49,64.71 v1(213.49,49.95) 213.49,46.27 211.63,44.41 v2(211.63,37.78) ; PR1017.1 261.34,23.74 PR1013.2 v2(261.29,22.92)
ACAV_IN: length 478.5
  TOP w0.254: v2(111.5,127.98) 112.19,127.98 112.48,127.69 U17.1 ; v2(259.56,24.37) 259.33,24.14 259.33,21.15 256.5,18.32 v2(256.5,17.02) 256.5,15.65 254.72,13.87 243.7,13.87 241.53,16.04 237.68,16.04 236.82,15.18 235.35,15.18 v2(235.23,15.05) 234.63,14.45 232.19,14.45 231.44,15.2 231.44,18.5 237.18,24.24 237.18,32.63 236.73,33.08 236.73,35.95 238.66,37.88 v2(238.66,40.35)
  IN1 w0.254: v2(111.5,127.98) 110.69,127.98 108.91,126.2 108.08,126.2 107.29,125.41 105.03,125.41 104.11,126.33 96.9,126.33 96.11,125.54 93.12,125.54 92.48,126.18 89.21,126.18 87.22,124.19 87.22,122.87 85.39,121.04 83.87,121.04 79.7,116.88 67.66,116.88 61.54,110.76 53.34,110.76 45.82,103.24 25.22,103.24 v2(24.03,102.05)
  IN2 w0.254: v2(24.03,102.05) 24.03,97.14 22.71,95.82 22.71,90.31 21.82,89.42 21.82,82.54 32.26,72.1 36.14,72.1 38,70.24 39.34,70.24 40.13,71.03 40.13,71.31 44.32,75.5 47.76,75.5 50.14,73.12 50.14,60.85 49.73,60.44 49.73,49.96 50.32,49.37 50.32,47.27 55.15,42.43 57.1,42.43 57.51,42.03 59.54,42.03 62.25,44.74 65.25,44.74 67.93,47.42 78.22,47.42 79.09,46.55 84.51,46.55 85.53,45.53 92.91,45.53 94.23,44.21 103.2,44.21 104.19,43.22 106.07,43.22 108.56,40.73 118.03,40.73 119.82,38.94 123.45,38.94 124.6,37.78 167.36,37.78 168.07,37.07 169.26,37.07 169.98,37.78 179.18,37.78 181.35,35.61 186.9,35.61 187.93,34.58 194.08,34.58 197.26,37.76 204.84,37.76 205.48,38.39 207.69,38.39 209.35,40.04 232.31,40.04 233.02,39.33 238.2,39.33 238.66,39.79 v2(238.66,40.35)
  BOTTOM w0.254: v2(238.66,40.35) 239.14,40.35 239.3,40.51 U51.A64 ; PQ707.3 253.63,15.87 254.79,17.02 v2(256.5,17.02) 256.82,17.02 257.11,16.73 PR717.1 257.11,15.4 PR772.2 ; PQ708.2 234.86,15.62 235.23,15.25 v2(235.23,15.05) ; U29.21 35.15,99.81 32.37,102.59 v4(24.57,102.59) v2(24.03,102.05) ; PR1021.1 v2(259.56,24.37)
ACAV_IN_NB: length 81.3
  TOP w0.102: v2(262.08,37.94) 262.08,37.67 264.05,35.69 264.05,26 262.05,24.01 262.05,22.77 261.69,22.42 261.69,21.02 259,18.33 259,16.4 256.08,13.48 243.7,13.48 241.61,15.56 v2(240.51,15.56)
  IN3 w0.127: v2(240,50.1) 240.31,50.1 240.54,49.87 240.54,49.26 240.77,49.04 241.43,49.04 243.2,47.26 247.8,47.26 249.17,48.63 251.1,48.63 251.15,48.68 254.27,48.68 259.54,43.41 259.54,40.48 v2(262.08,37.94)
  BOTTOM w0.102: PR742.1 240.04,18.17 240.73,17.48 240.73,15.77 v2(240.51,15.56) 240.51,14.81 v4(240.6,14.72) ; U51.B20 240.05,50.14 v2(240,50.1) ; PR1019.2 262.48,37.53 v2(262.08,37.94)
ACAVDK_SRC: length 5.9
  BOTTOM w0.102: PR1017.2 261.95,25.31 261.95,23.51 v1(262.36,23.1)
  BOTTOM w0.254: PU1001.4 261.97,27.76 262,27.72 262,26.58 PR1017.2
ACAVIN: length 2.5
  BOTTOM w0.254: PR1021.2 v1(259.56,26.89) 259.97,27.29 PU1001.8
ACDET: length 6.7
  BOTTOM w0.254: PU700.6 230.28,30.05 230.61,30.37 230.61,31.53 230.41,31.73 v1(230.41,32.07) 230.41,32.25 231.04,32.88 PC783.1 PR732.2 PR762.2
ACPRN: length 38.3
  IN3 w0.127: v2(254.06,15.15) 253.38,15.15 252.78,14.55 243.92,14.55 232.14,26.33 232.14,28.6 v2(230.12,30.62)
  BOTTOM w0.102: PR771.2 255.83,15.38 255.66,15.22 PQ707.5 254.13,15.22 v2(254.06,15.15) ; PU700.5 228.7,30.37 229.87,30.37 v2(230.12,30.62) 230.12,30.9 229.08,31.94 v1(229.03,31.94)
ADP_I: length 231.5
  TOP w0.102: v2(233.08,35.52) 232,35.52 229.16,38.37 229.16,39.59 229.49,39.92 229.49,45.81 228.4,46.9 v2(227.48,46.9) ; PR702.1 v2(48.25,40.97)
  IN3 w0.127: v2(233.08,35.52) 233.08,31.57 v2(233.78,30.87) 233.75,30.85 233.75,25.87 235.33,24.3 v2(236.09,24.3) ; v2(227.48,46.9) 226.98,46.9 226.58,46.5 218.46,46.5 208.78,36.82 197.09,36.82 193.3,33.03 179.4,33.03 177.4,31.03 175.68,31.03 174.81,30.15 156.84,30.15 154.77,32.22 145.42,32.22 142.3,35.34 123.54,35.34 122.54,34.34 118.11,34.34 116.39,36.06 111.73,36.06 111.04,35.37 82.25,35.37 81.76,35.87 67.85,35.87 67.01,35.03 56.66,35.03 53.25,38.44 53.25,40.01 52.28,40.97 v2(48.25,40.97)
  BOTTOM w0.102: v2(227.48,46.9) 227.48,47.5 v1(228.19,48.21) 229.07,49.09 PC746.1 R134.1 ; PR743.1 235.1,23.31 v2(236.09,24.3) ; v2(233.78,30.87) 233.15,31.51 PR704.1
ADP_I_R: length 5.7
  BOTTOM w0.102: U51.A12 236.58,47.92 v1(236.28,48.21) 236.02,48.48 234.86,48.48 234.77,48.39 233.04,48.39 232.59,48.84 R134.2
ALERT#: length 3.8
  TOP w0.203: PU500.32 158.27,170.35 158.55,170.63
  TOP w0.254: 158.55,170.63 158.65,170.63 v1(159.21,171.19) 159.66,171.64 v2(160.07,171.64) PR506.2
  BOTTOM w0.254: PR506.2 v2(160.07,171.64)
ALW_PWRGD_3V_5V: length 223.6
  TOP w0.102: v2(32.61,43.12) v1(33.27,43.12)
  IN3 w0.254: v2(237.23,40.78) 237.07,40.62 235.34,40.62 235.15,40.81 230,40.81 229.17,39.98 224.53,39.98 224,39.45 222.34,39.45 218.93,36.04 209.57,36.04 209.33,35.8 197.98,35.8 194.14,31.97 180.62,31.97 177.99,29.34 166.48,29.34 165.78,28.64 156.99,28.64 154.29,31.33 144.91,31.33 142.85,33.39 126.43,33.39 125.04,31.99 110.06,31.99 107.42,34.63 82.57,34.63 81.63,35.57 67.97,35.57 67.13,34.74 56.54,34.74 52.96,38.32 52.96,39.85 52.36,40.45 45.57,40.45 43.29,42.74 32.99,42.74 v2(32.61,43.12)
  BOTTOM w0.254: PR118.1 34.8,42.61 34.29,43.12 v2(32.61,43.12) ; U51.A1 237.6,42.09 237.23,41.72 v2(237.23,40.78)
ALWON: length 225.8
  IN4 w0.109: v2(62.48,44.06) 62.99,43.55 76.07,43.55 76.4,43.22 82.42,43.22 82.99,42.65 98.97,42.65 99.61,42.02 102.55,42.02 103.79,40.78 119.74,40.78 122.07,38.46 172.9,38.46 174.76,40.32 174.81,40.32 174.81,40.32 177.29,40.32 177.77,39.84 188.37,39.84 189.75,41.22 197.11,41.22 199.92,44.03 208.74,44.03 209.02,43.75 220.04,43.75 221.38,42.41 223.64,42.41 225.83,40.22 227.28,40.22 229.74,37.76 233.98,37.76 234.64,38.42 237.54,38.42 238.2,37.76 239.17,37.76 v2(239.7,38.29)
  BOTTOM w0.102: v2(62.48,44.06) 62.38,44.06 v4(60.7,42.38) 57.7,39.38 42.46,39.38 38.21,43.63 32.21,43.63 31.29,42.71 PR112.1 ; U51.A60 241.3,40.35 241.12,40.17 241.12,39.71 v2(239.7,38.29)
AUD_HP_NB_SENSE: length 266
  TOP w0.102: JIO1.69 14.17,82.53 15.38,82.53 15.59,82.31 17.5,82.31 18.06,82.87 18.06,86.97 v2(17.92,87.11)
  IN3 w0.127: v2(17.92,87.11) 18.96,87.11 19.78,86.29 21.9,86.29 23.98,84.21 25.93,84.21 26.52,83.63 26.52,82.6 30.21,78.91 30.21,74.46 36.31,68.36 38.56,68.36 41.79,65.13 41.79,64.49 42.63,63.65 42.63,62.17 44.65,60.15 44.65,57.81 54.1,48.36 57.28,48.36 62.51,43.13 75.2,43.13 75.85,42.48 98.73,42.48 99.8,41.42 100.38,41.42 101.14,40.65 120.51,40.65 122.03,39.13 144.2,39.13 147.2,36.13 167.23,36.13 167.99,36.89 172.72,36.89 174.24,38.42 180.47,38.42 181.23,39.18 187.56,39.18 188.86,40.48 193.24,40.48 197.83,45.07 204.24,45.07 218.46,59.3 219.81,59.3 222.81,62.29 222.81,63.44 224.99,65.62 225.44,65.62 v2(225.85,66.03)
  BOTTOM w0.102: U46.A41 232.39,69.66 232.03,70.02 231.46,70.02 231.3,69.86 231.3,68.96 230.17,67.83 v1(228.51,67.83) 227.21,67.83 225.85,66.46 v2(225.85,66.03)
AUD_NB_MUTE#: length 264.6
  TOP w0.102: JIO1.27 16.27,95.1 17.37,93.99 v2(17.37,93.89)
  IN3 w0.127: v2(231.32,68.03) 230.68,68.03 230.02,67.37 225.45,67.37 221.91,63.83 221.91,62.38 221.31,61.79 220.22,61.79 204.6,46.17 198.6,46.17 193.14,40.7 188.76,40.7 187.49,39.43 181.17,39.43 180.38,38.65 174.09,38.65 172.57,37.12 167.9,37.12 167.14,36.36 147.3,36.36 144.3,39.36 122.16,39.36 120.64,40.88 101.24,40.88 100.47,41.64 99.99,41.64 98.92,42.71 75.95,42.71 75.3,43.36 63.87,43.36 62.38,44.85 61.1,44.85 57.37,48.59 54.2,48.59 44.88,57.91 44.88,60.25 42.86,62.27 42.86,63.75 42.19,64.42 42.19,66.45 41.62,67.02 40.35,67.02 38.75,68.62 36.38,68.62 30.44,74.56 30.44,79 26.74,82.7 26.74,83.73 25.32,85.15 25.32,86.22 21.44,90.11 21.08,90.11 17.37,93.82 v2(17.37,93.89)
  BOTTOM w0.102: U46.A39 231.89,68.66 v1(231.7,68.47) 231.32,68.09 v2(231.32,68.03)
AUDIO_BACKLITE#: length 333.1
  TOP w0.102: v2(16.6,81.88) 14.16,81.88 JIO1.71
  IN4 w0.109: v2(254.75,57.75) 254.75,55.63 253.48,54.36 253.48,51.31 251.42,49.24 251.42,43.3 251.71,43 251.71,41.38 251.08,40.75 251.08,39.71 250.37,38.99 250.37,36.89 249.66,36.18 249.3,36.18 248.17,35.05 246.87,35.05 244.64,32.82 235.82,32.82 235.04,33.59 232.31,33.59 232.05,33.86 231.05,33.86 226.62,38.29 225,38.29 222.92,40.37 221.93,40.37 219.6,42.69 207.42,42.69 205.95,41.22 204.89,41.22 204.56,41.55 200.34,41.55 198.28,39.49 192,39.49 189.81,37.3 187.78,37.3 187.22,36.74 185.49,36.74 185.24,37 184.38,37 184.17,36.79 183.69,36.79 183.36,37.12 182.28,37.12 180.69,35.54 174.61,35.54 174.06,36.09 167.55,36.09 166.87,36.77 121.37,36.77 120.36,37.78 113.41,37.78 112.98,38.2 103.29,38.2 101.79,36.7 97.02,36.7 95.95,35.63 77.16,35.63 75.89,36.9 61.72,36.9 51.03,47.58 51.03,52.24 47.98,55.29 47.97,55.29 47.21,56.05 47.21,61.11 43.57,64.76 43.57,65.49 41.78,67.28 40.41,67.28 38.38,69.31 35.31,69.31 34.87,69.76 34.26,70.37 29.81,70.37 29.06,69.62 26.56,69.62 26.38,69.8 22.64,69.8 22.54,69.9 20.77,69.9 15.15,75.53 15.15,79.3 15.06,79.39 15.06,81.59 15.34,81.88 v2(16.6,81.88)
  BOTTOM w0.102: U46.B68 242.76,74.54 243.51,74.54 244.17,75.2 244.17,75.22 244.19,75.25 244.19,76.14 244.96,76.9 248,76.9 249.15,75.75 249.15,73.01 v1(249.31,72.85) 253.36,68.8 253.36,63 255.12,61.24 255.12,58.12 v2(254.75,57.75)
