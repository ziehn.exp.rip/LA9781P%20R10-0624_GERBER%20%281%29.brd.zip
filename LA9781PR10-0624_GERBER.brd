# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCI_DOCK: length 84.4
  TOP w0.102: v2(87.43,57.72) 87.12,58.03 RH162.2 CH76.1
  IN4 w0.109: v2(112.88,115.63) 112.01,114.77 112.01,108.19 112.6,107.61 112.6,105.39 110.54,103.33 110.54,102.3 109.1,100.86 109.1,99.73 107.45,98.08 105.35,98.08 103.77,96.5 101.07,96.5 91.77,87.2 91.77,84.93 93.27,83.43 93.27,77.33 92.57,76.63 92.57,71.09 95.35,68.31 95.35,65.47 92.38,62.5 90.25,62.5 89.01,61.25 89.01,59.3 v2(87.43,57.72)
  BOTTOM w0.102: JDOCK1.121 113.74,116.65 113.92,116.47 v1(113.92,115.72) 113.92,114.47 R756.1 113.6,114.48 113.6,114.91 v2(112.88,115.63)
CLK_PCI_LOOPBACK: length 61.7
  IN3 w0.127: v2(76.71,55.84) 76.88,55.84 77.39,55.33 77.39,54.98 78.51,53.86 78.99,53.86 79.42,53.43 83.72,53.43 85.89,55.6 86.51,55.6 86.91,55.21 86.91,53.73 87.26,53.38 89.33,53.38 89.46,53.51 89.46,55.34 89.59,55.47 90.74,55.47 90.87,55.34 90.87,54.11 90.99,53.99 93.66,53.99 93.79,54.11 93.79,54.71 93.66,54.84 92.04,54.84 91.92,54.96 91.92,55.43 v2(92.37,55.89)
  BOTTOM w0.076: UH1.D17 74.73,59.74 74.73,59.32 74.4,58.99 74.4,58.74 74.59,58.54 74.59,57.64
  BOTTOM w0.102: v2(76.71,55.84) 76.3,55.44 v1(76.25,55.44) 75.67,55.44 75.44,55.66 75.44,55.77 74.59,56.61 74.59,57.64 ; RH164.2 91.46,56.58 92.3,57.42 93.3,57.42 93.3,57.42 93.7,57.42 93.7,57.42 93.93,57.42 94.03,57.52 94.03,57.75 94.18,57.9 94.85,57.9 94.95,57.8 94.95,56.4 95.05,56.3 95.26,56.3 95.36,56.4 95.36,57.8 95.46,57.9 95.66,57.9 95.77,57.8 95.77,56.4 95.87,56.3 96.07,56.3 96.17,56.4 96.17,57.8 96.27,57.9 96.48,57.9 96.58,57.8 96.58,56.4 96.68,56.3 96.88,56.3 96.98,56.4 96.98,57.8 97.09,57.9 97.75,57.9 97.97,57.68 97.97,57.54 97.46,57.03 97.46,56.88 97.6,56.74 97.75,56.74 98.26,57.25 98.4,57.25 99.01,56.64 99.01,56.33 98.68,56 97.53,56 97.42,55.89 93.25,55.89 CH77.1 92.37,56.4 v2(92.37,55.89)
CLK_PCI_MEC: length 180.4
  TOP w0.102: RH160.2 87.55,61.02 CH16.1 88.75,60.31 89.25,60.31 89.36,60.21 90.24,60.21 90.6,59.86 90.6,58.99 90.75,58.84 v1(90.75,55.55) 90.75,55.16 v2(90.37,54.78)
  IN1 w0.109: v2(245.46,57.37) 244.92,57.9 243.77,57.9 243.13,57.26 238.92,57.26 238.27,57.92 230.85,57.92 229.97,57.04 213.38,57.04 211.2,54.86 200.06,54.86 192.32,47.12 172.62,47.12 172.24,46.75 131.49,46.75 131.05,47.19 127.49,47.19 127.14,47.54 122.08,47.54 121.53,48.09 118.64,48.09 113.79,52.95 96.72,52.95 94.89,54.78 v2(90.37,54.78)
  BOTTOM w0.102: U51.A29 245.3,52.03 245.28,52.05 245.28,52.48 245.52,52.72 246.24,52.72 246.61,53.09 246.61,55.36 R885.1 246.68,55.72 246.02,56.38 246.02,56.8 v2(245.46,57.37)
CLK_PCI_TPM: length 206.8
  IN3 w0.127: v2(91.36,40.48) 96.77,40.48 97.55,39.69 119.63,39.69 121.2,38.11 143.85,38.11 146.85,35.12 155.57,35.12 156.49,34.2 166.99,34.2 168.29,35.5 178.17,35.5 179.41,36.74 182.02,36.74 182.37,37.1 183.34,37.1 183.64,36.79 184.07,36.79 185.24,37.96 188.06,37.96 189.38,39.28 193.74,39.28 194.15,39.69 204.07,39.69 204.63,40.25 206.73,40.25 212.05,45.56 212.05,47.55 214.78,50.28 223.84,50.28 228.95,55.39 228.95,57.27 230.35,58.66 238.21,58.66 238.56,59.01 243.55,59.01 244.06,59.53 245.74,59.53 246.74,60.52 246.74,61.4 v2(246.73,61.41)
  BOTTOM w0.102: RH155.1 94.05,58.46 97.87,58.46 99.54,56.79 99.54,53.3 98.42,52.18 92.45,52.18 91.39,51.12 v1(91.39,44.03) 91.39,40.5 v2(91.36,40.48) ; v2(246.73,61.41) 246.91,61.23 247.75,61.23 RE5.1 248.82,60.16 249.17,60.16 249.71,60.7 U39.21
CLK_PCIE_CARD: length 117.6
  TOP w0.102: JIO1.28 20.39,95.1 20.48,95.19 21.23,95.19 21.94,95.9 21.94,96.28 v2(22.05,96.38)
  IN4 w0.117: v2(22.05,96.38) 21.79,96.64 21.79,97.01 23.39,98.62 32.56,98.62 32.94,98.23 37.15,98.23 37.53,98.61 72.09,98.61 77.18,93.52 78.13,93.52 78.36,93.29 v2(78.36,93.28)
  BOTTOM w0.102: RH122.2 93.9,66.29 95.69,66.29 96.55,67.16 96.91,67.51 96.91,67.51 102.86,73.46 102.86,85.52 97.07,91.3 79.22,91.3 77.88,92.65 77.88,93.34 77.97,93.43 78.21,93.43 v2(78.36,93.28)
CLK_PCIE_CARD#: length 117.6
  TOP w0.102: JIO1.26 20.24,95.7 20.49,95.45 21.12,95.45 21.68,96.01 21.68,96.21 21.5,96.38 v2(21.46,96.38)
  IN4 w0.117: v2(78.36,93.87) 78.3,93.8 77.3,93.8 72.21,98.9 37.42,98.9 37.04,98.51 33.06,98.51 32.67,98.9 23.27,98.9 21.5,97.13 21.5,96.42 v2(21.46,96.38)
  BOTTOM w0.102: v2(78.36,93.87) 78.19,93.7 77.86,93.7 77.61,93.45 77.61,92.54 79.11,91.03 v3(88.05,91.03) 96.96,91.03 102.59,85.41 102.59,73.57 96.8,67.78 96.8,67.78 96.36,67.35 95.58,66.56 93.89,66.56 RH121.2
CLK_PCIE_EXP: length 117.3
  TOP w0.102: JIO1.60 20.21,85.5 20.35,85.64 22.08,85.64 24.99,88.56 24.99,92.3 25.22,92.53 25.39,92.53 v2(25.54,92.37)
  IN4 w0.117: v2(25.54,92.37) 25.69,92.52 26.06,92.52 26.59,93.06 26.59,93.56 27.63,94.6 30.32,94.6 30.63,94.91 38.33,94.91 38.61,95.19 42.39,95.19 42.8,95.59 65.92,95.59 71.98,89.53 71.98,89.14 71.86,89.02 71.65,89.02 71.51,89.16 v2(71.51,89.17)
  BOTTOM w0.102: v2(71.51,89.17) 71.7,89.36 71.7,89.55 72.32,90.17 96.91,90.17 101.08,86 101.08,76.28 100.32,75.51 100.32,71.99 97.03,68.7 94.46,68.7 94.34,68.58 93.78,68.58 RH139.2
CLK_PCIE_EXP#: length 117.1
  TOP w0.102: JIO1.58 20.24,86.1 20.43,85.91 21.97,85.91 24.73,88.67 24.73,92.41 25.11,92.79 25.38,92.79 v2(25.54,92.96)
  IN4 w0.117: v2(25.54,92.96) 25.69,92.81 25.94,92.81 26.31,93.18 26.31,93.68 27.51,94.88 30.2,94.88 30.51,95.19 38.21,95.19 38.49,95.47 42.27,95.47 42.68,95.88 66.03,95.88 72.26,89.65 72.26,89.27 v2(72.39,89.14)
  BOTTOM w0.102: v2(72.39,89.14) 72.26,89 72.07,89 71.96,89.1 71.96,89.44 72.43,89.9 96.8,89.9 100.81,85.89 100.81,76.39 100.05,75.62 100.05,72.1 96.92,68.97 94.35,68.97 94.23,68.85 93.47,68.85 93.36,68.95 93.36,69.12 93.52,69.28 RH137.2
CLK_PCIE_LAN: length 44.5
  TOP w0.102: U31.44 112.33,88.39 112.4,88.33 112.4,88.13 v2(112.22,87.95)
  BOTTOM w0.102: v2(112.22,87.95) 112.38,88.11 112.38,88.22 111.99,88.61 106.93,88.61 103.61,85.28 103.61,83.71 103.71,83.61 105.65,83.61 105.9,83.35 105.9,82.72 105.65,82.47 103.71,82.47 103.61,82.36 103.61,73.14 95.69,65.23 92.24,65.23 92.02,65.01 91.08,65.01 90.94,64.87 90.94,64.68 RH92.2
CLK_PCIE_LAN#: length 44.5
  TOP w0.102: v2(112.8,87.95) 112.67,88.08 112.67,88.33 112.73,88.39 U31.45
  BOTTOM w0.102: RH82.2 91.24,65.28 91.91,65.28 92.12,65.49 95.58,65.49 103.34,73.25 103.34,82.48 103.6,82.73 105.54,82.73 105.64,82.83 105.64,83.24 105.54,83.34 v3(104.46,83.34) 103.6,83.34 103.34,83.6 103.34,85.39 106.82,88.88 112.1,88.88 112.65,88.33 112.65,88.1 v2(112.8,87.95)
CLK_PCIE_MINI1: length 190
  IN4 w0.117: v2(266.96,65.29) 267.09,65.42 267.21,65.42 267.35,65.28 267.35,65 266.77,64.43 264.54,64.43 263.9,65.06 253.44,65.06 249.74,61.35 248.74,61.35 248.28,60.89 248.28,60.56 246.46,58.74 244.55,58.74 243.99,58.18 243.53,58.18 243.25,57.9 241.35,57.9 240.87,57.42 238.58,57.42 238.09,57.91 234.04,57.91 233.8,58.15 230.36,58.15 229.6,57.39 143.51,57.39 143.37,57.24 123.89,57.24 123.56,57.57 115.61,57.57 108.77,64.42 105.36,64.42 v2(105.23,64.55)
  BOTTOM w0.102: RH308.2 93.91,63.87 98.53,63.87 98.94,63.46 103.3,63.46 104.22,64.38 105.06,64.38 v2(105.23,64.55) ; v2(266.96,65.29) 267.09,65.16 267.09,63.92 267.26,63.75 267.26,60.99 267.79,60.47 268.27,60.47 268.54,60.2 JMINI1.13
CLK_PCIE_MINI1#: length 190
  IN4 w0.117: v2(105.25,63.95) 105.44,64.13 108.65,64.13 115.5,57.29 123.45,57.29 123.78,56.96 143.48,56.96 143.63,57.11 229.72,57.11 230.48,57.87 233.68,57.87 233.92,57.63 237.97,57.63 238.46,57.13 240.98,57.13 241.47,57.62 243.37,57.62 243.65,57.89 244.11,57.89 244.67,58.46 246.58,58.46 248.56,60.44 248.56,60.77 248.86,61.07 249.85,61.07 253.56,64.78 263.79,64.78 264.42,64.14 266.89,64.14 267.63,64.88 267.63,65.16 v2(267.76,65.29)
  BOTTOM w0.102: v2(267.76,65.29) 267.7,65.36 267.49,65.36 267.36,65.23 267.36,64.03 267.53,63.86 267.53,61.11 267.9,60.73 268.27,60.73 268.54,61 JMINI1.11 ; RH307.2 93.88,63.6 v3(96.25,63.6) 98.42,63.6 98.83,63.2 103.41,63.2 104.33,64.11 105.09,64.11 v2(105.25,63.95)
CLK_PCIE_MINI2: length 2.3
  BOTTOM w0.102: JMINI2.13 115.49,169.15 115.22,169.42 115.22,169.72 RH126.2
CLK_PCIE_MINI2#: length 2.3
  BOTTOM w0.102: RH127.2 114.96,169.74 114.96,169.42 114.69,169.15 JMINI2.11
CLK_PCIE_MINI3: length 58.8
  TOP w0.102: v2(85.58,38.29) 85.67,38.2 85.88,38.2 86,38.32 86,38.34 86,38.34 86,40.37 91.76,46.12 91.76,50.6 96.11,54.95 96.11,57.57 95.83,57.85 95.83,66.43 94.68,67.59 94.29,67.59 94.21,67.51 v2(94.21,67.42)
  BOTTOM w0.102: v2(94.21,67.42) 94.03,67.6 91.99,67.6 91.8,67.41 91.34,67.41 RH135.2 ; v2(85.58,38.29) 85.87,38 85.87,37.58 85.71,37.43 85.71,36.24 85.05,35.58 85.05,31.54 83.48,29.97 83.48,24.77 86.01,22.24 86.01,21.77 85.74,21.5 JMINI3.13
CLK_PCIE_MINI3#: length 58.8
  TOP w0.102: v2(94.21,68.03) 94.38,67.86 94.79,67.86 96.1,66.54 96.1,57.96 96.38,57.68 96.38,54.84 92.02,50.49 92.02,46.01 86.27,40.25 86.27,38.45 v2(86.41,38.3)
  BOTTOM w0.102: v2(94.21,68.03) 94.04,67.87 91.88,67.87 91.69,67.68 91.37,67.68 RH133.2 ; v2(86.41,38.3) 86.13,38.02 86.13,37.47 85.98,37.32 85.98,36.13 85.32,35.47 85.32,31.43 83.74,29.86 83.74,24.88 86.27,22.35 86.27,21.77 86.54,21.5 JMINI3.11
CLK_PCIE_NVR: length 151.6
  IN3 w0.127: v2(14.32,153.84) 14.18,153.7 14.18,148.18 13.31,147.31 13.31,144.92 22.91,135.32 22.91,123.48 33.76,112.63 36.1,112.63 41.53,107.2 41.53,106.69 55.19,93.03 65.66,93.03 70,88.69 72.23,88.69 72.58,88.34 72.58,87.96 v2(72.74,87.8)
  BOTTOM w0.102: JMINI4.13 14.44,156.78 14.17,156.51 14.17,153.99 v2(14.32,153.84) ; v2(72.74,87.8) 72.65,87.7 72.65,87.39 72.99,87.05 78.17,87.05 79.46,88.34 96.69,88.34 98.54,86.49 98.54,85.18 98.12,84.76 98.12,76.85 98.54,76.43 98.54,72.69 96.96,71.12 93.78,71.12 RH142.2
CLK_PCIE_NVR#: length 151.6
  IN3 w0.127: v2(13.74,153.84) 13.88,153.7 13.88,148.31 13,147.43 13,144.79 22.6,135.19 22.6,123.36 33.63,112.33 35.97,112.33 41.22,107.07 41.22,106.57 55.07,92.72 65.53,92.72 69.87,88.38 72.11,88.38 72.28,88.21 72.28,87.91 v2(72.16,87.8)
  BOTTOM w0.102: v2(72.16,87.8) 72.19,87.8 72.38,87.61 72.38,87.28 72.88,86.78 78.28,86.78 79.57,88.07 96.58,88.07 98.27,86.38 98.27,85.29 97.85,84.87 97.85,76.74 98.27,76.32 98.27,72.81 96.85,71.39 93.63,71.39 93.46,71.56 93.46,71.69 RH144.2 ; v2(13.74,153.84) 13.91,154 13.91,156.51 13.64,156.78 JMINI4.11
CLK_PCIE_VGA: length 85.8
  TOP w0.102: v2(79.73,134.95) 79.57,135.11 79.57,135.69 79.69,135.8 JMXM1.185
  IN4 w0.117: v2(82.37,66.96) 82.18,67.14 82.18,67.42 82.45,67.68 84.76,67.68 88.22,71.14 88.22,72.72 89.43,73.93 89.43,101.1 90.7,102.37 90.7,108.12 92.94,110.36 92.94,115.74 93.32,116.13 93.32,121.85 92.43,122.74 92.43,125.78 90.38,127.84 90.38,129.75 87.01,133.11 81.12,133.11 79.58,134.65 79.58,134.8 v2(79.73,134.95)
  BOTTOM w0.089: v2(82.37,66.96) 82.34,66.98 82.34,67.22 82.57,67.45 UH1.AB36
CLK_PCIE_VGA#: length 85.8
  TOP w0.102: v2(79.15,134.95) 79.31,135.11 79.31,135.69 79.19,135.8 JMXM1.183
  IN4 w0.117: v2(81.72,66.96) 81.9,67.14 81.9,67.53 82.33,67.96 84.64,67.96 87.93,71.26 87.93,72.84 89.15,74.05 89.15,101.22 90.42,102.49 90.42,108.23 92.66,110.47 92.66,115.86 93.04,116.24 93.04,121.73 92.15,122.62 92.15,125.67 90.09,127.72 90.09,129.63 86.89,132.83 81,132.83 79.3,134.54 79.3,134.8 v2(79.15,134.95)
  BOTTOM w0.089: UH1.AB35 81.72,67.05 v2(81.72,66.96)
CLK_SIO_14M: length 163.1
  TOP w0.102: v2(88.53,55.82) 88.53,55.74 88.95,55.32 CH79.1 88.85,54.93 88.34,55.44 87.6,55.44 RH157.1
  IN1 w0.109: v2(88.53,55.82) 89.01,55.34 95.19,55.34 95.67,55.82 101.32,55.82 103.66,53.48 113.95,53.48 118.85,48.58 121.74,48.58 122.27,48.04 127.33,48.04 127.7,47.68 131.25,47.68 131.6,47.33 155.73,47.33 156.28,47.89 158.28,47.89 158.56,47.61 192.1,47.61 199.84,55.35 210.91,55.35 213.41,57.85 228.42,57.85 228.67,58.1 v2(228.67,58.31)
  BOTTOM w0.102: U46.A32 234.48,63.62 233.7,62.85 233.7,61.56 R794.1 233.83,61.48 234.34,60.97 234.34,60.21 232.99,58.87 v1(230.08,58.87) 229.26,58.87 228.7,58.31 v2(228.67,58.31)
CLK_TP_SIO: length 276
  TOP w0.102: JIO1.110 20.22,70.5 20.3,70.42 22.78,70.42 v1(23.92,71.56) 24.3,71.94 v2(24.3,72.48)
  IN4 w0.109: v2(24.3,72.48) 25.29,73.47 27.89,73.47 28.53,74.11 28.53,76.8 31.03,79.3 35.13,79.3 37.04,77.38 37.04,75.1 39.21,72.93 40.83,72.93 44.65,69.1 45.7,69.1 46.14,68.66 49.68,65.13 49.68,57.38 53.49,53.56 53.49,52.46 56.31,49.64 57.07,49.64 62.03,44.69 62.46,44.69 63.37,43.78 76.14,43.78 76.49,43.43 82.51,43.43 83.08,42.86 99.06,42.86 99.69,42.23 102.64,42.23 103.87,41 119.82,41 122.15,38.67 172.81,38.67 174.67,40.53 174.72,40.53 174.72,40.53 177.38,40.53 177.86,40.05 188.28,40.05 189.66,41.43 197.02,41.43 199.85,44.26 204.62,44.26 205.46,45.1 207.97,45.1 209.11,43.96 220.13,43.96 221.46,42.62 223.73,42.62 225.91,40.45 227.43,40.45 229.06,38.82 246.73,38.82 249.01,41.11 250.85,41.11 251.29,41.55 251.29,42.83 250.87,43.24 250.87,46.6 v2(249.38,48.1)
  BOTTOM w0.102: v2(249.38,48.1) 249.32,48.04 248.63,48.04 U51.A37
CLK_XDP: length 1.8
  TOP w0.102: RH107.1 206.22,122.44 JXDP1.13
CLK_XDP#: length 2
  TOP w0.102: JXDP1.12 211.32,122.94 211.61,123.23 212.24,123.23 RH108.2
CLKRUN#: length 262.9
  TOP w0.076: 68.5,73.06 68.65,72.91 68.65,72.48 68.88,72.25 69.59,72.25 69.72,72.12 70.25,72.12 v2(70.64,72.5)
  TOP w0.102: v2(247.84,52.18) 248.02,52.35 248.02,54.28 246.94,55.36 246.94,60.46 245.87,61.52 245.87,62.33 244.51,63.69 244.08,63.69 242.71,65.06 241.98,65.06 v2(241.57,65.47) ; RH90.2 64.57,77.15 v1(65.08,76.64) 65.34,76.38 65.81,76.38 66.78,75.42 66.78,75.27 66.9,75.14 66.9,74.66 68.5,73.06
  IN1 w0.109: v2(70.64,72.5) 70.15,72.99 69.34,72.99 69.23,73.1 68.88,73.1 67.2,71.42 64.79,71.42 63.45,70.08 63.45,63.51 64.01,62.94 64.01,61.87 63.93,61.79 63.93,59.32 64.59,58.66 64.59,54.95 63.73,54.09 63.73,52.46 64.51,51.67 65.26,51.67 67.56,49.37 67.56,48.39 70.27,45.67 72.35,45.67 73.21,44.82 75.9,44.82 77.4,43.32 80.58,43.32 81.31,42.58 94.06,42.58 94.8,43.32 103.1,43.32 104.06,42.36 113.48,42.36 113.61,42.23 113.76,42.23 114.45,41.53 120.35,41.53 121.53,40.35 122.87,39.01 172.99,39.01 174.52,40.54 177.12,40.54 177.96,39.71 183.15,39.71 183.44,39.41 188.19,39.41 188.64,39.85 193.06,39.85 200.23,47.02 210.62,47.02 211.58,47.98 215.7,47.98 218,50.28 231.67,50.28 233.16,51.76 243.36,51.76 243.86,52.27 243.86,52.58 244.23,52.95 244.75,52.95 244.96,52.73 245.92,52.73 246.47,52.18 v2(247.84,52.18)
  IN4 w0.109: v2(252.28,56.2) 252.28,55.77 248.69,52.18 v2(247.84,52.18)
  BOTTOM w0.102: v2(247.84,52.18) 247.03,52.18 246.8,51.95 U51.A32 ; U46.B20 241.23,65.12 v2(241.57,65.47) ; v2(252.28,56.2) 251.68,56.8 U39.15 ; v2(70.64,72.5) 70.64,72.38 70.34,72.09 UH1.AN7
COEX1_BT_ACTIVE: length 322.7
  TOP w0.102: JBT1.3 v2(300.56,107.73)
  IN1 w0.109: v2(300.56,107.73) 300.51,107.73 300.05,108.19 295.43,108.19 292.96,105.73 291.9,105.73 289.25,103.08 289.25,94.67 280.1,85.52 278.26,85.52 277.69,84.95 277.69,82.2 276.68,81.2 276.68,80.83 274.96,79.11 260.73,79.11 v2(260.48,78.85)
  IN4 w0.109: v2(126.03,172.28) 126.02,172.27 126.02,171.4 126.49,170.94 126.49,169.46 130.37,165.58 131.37,165.58 133.02,163.93 133.02,157.45 130.61,155.04 130.61,152.43 128.44,150.26 127.44,150.26 124.92,147.75 124.92,143.1 125.58,142.44 125.84,142.44 126.99,141.28 126.99,137.77 128.4,136.36 128.4,129.78 128.29,129.67 128.29,117.23 124.49,113.43 121.74,113.43 120.9,112.59 120.9,107.16 122.91,105.15 133.45,105.15 133.48,105.13 135.38,105.13 145.66,94.86 186.22,94.86 205.75,75.32 207.83,75.32 210.35,72.81 215.54,72.81 217.75,70.6 217.75,69.99 219.82,67.93 226.37,67.93 227.06,68.61 227.06,69.28 227.76,69.98 228.83,69.98 230.68,71.83 230.68,75.94 232.67,77.93 240.51,77.93 240.75,77.69 247.49,77.69 248.84,79.04 260.29,79.04 v2(260.48,78.85)
  BOTTOM w0.102: v2(300.56,107.73) 300.56,108.87 v1(300.65,108.95) ; v2(126.03,172.28) 125.93,172.38 125.41,172.38 124.26,171.22 118.98,171.22 117.77,172.43 113.96,172.43 113.59,172.06 113.59,170.18 112.29,168.88 JMINI2.5
COEX2_WLAN_ACTIVE: length 427.7
  TOP w0.102: v2(99.62,85.13) 99.62,85.18 101.45,83.35 113.36,83.35 115.14,85.13 125.1,85.13 126.07,86.09 127.7,86.09 130.96,89.35 134.85,93.24 134.85,115.7 133.6,116.94 133.6,130.29 133.6,145.63 133.25,145.99 133.25,151.25 131.2,153.29 131.2,157.78 129.85,159.13 127.97,159.13 124.67,162.43 124.04,162.43 123.24,163.23 123.24,168.77 120.06,171.95 v2(118.92,171.95) ; JBT1.8 v2(295.56,107.58)
  IN1 w0.109: v2(99.62,85.13) 99.49,85 99.49,82.92 98.32,81.75 98.32,80.79 99.26,79.85 99.26,76.95 99.95,76.26 99.95,70.42 98.96,69.43 98.96,57.95 v2(99.31,57.6) 101.09,59.37 111.45,59.37 112.36,58.46 116.31,58.46 117.63,57.14 120.31,54.47 120.31,53.34 124.07,49.57 154.12,49.57 154.63,50.08 158.95,50.08 159.46,49.57 191.2,49.57 196.42,54.79 197.2,54.79 199.26,56.86 210.29,56.86 212.75,59.32 226.08,59.32 226.56,59.79 229.43,59.79 229.68,59.54 237.9,59.54 238.33,59.12 243.53,59.12 243.66,59.25 250.54,59.25 251.71,60.41 254.71,60.41 254.91,60.21 255.88,60.21 256.84,59.25 262.48,59.25 263.12,58.61 284.99,58.61 292.76,66.38 292.76,73.97 291.59,75.14 290.89,75.83 290.89,81.92 289.67,83.15 289.67,102.84 291.34,104.51 291.84,104.51 292.53,105.19 293.19,105.19 295.56,107.56 v2(295.56,107.58)
  BOTTOM w0.102: v2(295.56,107.58) 295.56,108.51 R904.1 C753.1 ; v2(99.62,85.13) v1(99.62,85.74) ; v2(118.92,171.95) 118.54,171.95 117.85,172.63 113.14,172.63 112.06,171.55 111.44,171.55 C601.1 111.49,170.06 JMINI2.3
COMP: length 5.9
  TOP w0.203: PU500.7 154.95,171.83 154.74,172.05
  TOP w0.254: 154.74,172.05 153.33,172.05 v1(152.84,172.53) 152.47,172.91 PR541.2 151.36,173.83 PC525.2
CONTACTLESS_DET#: length 81.9
  TOP w0.102: v2(110.59,44.36) 110.96,43.99 110.96,36.39 109.69,35.12 109.69,31.21 v1(111.27,29.63) 111.27,28.4 111.97,27.7 112.96,27.7 114.08,28.82 JUSH1.17 ; v2(81.08,43.84) 80.63,44.29 80.21,44.29 79.86,43.93 70.94,43.93 70.43,44.44 70.43,45.43 70.79,45.78 71.32,45.78 71.48,45.94 RPH8.7 71.48,46.52 72.57,47.61 72.91,47.61 73.19,47.89 73.42,47.89 74.42,48.89 74.42,53.23 73.61,54.04 73.61,56.27 v2(73.4,56.48)
  IN1 w0.109: v2(110.59,44.36) 110.16,44.79 109.85,44.79 108.75,43.69 105.7,43.69 105.47,43.46 103.9,43.46 103.59,43.77 94.53,43.77 93.77,43.01 81.91,43.01 v2(81.08,43.84)
  BOTTOM w0.089: UH1.C16 74.22,59.29 74.22,59.07 74.22,58.82 73.97,58.57 73.97,58.11
  BOTTOM w0.102: v2(73.4,56.48) 73.89,56.96 73.89,57.84 73.97,57.93 73.97,58.11
CPPE#: length 212
  TOP w0.102: v2(98.68,83.73) 100.02,83.73 100.84,82.92 113.51,82.92 115.31,84.72 125.27,84.72 126.24,85.69 127.87,85.69 131.37,89.18 135.27,93.08 135.27,115.85 134.01,117.11 v1(134.01,147.61) 134.01,151.15 131.61,153.55 131.61,157.94 131,158.55 131,161.33 130.36,161.96 129.88,161.96 128.95,161.04 127.76,161.04 127.44,160.72 126.96,160.72 126.36,161.32 126.36,163.44 125.04,164.76 v2(125.04,166.48)
  IN1 w0.109: v2(88.16,53.91) 87.83,54.25 87.83,56.53 88.69,57.39 93.45,57.39 98.73,62.68 98.73,69.94 99.72,70.93 99.72,76.19 99.05,76.86 99.05,79.76 98.07,80.74 98.07,83.12 v2(98.68,83.73)
  BOTTOM w0.076: UH1.B13 73.08,58.87 72.95,58.74 72.95,58.19 72.59,57.83 72.59,57.29 72.77,57.11 72.77,57.01
  BOTTOM w0.102: v2(125.04,166.48) 125.2,166.64 126.39,166.64 126.92,166.1 128.01,166.1 128.29,166.38 JMINI2.37 128.29,169.99 R823.1 ; 72.77,57.01 72.77,56.24 73.24,55.77 73.99,55.77 74.55,55.2 74.55,53.78 74.93,53.4 74.93,52.28 74.65,52 74.65,49.09 72.59,47.03 72.59,45.43 73.51,44.51 73.51,42.74 74.15,42.1 77.33,42.1 77.77,41.66 79.54,41.66 79.96,42.07 79.96,43.34 79.73,43.57 79.73,47.11 83.26,50.64 83.26,52.29 84.71,53.73 85.8,53.73 85.88,53.66 87.91,53.66 v2(88.16,53.91)
CPU1.5V_S3_GATE: length 4.1
  BOTTOM w0.102: R889.2 250.16,50.18 v1(250.16,49.45) 250.16,48.96 249.81,48.6 248.99,48.6 248.81,48.42 U51.A36
CPU_B+: length 26.6
  TOP w0.254: v2(157.81,155.59) 157.63,155.59 155.14,158.08 154.28,158.08 153.52,158.84 153.52,161.3 153.3,161.52 153.3,162.43 153.77,162.9 PR526.2
  BOTTOM w0.254: 165.4,166.92 160.98,162.5 160.98,160.52 161.44,160.06 161.44,156.93 160.09,155.59 v2(157.81,155.59)
  vias: v1(191.95,165.84) v2(171.75,165.29) v2(177.6,165.24) v2(184.25,165.27) v2(191.69,163.34) v3(165.96,169.61) v3(165.96,168.97) v3(165.96,168.34) v3(166.98,169.61) v3(166.98,168.97) v3(166.98,168.34) v3(167.99,169.61) v3(167.99,168.97) v3(167.99,168.34) v3(171.93,169.74) v3(171.93,168.97) v3(171.93,168.21) v3(174.6,169.74) v3(174.67,168.97) v3(174.67,168.21) v3(179.04,169.74) v3(179.04,168.97) v3(179.04,168.21) v3(181.7,169.86) v3(181.77,169.13) v3(181.77,168.36) v3(186.16,169.86) v3(186.16,169.1) v3(186.16,168.34) v3(188.82,169.86) v3(188.82,169.1) v3(188.82,168.34) v3(189.84,165.16) v3(190.22,165.8) v3(190.6,165.16) v3(191.11,165.8) v3(191.49,165.16) v3(198.25,164.63) v3(198.93,164.66) v3(199.13,165.29) v3(202.23,165.8) v3(202.23,165.01) v3(203.81,166.79) v3(204.47,166.74)
CPU_DETECT#: length 110.5
  TOP w0.102: JCPU1.AP32 v2(195.06,136.31)
  IN1 w0.109: v2(245.11,73.98) 245.06,74.03 239.29,74.03 238.58,74.74 236.14,74.74 236.1,74.78 229.09,74.78 227.38,76.49 227.38,78.4 222.99,82.79 222.27,82.79 219.13,85.93 219.13,91.85 214.58,96.41 214.58,100.78 211.82,103.54 209.17,103.54 208.08,104.64 208.08,109.54 209.19,110.66 209.19,112.76 205.79,116.17 204.37,116.17 198.65,121.88 193.78,121.88 193.52,122.14 193.52,122.77 192.53,123.76 192.53,133.16 193.62,134.25 193.62,135.52 193.95,135.85 194.49,135.85 194.94,136.31 v2(195.06,136.31)
  IN3 w0.127: v2(248.59,70.12) 248.44,70.12 245.11,73.44 v2(245.11,73.98)
  BOTTOM w0.102: U46.A3 244.31,72.16 v1(245.11,72.95) v2(245.11,73.98) ; v2(248.59,70.12) 248.95,69.75 RP2.8
CPU_DMI: length 11.8
  TOP w0.102: JCPU1.E26 v2(165.06,129.31)
  BOTTOM w0.089: 160.83,129.68 160.85,129.68 160.89,129.72 164.65,129.72 v2(165.06,129.31)
  BOTTOM w0.102: RC13.1 157.28,125.29 157.68,125.29 157.97,125.58 157.97,126.26 v3(158.47,126.76) 159.43,127.72 159.43,128.64 160.47,129.68 160.83,129.68
CPU_DMI#: length 11.8
  TOP w0.102: JCPU1.D26 v2(165.06,130.31)
  BOTTOM w0.089: v2(165.06,130.31) 164.66,129.91 160.89,129.91 160.85,129.95 160.83,129.95
  BOTTOM w0.102: RC15.1 157.39,125.55 157.57,125.55 157.71,125.69 157.71,126.37 159.17,127.83 159.17,128.75 160.36,129.95 160.83,129.95
CPU_DPLL: length 13.3
  TOP w0.089: v2(168.06,132.31) 168.53,131.84 JCPU1.H28
  BOTTOM w0.089: 160.12,131.66 160.14,131.66 160.21,131.72 167.49,131.72 167.78,132.02 167.78,132.13 167.96,132.31 v2(168.06,132.31)
  BOTTOM w0.102: RC52.1 157.07,129.78 157.94,129.78 158.83,130.67 159.82,131.66 160.12,131.66
CPU_DPLL#: length 13.3
  TOP w0.089: v2(167.06,132.31) 167.53,131.84 JCPU1.G28
  BOTTOM w0.089: v2(167.06,132.31) 167.48,132.31 167.61,132.19 167.61,132.09 167.42,131.9 160.17,131.9 160.14,131.93 160.12,131.93
  BOTTOM w0.102: 160.12,131.93 159.71,131.93 v3(158.82,131.04) 158.56,130.78 157.83,130.05 157.09,130.05 RC51.1
CPU_EDP_HPD: length 49.1
  BOTTOM w0.102: U23.1 126.6,147.3 126.47,147.43 126.47,148.68 129.13,151.35 131.32,151.35 132.36,152.39 137.46,152.39 143.86,158.79 150.34,158.79 156.41,152.72 v1(160.21,152.72) RC75.1 165.63,152.21 QC6.2
CPU_PLTRST#: length 275.9
  TOP w0.102: RC53.2 202.21,131.76 v2(202.28,131.7) 202.74,131.7 v1(202.98,131.94)
  IN3 w0.127: v2(202.28,131.7) 202.58,131.7 203.63,130.65 203.63,119.83 206.7,116.75 206.7,115.41 209.46,112.65 209.46,106.27 209.96,105.78 209.96,104.67 207.95,102.66 207.95,102.14 207.49,101.68 207.49,97.68 209.65,95.52 209.65,94.91 210.51,94.04 210.51,89.12 211.68,87.95 211.68,80.78 207.73,76.83 207.73,71.86 204.14,68.26 204.14,66.03 201.8,63.69 201.8,61.4 199.01,58.61 199.01,56.39 196.73,54.11 195.58,54.11 191.78,50.31 190.86,50.31 189.26,48.71 168.88,48.71 168.68,48.5 168.68,47.44 168.25,47 166.42,47 164.1,44.68 150.32,44.68 148.7,46.3 128.43,46.3 128.22,46.09 125.02,46.09 122.05,49.06 119.51,49.06 117.07,51.5 101.87,51.5 100.93,52.44 92.07,52.44 91.77,52.13 85.77,52.13 85.22,52.69 78.29,52.69 76.91,54.08 75.66,54.08 74.32,55.41 71.12,55.41 67.31,59.22 67.31,60.05 66.06,61.3 66.06,61.91 65.38,62.6 64.84,62.6 63.88,61.63 59.28,61.63 57.86,63.06 57.02,63.06 55.04,61.07 54.41,61.07 53.5,61.98 53.5,68.93 54.12,69.54 54.12,70.56 55.2,71.64 57.73,71.64 57.94,71.84 59.97,71.84 60.1,71.97 64.72,71.97 66.25,73.5 66.25,73.6 v2(66.75,74.11)
  BOTTOM w0.076: v2(66.75,74.11) 67.13,74.11 67.69,73.55 67.97,73.55 68.15,73.72 68.43,73.72 68.71,73.44 UH1.AU4
CPU_PLTRST#_R: length 23.4
  TOP w0.102: JCPU1.AT26 197.19,129.84 198.3,130.95 199.87,130.95 RC53.1 ; v2(202.72,130.87) 201.57,130.87 RC53.1 ; RC53.1 RC54.1 ; RC8.1 212.7,130.09 211.15,131.64 v2(206.35,131.64)
  IN1 w0.109: v2(202.72,130.87) 203.48,131.64 v2(206.35,131.64)
  BOTTOM w0.102: v4(206.6,131.05) 206.35,131.31 v2(206.35,131.64)
CPU_PWR_DEBUG: length 18.8
  TOP w0.109: v2(169.06,131.31) JCPU1.H27
  BOTTOM w0.089: 167.88,131.74 167.54,131.4 167.54,131.2 167.08,130.75
  BOTTOM w0.102: 167.88,131.74 168.48,131.74 168.91,131.31 v2(169.06,131.31) ; RC71.1 RC69.2 v1(158.08,124.14) 158.58,124.65 158.58,125.98 160.15,127.55 160.15,128.05 160.86,128.77 164.46,128.77 164.62,128.92 165.28,128.92 165.54,129.18 165.54,130.45 165.84,130.75 167.08,130.75
CPU_SSC_DPLL: length 12
  TOP w0.089: v2(165.06,131.31) 165.53,130.84 JCPU1.E27
  BOTTOM w0.089: 161.52,130.91 161.52,130.91 161.54,130.9 165.28,130.9 165.51,131.13 165.51,131.27 165.37,131.41 165.16,131.41 v2(165.06,131.31)
  BOTTOM w0.102: 161.52,130.91 161.37,130.91 161.29,130.82 160,130.82 158,128.83 v3(158,128.42) 158,128.06 157.67,127.74 157.49,127.74 RC22.1
CPU_SSC_DPLL#: length 12.1
  TOP w0.089: JCPU1.F27 166.53,130.84 v2(166.06,131.31)
  BOTTOM w0.089: v2(166.06,131.31) 165.76,131.31 165.71,131.26 165.71,131.08 165.35,130.72 161.61,130.72 161.6,130.71 161.6,130.7 161.52,130.62
  BOTTOM w0.102: RC43.1 157.43,127.47 157.78,127.47 158.27,127.95 158.27,128.72 160.11,130.56 161.45,130.56 161.52,130.62
CPU_VTT_ON: length 27.7
  IN4 w0.254: v2(243.51,65.14) 244.54,66.17 245.4,66.17 246.16,66.93 246.16,72.26 250.04,76.14 250.06,76.14 v2(250.07,76.15)
  BOTTOM w0.254: v2(250.07,76.15) 249.67,76.15 v1(249.21,76.61) 248.44,77.38 244.68,77.38 243.69,76.39 243.69,75.4 243.31,75.02 242.77,75.02 242.33,75.46 242.33,76 241.39,76.94 RP4.1 ; v2(243.51,65.14) 243.41,65.14 243.14,65.41 U46.B17
CRT_11: length 8.5
  TOP w0.102: JCRT1.11 80.01,172.17 78.38,172.17 75.16,168.95 T61.1
CRT_EN: length 2.5
  BOTTOM w0.102: R421.2 97.74,101.72 v1(97.74,101.96) 97.74,102.07 97.11,102.7 U19.2
CRT_IREF: length 3.4
  TOP w0.254: v2(84.23,64.96) 84.33,65.06 v1(84.81,65.06) 86.21,65.06 RH97.2
  BOTTOM w0.254: v2(84.23,64.96) 84.5,65.24 UH1.U40
CRT_SWITCH: length 157.7
  TOP w0.102: v2(233.81,75.6) 233.2,75.6 232.64,76.16 231.06,76.16 230.45,75.55 225.93,75.55 223.09,72.71 217.32,72.71 215.7,74.33 v2(211.53,74.33)
  IN1 w0.109: v2(99.06,104.43) v2(99.06,103.65)
  BOTTOM w0.102: v2(211.53,74.33) 209.47,74.33 207.82,75.98 207.82,76.8 206.93,77.69 206.45,77.69 205.66,78.47 198.2,78.47 192.15,84.52 189.14,84.52 188.08,85.59 179.58,85.59 179.48,85.48 169.4,85.48 165.43,89.45 154.2,89.45 152.16,87.42 147.52,87.42 146.33,86.22 139.35,86.22 126.09,99.48 124.45,99.48 123.59,100.34 118.55,100.34 114.64,104.25 105.6,104.25 v1(104.94,103.59) 104.59,103.24 99.47,103.24 v2(99.06,103.65) 98.97,103.74 U19.40 ; U46.B52 234.23,74.37 233.81,74.79 v2(233.81,75.6) ; v2(99.06,104.43) 98.96,104.54 U19.38
CS_1.35V: length 4.8
  BOTTOM w0.102: PR201.2 149.71,18.65 150.16,18.2 v1(150.16,16.47)
  BOTTOM w0.203: PU200.13 149.97,20.39
  BOTTOM w0.254: PR201.2 150.01,19.16 150.01,20.35 149.97,20.39
CSON_1: length 40
  IN2 w0.254: v3(200.56,15.05) 201.01,15.05 204.32,11.75 212.32,11.75 215.24,14.67 215.24,15.46 220.7,20.92 226.36,20.92 v3(227.94,22.49)
  BOTTOM w0.102: v1(230.43,23.33) 230,23.76 PC786.1
  BOTTOM w0.254: PR761.2 229.14,23.75 PC786.1 229.15,23.06 PC792.2 227.99,22.54 v3(227.94,22.49) ; v3(200.56,15.05) 200.15,15.46 PR723.3
CSOP_1: length 36.8
  IN2 w0.254: v3(226.54,22.42) 226.54,22.04 225.93,21.43 220.67,21.43 214.73,15.48 214.73,14.88 212.11,12.26 204.53,12.26 201.22,15.56 200.81,15.56 v3(200.56,15.81)
  BOTTOM w0.102: v3(226.54,22.42) v1(225.79,22.42)
  BOTTOM w0.254: v3(226.54,22.42) 227.24,22.42 PC792.1 227.24,23.08 PR759.2 ; v3(200.56,15.81) 200.91,15.46 PR723.2
CSS_GC: length 262.8
  TOP w0.102: v2(30,69.93) v1(30.42,70.35)
  TOP w0.254: v2(30,69.93) 29.22,69.15 29.18,69.15 PR703.2
  IN2 w0.254: v2(257.58,28.84) 257.24,28.84 256.83,29.25 254.86,29.25 254.38,28.77 252.12,28.77 251.89,28.54 239.62,28.54 236.02,32.14 234.19,32.14 232.48,33.85 222.44,33.85 219.56,36.72 206.03,36.72 205.5,36.18 198.54,36.18 194.45,32.09 187.14,32.09 186.53,32.7 179.87,32.7 178.54,34.04 176.55,34.04 175.16,35.42 167.26,35.42 166.55,36.13 123.83,36.13 122.61,37.35 119.06,37.35 118.93,37.48 103.83,37.48 103.25,36.89 97.51,36.89 92.96,41.44 78.05,41.44 76.73,40.12 54.68,40.12 47.8,47 47.8,48.6 48.51,49.31 48.51,59.25 42.59,65.16 41.48,65.16 40.51,66.13 40.51,66.46 38.58,68.39 36.24,68.39 34.14,70.5 30.57,70.5 v2(30,69.93)
  BOTTOM w0.254: v2(257.58,28.84) 257.71,28.84 258.04,29.18 PU1001.10
CSSN_1: length 193.1
  TOP w0.254: v2(36.32,108.8) 36.23,108.71 36.23,108.48 36.39,108.32 36.77,108.32 37.67,109.22 45.23,109.22 50.87,114.86 60.91,114.86 62.73,116.68 87.97,116.68 88.4,117.11 88.4,117.7 89.06,118.35 91.2,118.35 93.44,120.59 95.9,120.59 97.17,119.32 103.64,119.32 105.61,121.29 112.66,121.29 115.4,124.03 117.7,124.03 118.49,124.82 118.49,126.74 119.33,127.58 119.33,128.05 v2(119.23,128.16) ; PR711.1 34.9,64.58 PR707.1 33.55,64.58 33.28,64.31 32.47,64.31 31.65,65.14 PQ702.3 30.81,65.14 29.31,63.64 28.52,63.64 27.68,64.47 27.68,70.03 28.12,70.46 28.12,71.54 v2(28.22,71.64) ; PR712.1 126.21,134.77 PQ703.2 126.21,132.21 125.94,131.94 125.06,131.94 124.7,131.59 124.7,130.21 v2(125.33,129.58)
  IN1 w0.254: v2(119.23,128.16) 119.33,128.26 119.33,128.75 119.91,129.32 122.89,129.32 123.24,128.97 125.47,128.97 125.63,129.12 125.63,129.29 v2(125.33,129.58) ; v2(36.32,108.8) 36.21,108.69 36.21,107.55 35.53,106.87 16.82,106.87 14.51,104.57 14.51,95.11 13.3,93.89 13.3,83.82 14.77,82.34 14.77,79.1 16.49,77.38 22.24,77.38 23.58,76.04 24.67,76.04 28.13,72.58 28.13,71.73 v2(28.22,71.64)
CSSN_2: length 229
  TOP w0.254: PU701.5 49.49,41.01 PR706.1 50.04,42.6 50.04,45.19 v2(50.19,45.34) ; v2(37.44,63.72) v1(36.89,64.27) 36.12,64.27 PR711.2
  IN4 w0.254: v2(226.29,34.61) 226.39,34.71 226.39,35.01 222.55,38.85 221.89,38.85 219.18,41.55 208.95,41.55 207.52,40.12 204.98,40.12 204.14,39.28 200.32,39.28 199.16,38.12 192.45,38.12 190.74,36.41 190.74,35.51 189.92,34.68 181.71,34.68 181.2,34.18 174.18,34.18 173.54,34.82 168.45,34.82 167.85,34.21 119.2,34.21 117.08,36.34 110.58,36.34 109.98,35.74 103.11,35.74 102.77,35.4 97.88,35.4 96.58,34.1 91.54,34.1 90.92,33.48 81.43,33.48 80.55,34.35 76.64,34.35 75.37,35.62 68.56,35.62 68.51,35.57 61.16,35.57 57.26,39.47 55.78,39.47 52.07,43.18 51.8,43.18 50.19,44.8 v2(50.19,45.34) 50.19,45.55 49.75,45.99 49.75,51.68 45.94,55.49 45.94,60.16 42.26,63.84 37.57,63.84 v2(37.44,63.72)
  BOTTOM w0.254: PU700.1 226.29,31.67 226.35,31.72 226.35,32.31 PC703.2 226.3,32.89 226.3,33.4 PC704.1 226.29,33.87 v2(226.29,34.61)
CSSP_1: length 193
  TOP w0.254: PR710.1 34.83,63.67 PR707.2 33.55,63.67 33.28,63.93 32.42,63.93 32.07,63.58 32.07,61.58 31.68,61.2 PQ700.3 28.99,63.25 28.33,63.25 27.3,64.28 27.3,70.22 27.72,70.64 27.72,71.55 v2(27.63,71.64) ; v2(35.71,108.8) 35.85,108.66 35.85,108.32 36.23,107.94 36.93,107.94 37.83,108.84 45.39,108.84 51.03,114.48 61.07,114.48 62.89,116.29 88.13,116.29 88.78,116.95 88.78,117.54 89.22,117.97 91.36,117.97 93.6,120.21 95.74,120.21 97.01,118.94 103.8,118.94 105.76,120.9 112.82,120.9 115.56,123.65 117.85,123.65 118.87,124.66 118.87,126.58 119.71,127.42 119.71,128.05 v2(119.81,128.16) ; PQ703.5 126.21,130.37 126.83,129.74 PR709.1 126.35,129.4 v2(126.19,129.57)
  IN1 w0.254: v2(35.71,108.8) 35.83,108.69 35.83,107.71 35.37,107.25 16.66,107.25 14.13,104.72 14.13,95.27 12.91,94.05 12.91,83.66 14.39,82.18 14.39,78.94 16.33,77 22.08,77 23.42,75.65 24.52,75.65 27.75,72.42 27.75,71.76 v2(27.63,71.64) ; v2(126.19,129.57) 126.01,129.39 126.01,128.96 125.63,128.59 123.09,128.59 122.73,128.94 120.06,128.94 119.71,128.59 119.71,128.26 v2(119.81,128.16)
CSSP_2: length 225.9
  TOP w0.254: v2(36.75,63.72) 36.58,63.89 35.96,63.89 PR710.2 ; PR708.1 v1(50.56,44.17) 50.56,44.36 v2(50.93,44.73)
  IN4 w0.254: v2(36.75,63.72) 37.24,64.2 42.41,64.2 46.3,60.31 46.3,55.67 50.1,51.87 50.1,46.14 50.93,45.31 v2(50.93,44.73) 51.89,43.78 52.07,43.78 55.92,39.93 57.34,39.93 61.29,35.98 75.52,35.98 76.79,34.71 89.02,34.71 89.2,34.53 89.59,34.53 89.59,34.53 96.4,34.53 97.65,35.78 102.3,35.78 103.76,37.24 112.41,37.24 112.93,36.72 117.3,36.72 119.28,34.74 119.38,34.74 119.49,34.63 167.76,34.63 168.31,35.17 173.68,35.17 174.3,34.56 181.04,34.56 181.55,35.07 189.8,35.07 190.39,35.66 190.39,36.56 192.33,38.5 198.99,38.5 200.19,39.69 204.02,39.69 204.82,40.5 207.36,40.5 208.83,41.97 219.3,41.97 222.05,39.23 222.71,39.23 226.77,35.17 226.77,34.71 v2(226.87,34.61)
  BOTTOM w0.254: PU700.2 226.79,31.67 226.73,31.72 226.73,32.41 PC703.1 226.68,32.89 226.68,33.27 PC702.2 226.87,33.82 v2(226.87,34.61)
D_CLKRUN#: length 168
  TOP w0.102: v2(241.76,62.24) 239.95,60.44 237.02,60.44 236.77,60.19 226.39,60.19 225.35,61.23 222.86,61.23 220.75,63.34 219.81,63.34 214.71,68.44 213.43,68.44 212.98,68.9 211.54,68.9 210.44,70 210.44,71.44 208.48,73.39 208.48,75.44 209.04,76 209.04,78.08 208,79.13 208,80.99 v2(208.23,81.22)
  BOTTOM w0.102: v2(208.23,81.22) 208,80.99 199.13,80.99 193.17,86.96 190.37,86.96 186.56,90.77 179.61,90.77 177.5,92.88 136.14,92.88 127.08,101.94 126.58,101.94 124.39,104.14 122.06,104.14 113.8,112.4 112.48,112.4 111.24,113.64 v1(111.24,115.84) JDOCK1.111 ; U46.A19 240.98,63.71 241.1,63.59 241.1,62.9 v2(241.76,62.24) 241.76,61.89 241.39,61.52 RP3.8
D_DLDRQ1#: length 168.1
  TOP w0.102: v2(239.16,65.47) 239.09,65.47 238.45,64.83 237.78,64.83 237.07,64.12 235.14,64.12 234.36,63.34 231.48,63.34 229.62,61.48 227.43,61.48 226.39,62.52 225.56,62.52 223.25,64.83 219.88,64.83 214.77,69.94 213.1,69.94 209.29,73.75 209.29,75.1 209.85,75.66 209.85,79.36 210.26,79.77 210.26,80.73 208.86,82.13 v2(208.3,82.13)
  IN3 w0.127: v2(239.16,65.47) 240.84,63.8 240.84,62.52 240.54,62.22 v2(240.49,62.22)
  BOTTOM w0.102: JDOCK1.117 112.74,117.93 112.98,117.69 112.98,116.42 112.29,115.74 112.29,113.16 112.65,112.81 113.97,112.81 122.23,104.55 125.5,104.55 127.85,102.19 127.85,101.75 136.29,93.31 177.65,93.31 179.78,91.17 186.73,91.17 190.54,87.36 193.33,87.36 198.96,81.74 v1(200.21,81.74) 205.27,81.74 205.54,81.47 207.36,81.47 208.02,82.13 v2(208.3,82.13) ; v2(240.49,62.22) 240.39,62.12 RP3.6 ; U46.B24 239.23,65.41 v2(239.16,65.47)
D_LAD0: length 156.3
  TOP w0.102: v2(210.92,76.82) 210.92,76.44 210.72,76.24 210.72,73.87 212.03,72.56 215.29,72.56 221.39,66.46 230.58,66.46 230.88,66.15 233.64,66.15 233.94,66.46 235.74,66.46 v2(236.14,66.06)
  BOTTOM w0.102: JDOCK1.97 v1(107.74,116.08) 107.74,115.7 112.06,111.39 113.38,111.39 117.3,107.47 117.3,106.45 117.79,105.96 118.75,105.96 121.97,102.74 123.2,102.74 125.04,100.9 126.68,100.9 135.72,91.86 166.27,91.86 169.14,88.99 186.74,88.99 189.79,85.94 192.74,85.94 198.74,79.95 207.16,79.95 210.29,76.82 v2(210.92,76.82) ; U46.B29 236.73,65.14 236.55,65.32 236.55,65.65 v2(236.14,66.06)
D_LAD1: length 158
  TOP w0.102: v2(236.98,65.47) 236.44,64.94 234.75,64.94 234.62,64.81 233.89,64.81 233.2,65.49 229.61,65.49 229.15,65.04 224.59,65.04 223.78,65.85 220.39,65.85 214.1,72.15 211.86,72.15 210.31,73.7 210.31,77.41 v2(210.74,77.84)
  BOTTOM w0.102: JDOCK1.99 108.24,115.49 112.14,111.59 113.46,111.59 117.5,107.55 117.5,106.53 117.87,106.16 118.84,106.16 119.97,105.02 121.91,103.09 v1(122.33,103.09) 124.29,103.09 126.27,101.11 126.76,101.11 135.81,92.06 166.36,92.06 169.23,89.19 186.97,89.19 190.02,86.14 192.83,86.14 198.82,80.15 207.29,80.15 209.6,77.84 v2(210.74,77.84) ; U46.B28 237.23,65.23 v2(236.98,65.47)
D_LAD2: length 161.6
  TOP w0.102: v2(208.81,79.21) 209.45,78.58 209.45,75.83 208.89,75.27 208.89,73.56 212.92,69.53 214.58,69.53 219.73,64.38 220.59,64.38 223.05,61.91 225.66,61.91 226.7,60.87 235.36,60.87 236.32,61.84 236.32,62.37 236.96,63.01 237.56,63.01 237.72,63.16 v2(238.05,63.16)
  BOTTOM w0.102: U46.A25 237.98,63.09 v2(238.05,63.16) ; JDOCK1.103 109.24,114.78 112.22,111.79 113.55,111.79 117.7,107.64 117.7,106.62 117.96,106.36 118.92,106.36 121.78,103.51 124.16,103.51 126.33,101.33 126.82,101.33 135.89,92.27 166.44,92.27 169.31,89.4 187.07,89.4 190.12,86.35 192.91,86.35 198.88,80.38 207.64,80.38 v1(208.03,79.99) v2(208.81,79.21)
D_LAD3: length 161.6
  TOP w0.102: v2(208.81,79.79) 209.65,78.96 209.65,75.75 209.09,75.19 209.09,73.65 213,69.74 214.69,69.74 219.82,64.61 220.65,64.61 223.14,62.12 225.86,62.12 226.9,61.07 235.15,61.07 236.02,61.94 236.02,62.47 236.78,63.23 237.46,63.23 237.79,63.56 238.25,63.56 v2(238.66,63.16)
  BOTTOM w0.102: U46.A24 238.48,63.34 v2(238.66,63.16) ; JDOCK1.105 109.74,117.89 109.6,117.75 v1(109.6,115.09) 109.6,114.7 112.31,112 113.63,112 121.9,103.73 124.22,103.73 126.42,101.54 126.91,101.54 135.98,92.47 166.53,92.47 169.4,89.6 187.15,89.6 190.2,86.55 193,86.55 198.97,80.58 208.02,80.58 v2(208.81,79.79)
D_LFRAME#: length 162.7
  TOP w0.102: v2(239.16,66.06) 238.73,65.62 238.73,65.41 238.36,65.04 237.7,65.04 236.98,64.33 235.06,64.33 234.27,63.54 231.39,63.54 229.64,61.79 227.41,61.79 226.47,62.73 225.64,62.73 223.33,65.04 219.96,65.04 214.86,70.14 213.19,70.14 209.5,73.83 209.5,75.02 210.11,75.63 210.11,77.79 v2(210.74,78.42)
  BOTTOM w0.102: v2(239.16,66.06) 239.57,65.65 239.57,65.24 239.73,65.09 U46.B23 ; v2(210.74,78.42) 210.74,78.47 v1(210.31,78.91) 208.43,80.79 199.05,80.79 193.08,86.75 190.29,86.75 187.24,89.8 171.91,89.8 169.04,92.67 136.06,92.67 126.99,101.74 126.5,101.74 124.3,103.94 121.98,103.94 113.72,112.2 112.39,112.2 110.74,113.85 JDOCK1.109
D_SERIRQ: length 168.1
  TOP w0.102: v2(208.81,81.57) 208.81,81.19 208.41,80.79 208.41,79.01 209.24,78.17 209.24,75.92 208.69,75.36 208.69,73.48 210.68,71.48 210.68,70.04 211.62,69.1 213.06,69.1 213.52,68.64 214.83,68.64 219.93,63.54 220.84,63.54 222.94,61.43 225.53,61.43 226.54,60.41 236.71,60.41 236.94,60.64 239.57,60.64 v2(241.17,62.24)
  BOTTOM w0.102: RP3.7 240.89,61.68 241.17,61.96 v2(241.17,62.24) 240.79,62.62 240.79,63.39 240.48,63.7 U46.A20 ; JDOCK1.115 112.24,117.97 112.77,117.44 112.77,116.51 112.09,115.82 112.09,113.08 112.56,112.61 113.89,112.61 122.15,104.34 125.41,104.34 127.37,102.39 v1(127.37,102.18) 127.37,101.94 136.2,93.1 177.56,93.1 179.7,90.97 186.65,90.97 190.46,87.16 193.25,87.16 199.02,81.39 204.71,81.39 204.89,81.22 207.4,81.22 207.81,81.63 208.75,81.63 v2(208.81,81.57)
DAI_12MHZ#: length 122.8
  TOP w0.102: v2(15.89,84.39) 15.8,84.3 JIO1.63 ; v2(99.57,113.6) 98.42,114.75 83.22,114.75 83.09,114.87 v1(80.58,114.87) 80.31,115.14 63.87,115.14 62,113.27 52.75,113.27 45.85,106.36 39.93,106.36 v2(39.65,106.64)
  IN1 w0.109: v2(15.89,84.39) 14.5,85.79 14.5,93.33 15.73,94.56 15.73,100.91 20.42,105.6 38.73,105.6 39.65,106.52 v2(39.65,106.64)
  BOTTOM w0.102: JDOCK1.89 104.74,114.32 RE11.1 105.18,114.31 105.56,113.93 105.56,113.12 105.08,112.64 100.76,112.64 99.8,113.6 v2(99.57,113.6)
DAI_BCLK#: length 122.6
  TOP w0.102: v2(38.99,106.64) 39.47,107.13 40.03,107.13 40.59,106.57 45.76,106.57 52.7,113.5 61.71,113.5 v1(62.57,114.36) 63.55,115.34 82.91,115.34 83.27,114.99 101.31,114.99 v2(101.57,115.25) ; v2(15.51,80.2) 15.4,80.1 JIO1.77
  IN1 w0.109: v2(15.51,80.2) 15.71,80.2 16.18,80.67 16.18,82.39 14.27,84.29 14.27,93.49 15.52,94.73 15.52,101 20.4,105.88 38.33,105.88 38.99,106.54 v2(38.99,106.64)
  BOTTOM w0.102: v2(101.57,115.25) 101.7,115.13 RE12.1 101.07,114.95 101.07,117.21 101.74,117.88 JDOCK1.77
DAI_DI: length 118.7
  TOP w0.102: v2(101.57,116.44) 100.53,115.39 83.44,115.39 83.06,115.77 63.13,115.77 61.31,113.96 51.59,113.96 45.54,107.91 38.99,107.91 v1(38.35,107.28) 37.77,106.69 v2(37.77,106.64) ; v2(15.47,81.42) 15.35,81.3 JIO1.73
  IN1 w0.109: v2(15.47,81.42) 15.47,82.39 13.85,84.01 13.85,93.74 15.1,94.99 15.1,101.24 20.22,106.36 37.49,106.36 v2(37.77,106.64)
  BOTTOM w0.102: JDOCK1.83 103.24,117.68 102.01,116.45 101.58,116.45 v2(101.57,116.44)
DAI_DO#: length 120
  TOP w0.102: v2(101.57,115.84) 100.93,115.19 83.35,115.19 83,115.55 63.26,115.55 61.44,113.73 51.98,113.73 v1(49.78,111.53) 45.93,107.68 39.42,107.68 v2(38.38,106.64) ; v2(15.59,80.84) 15.46,80.7 JIO1.75
  IN1 w0.109: v2(15.59,80.84) 15.94,81.18 15.94,82.25 14.06,84.13 14.06,93.65 15.31,94.91 15.31,101.15 20.29,106.13 37.87,106.13 v2(38.38,106.64)
  BOTTOM w0.102: JDOCK1.85 103.74,117.62 101.88,115.76 101.65,115.76 v2(101.57,115.84)
DAI_LRCK#: length 121.7
  TOP w0.102: v2(15.47,79.57) 15.4,79.5 JIO1.79 ; v2(38.2,108.32) 38.3,108.42 v1(45.44,108.42) 51.21,114.19 61.21,114.19 63.03,116 83.11,116 83.52,115.6 100.14,115.6 v2(101.57,117.03)
  IN1 w0.109: v2(38.2,108.32) 36.46,106.58 16.93,106.58 14.88,104.53 14.88,95.07 13.64,93.83 13.64,83.92 15.06,82.5 15.06,79.98 v2(15.47,79.57)
  BOTTOM w0.102: v2(101.57,117.03) 102.24,117.7 JDOCK1.79
DAT_DDC2_CRT: length 104.3
  TOP w0.102: v2(85.65,164.3) v1(84.73,165.21) 84.53,165.42 84.53,167.12 85.06,167.65 R47.2 85.06,170.35 83.08,172.33 JCRT1.12
  IN4 w0.109: v2(85.65,164.3) 85.66,164.3 86.72,165.36 90.17,165.36 90.89,164.64 93.06,164.64 93.93,163.77 95.33,163.77 96.79,162.31 100.68,162.31 102.39,160.59 105.76,160.59 109.14,157.21 110.54,157.21 111.96,155.79 111.96,154.68 112.43,154.22 112.43,152.93 114.43,150.93 114.43,140.94 112.88,139.4 112.88,136.89 109.09,133.1 109.09,129.55 109.45,129.2 109.45,116.95 107,114.5 107,112.85 106.4,112.25 106.4,106.92 v2(105.18,105.7)
  BOTTOM w0.102: v2(105.18,105.7) 105,105.88 100.1,105.88 99.84,106.14 U19.34
DAT_DDC2_DOCK: length 22
  IN3 w0.127: v2(93.5,124.78) 93.04,124.32 93.04,121.81 96.37,118.48 96.37,115.29 95.47,114.4 95.47,109.93 v2(95.86,109.54)
  BOTTOM w0.102: v2(93.5,124.78) 92.74,125.53 JDOCK1.46 ; U19.25 95.51,109.19 v2(95.86,109.54) 95.86,109.84 v1(96.19,110.17)
DAT_KBD: length 230.1
  TOP w0.102: v2(250.8,49.7) 250.8,50.2 249.78,51.22 249.78,52.29 250.37,52.88 250.37,55.13 249.91,55.6 249.91,57.11 249.35,57.67 249.35,58.53 248.51,59.37 248.51,63.16 245.62,66.05 244.22,66.05 243.46,66.82 243.46,68.17 242.77,68.85 242.77,69.26 242.4,69.63 241.15,69.63 240.57,70.22 237.72,70.22 236.35,68.85 235.41,68.85 235.25,68.69 231.19,68.69 230.12,67.63 228.84,67.63 228.61,67.86 221.66,67.86 220.24,69.28 v2(219.48,69.28)
  IN1 w0.109: v2(250.8,49.7) 250.49,50 249.12,50 248.31,49.19 248.31,48.22 247.34,47.26 246.68,47.26 246.33,47.61 v2(246.33,47.69)
  BOTTOM w0.102: v2(246.33,47.69) 246.33,47.59 246.68,47.23 247.34,47.23 247.41,47.17 U51.B41 ; v2(250.8,49.7) 250.91,49.58 RP6.8 ; JDOCK1.80 102.24,128.74 106.66,133.16 113.87,133.16 115.7,131.33 119.12,131.33 120.98,133.19 126.36,133.19 129.81,129.74 129.81,128.52 131.57,126.76 131.57,117.97 132.61,116.93 132.61,108.98 136.37,105.22 140.32,105.22 145.79,110.69 152.88,110.69 157.68,105.9 157.68,101.31 161.7,97.3 188.66,97.3 191.27,94.68 196.82,94.68 202.48,89.01 207.65,89.01 212.39,84.27 v1(212.39,79.08) 212.39,77.08 219.57,69.9 219.57,69.37 v2(219.48,69.28)
DAT_MSE: length 197.4
  TOP w0.102: v2(246.99,46.81) 246.57,47.23 246.12,47.23 245.72,47.64 245.72,48.58 245.41,48.88 244.58,48.88 244.42,49.04 242.54,49.04 241.4,47.89 240.47,47.89 240.24,47.66 238.73,47.66 238.62,47.56 236.32,47.56 236.07,47.31 235.05,47.31 234.54,47.82 234.12,47.82 232.62,49.31 231.72,49.31 224.43,56.6 218.71,56.6 211.5,63.81 211.5,68.06 209.83,69.74 209.83,70.9 207.67,73.06 207.67,76.11 207.62,76.16 207.62,77.43 206.45,78.6 206.45,78.96 v2(206.98,79.49)
  IN1 w0.109: v2(250.8,49.06) 249.6,49.06 247.36,46.81 v2(246.99,46.81)
  BOTTOM w0.102: JDOCK1.73 100.74,117.9 100.44,117.6 100.44,116.4 99.87,115.83 99.87,115.8 99.5,115.43 99.47,115.43 98.88,114.84 98.88,113.63 99.31,113.2 99.9,113.2 100.66,112.43 v1(106.29,112.43) 110.72,112.43 111.97,111.18 113.3,111.18 117.09,107.39 117.09,106.36 117.7,105.75 118.67,105.75 121.88,102.54 123.12,102.54 124.96,100.7 126.6,100.7 135.64,91.66 166.19,91.66 169.06,88.79 186.66,88.79 189.7,85.74 192.66,85.74 198.68,79.72 206.75,79.72 v2(206.98,79.49) ; RP6.7 250.82,49.08 v2(250.8,49.06) ; v2(246.99,46.81) 247.14,46.67 U51.B42
DAT_TP_SIO: length 276.6
  TOP w0.102: v2(23.72,72.48) 23.72,72.24 v1(22.5,71.03) 22.15,70.68 20.67,70.68 20.25,71.1 JIO1.108
  IN4 w0.109: v2(23.72,72.48) 24.96,73.72 27.85,73.72 28.32,74.19 28.32,76.89 30.94,79.51 35.21,79.51 37.25,77.47 37.25,75.18 39.3,73.14 40.91,73.14 44.73,69.31 45.79,69.31 46.23,68.88 49.91,65.2 49.91,57.44 53.7,53.65 53.7,52.58 56.41,49.87 57.16,49.87 62.14,44.9 62.63,44.9 63.52,44.01 76.21,44.01 76.47,43.75 79.48,43.75 80.01,44.29 82.12,44.29 83.32,43.08 103.12,43.08 104.99,41.21 119.91,41.21 122.24,38.88 170.87,38.88 172.74,40.75 177.7,40.75 178.05,41.1 188.88,41.1 189.47,41.68 196.97,41.68 199.76,44.47 204.54,44.47 205.37,45.31 208.06,45.31 209.2,44.17 220.22,44.17 221.55,42.84 223.85,42.84 226.03,40.66 227.52,40.66 229.14,39.04 246.64,39.04 248.93,41.32 250.76,41.32 251.08,41.64 251.08,42.35 250.29,43.14 248.97,43.14 247.93,44.18 247.93,46.72 v2(246.96,47.69)
  BOTTOM w0.102: U51.B40 246.99,47.67 v2(246.96,47.69)
DC_BLOCK_GC: length 290
  TOP w0.254: v2(14.86,60.19) 14.55,60.49 10.16,60.49 v1(9.8,60.85) 9.37,61.28 PR700.1
  IN2 w0.254: v2(260.47,27.32) 260.35,27.2 251.65,27.2 251.03,27.83 239.11,27.83 235.52,31.42 233.87,31.42 232.15,33.13 221.94,33.13 219.28,35.8 206.3,35.8 205.84,35.34 198.82,35.34 194.7,31.23 186.63,31.23 186,31.86 179.7,31.86 178.24,33.33 176.16,33.33 174.98,34.51 118.81,34.51 117.26,36.06 110.49,36.06 110.18,35.75 97.64,35.75 93.46,39.93 90.71,39.93 90.09,40.55 78.38,40.55 77.24,39.41 54.39,39.41 46.86,46.93 46.86,48.67 47.8,49.61 47.8,58.53 42.39,63.95 41.38,63.95 38.58,66.74 37.69,66.74 37.06,67.37 35.79,67.37 34.52,68.64 29.69,68.64 26.77,65.72 26.77,62.52 25.98,61.74 16.41,61.74 v2(14.86,60.19)
  BOTTOM w0.254: PU1001.7 v2(260.47,27.32)
DDR3_DRAMRST#_CPU: length 32.9
  TOP w0.089: v2(194.06,106.31) 193.59,106.78 JCPU1.AN3
  TOP w0.102: RD30.1 209.07,90.87 QD9.3 ; RD30.1 209.52,92.22 209.52,94.35 208.48,95.39 v1(207.44,95.39) v2(206.68,94.63) ; RD30.1 RD6.2
  BOTTOM w0.102: v2(206.68,94.63) 206.4,94.63 203.02,98.01 194.67,98.01 192.51,100.17 192.51,105.6 192.76,105.86 193.61,105.86 v2(194.06,106.31)
DDR3_DRAMRST#_R: length 102.9
  TOP w0.102: JDIMM3.30 180.54,50.77 182.24,52.47 v2(182.24,52.7) ; JDIMM1.30 180.54,65.23 181.41,66.1 181.41,68.66 v2(180.85,69.21) ; v2(206.53,92.47) 207.11,92.47 RD51.2
  IN3 w0.127: v2(198.97,72.19) 198.97,72.26 205.74,79.03 205.74,88.41 206.53,89.2 v2(206.53,92.47)
  IN4 w0.109: v2(182.24,52.7) 182.24,52.25 183.18,51.31 189.52,51.31 190.88,52.67 192.9,52.67 196.52,56.29 v2(197.93,56.29)
  BOTTOM w0.102: v2(197.93,56.29) 200.23,58.59 200.23,63.34 201.29,64.4 v1(201.29,66.5) 201.29,68.49 199.87,69.91 199.87,71.29 v2(198.97,72.19) 197.61,73.55 185.79,73.55 183.28,76.06 181.58,76.06 180.54,75.02 JDIMM2.30 180.54,69.53 v2(180.85,69.21) ; v2(182.24,52.7) 181.35,53.59 181.35,56.31 180.54,57.12 JDIMM4.30
DDR_1.35V_CNTRL0: length 99.2
  IN3 w0.127: v2(234.54,75.63) 234.54,75.73 234.09,76.19 233.5,76.19 233.32,76.01 231.04,76.01 230.08,75.06 229.53,75.06 226.34,71.87 226.13,71.87 223.48,69.22 223.48,69.11 207.02,52.65 204.7,52.65 204.08,52.03 201.23,52.03 191.73,42.53 188.01,42.53 187.5,42.02 177.85,42.02 177.14,41.31 170.97,41.31 v2(169.26,39.61)
  BOTTOM w0.102: v2(169.26,39.61) 166.81,37.16 166.81,34.17 v1(160.76,28.12) PR216.2 161.25,26.51 PR219.1 ; v2(234.54,75.63) 234.48,75.56 U46.A49
DDR_1.35V_CNTRL1: length 111.5
  IN3 w0.127: v2(244.18,65.09) 244.18,65.48 243.18,66.49 237.95,66.49 237.51,66.05 237.51,63.64 236.35,62.47 236.35,62.07 235.58,61.3 234.72,61.3 234.49,61.07 228.44,61.07 225.27,57.9 225.27,54.95 222.95,52.63 220.9,52.63 220.2,51.93 213.84,51.93 209.87,47.96 209.87,46.9 206.39,43.42 205.33,43.42 203.63,41.72 194.82,41.72 193.34,40.25 188.95,40.25 187.66,38.95 181.33,38.95 180.57,38.19 174.42,38.19 172.9,36.67 168.09,36.67 167.04,35.61 v2(166.13,35.61)
  BOTTOM w0.102: v2(166.13,35.61) 159.62,29.11 158.3,29.11 v1(157.05,27.86) 156.67,27.48 PR222.2 157.56,25.85 PR223.1 ; U46.A16 243.91,65.66 244.18,65.38 v2(244.18,65.09)
DDR_A_BS0: length 77.2
  TOP w0.102: JDIMM1.109 154.44,70.94 154.19,70.69 154.19,66.16 v2(154.65,65.7) ; JCPU1.V5 178.51,108.84 v2(178.06,109.29)
  IN1 w0.089: v2(178.06,109.29) 178.19,109.29 178.29,109.19 178.29,108.84 178.18,108.73 177.87,108.73 177.7,108.56 177.7,108.03 176.68,107.01 176.68,104.86 176.55,104.73 176.55,103.7
  IN1 w0.208: 176.55,103.7 176.15,103.29 176.15,101.16 164.79,89.8 163.2,89.8 155.75,82.35 155.75,80.14 155.49,79.87 155.49,79.33 155.09,78.93 155.09,78.43 155.28,78.24 155.28,78.01 154.35,77.08 154.35,72.33 154.81,71.88 154.81,70.86 155.17,70.5 155.17,69.18 155.19,69.15 155.19,66.69 155.34,66.54 155.9,66.54 156.07,66.36 156.07,65.99 155.89,65.82 155.54,65.82 155.36,65.64 155.36,62.98 155.18,62.8 154.83,62.8 154.65,62.98 v2(154.65,65.7)
  BOTTOM w0.102: v2(154.65,65.7) 154.16,65.7 153.95,65.91 153.95,67.38 153.83,67.5 153.65,67.5 153.53,67.38 153.53,65.34 153.63,65.24 154.15,65.24 154.44,64.95 JDIMM2.109
DDR_A_BS1: length 78.1
  TOP w0.102: v2(154.62,68.83) 154.72,68.83 155.58,67.98 155.58,65.72 154.74,64.89 JDIMM1.108 ; v2(177.06,108.31) JCPU1.U5
  IN1 w0.089: 175.09,103.21 175.09,104.47 175.68,105.06 175.68,107.65 175.87,107.84 176.31,107.84 176.5,108.02 176.5,108.45 176.7,108.65 176.91,108.65 177.06,108.5 v2(177.06,108.31)
  IN1 w0.208: v2(154.62,68.83) 154.23,68.44 154.23,67.43 153.56,66.75 153.56,64.03 153.38,63.85 152.17,63.85 151.99,64.03 151.99,64.47 152.17,64.64 152.55,64.64 152.72,64.82 152.72,65.43 152.55,65.6 152,65.6 151.83,65.78 151.83,66.23 152.01,66.41 152.46,66.41 153.72,67.67 153.72,69.03 153.85,69.15 153.98,69.15 154.16,69.33 154.16,69.79 153.98,69.97 153.85,69.97 153.72,70.1 153.72,71.37 153.29,71.81 153.29,73.33 153.11,73.51 153.11,77.41 153.06,77.46 153.06,79.65 153.55,80.15 153.55,81.93 159.47,87.85 159.47,88.32 162.2,91.04 162.74,91.04 162.93,91.23 162.93,91.49 163.11,91.67 163.57,91.67 163.75,91.49 163.75,91.05 163.93,90.87 164.35,90.87 164.52,91.05 164.52,91.49 164.7,91.67 165.15,91.67 175.09,101.62 175.09,103.21
  BOTTOM w0.102: JDIMM2.108 154.74,71.12 154.2,70.58 154.2,69.26 v2(154.62,68.83)
DDR_A_BS2: length 74.8
  TOP w0.102: JDIMM1.79 163.44,71.4 165.43,69.41 165.43,66.82 165.03,66.42 v2(165.03,66.38) ; v2(184.06,105.31) 184.53,104.84 JCPU1.AD1
  IN1 w0.089: v2(184.06,105.31) 184.24,105.49 184.52,105.49 184.66,105.35 184.66,104.12 185.74,103.03 185.74,102.86
  IN1 w0.208: v2(165.03,66.38) 165.01,66.36 164.75,66.36 164.56,66.18 164.56,65.73 164.74,65.55 164.84,65.55 165.02,65.37 165.02,65.11 164.84,64.94 164.62,64.94 164.44,64.76 164.44,64.43 164.62,64.25 164.85,64.25 165.03,64.07 165.03,63.77 164.85,63.59 164.64,63.59 164.49,63.44 164.49,63.13 164.84,62.78 164.84,62.55 164.57,62.27 164.05,62.27 163.87,62.45 163.87,66.16 164.5,66.79 164.5,71.69 165.44,72.63 165.44,73.55 182.68,90.79 182.68,91.97 182.09,92.56 182.09,92.98 183.29,94.18 183.29,94.79 184.63,96.13 185.74,97.24 185.74,102.86
  BOTTOM w0.102: v2(165.03,66.38) 165.34,66.69 166.01,66.69 166.19,66.51 166.19,66.25 165.3,65.35 165.01,65.35 164.89,65.48 164.89,65.74 164.76,65.87 164.55,65.87 164.43,65.74 164.43,65.33 164.35,65.25 163.54,65.25 163.44,65.15 JDIMM2.79
