# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N265433: length 4.7
  TOP w0.102: v1(24.57,57.66) 24.57,57.72 23.28,59.01 PQ8.1 22.18,59.01 21.94,59.25 21.94,59.75 22.15,59.96 PQ8.2
N16717680: length 41.3
  TOP w0.254: PR22.1 26.16,60.91 PQ8.4 24.87,61.35 PR16.2 PR20.1 25.81,62.43 25.35,62.89 PC9.1 25.35,64.73 v1(24.46,65.62) 24.23,65.85 v2(23.54,65.85)
  TOP w0.508: PQ5.4 v3(2.26,82.87)
  IN3 w0.254: v2(23.54,65.85) 23.11,65.85 22.63,66.33 22.63,67.98 21.97,68.64 20.27,68.64 12.98,75.93 12.98,77.61 11.28,79.31 11.28,79.77 8.94,82.11 6.32,82.11 5.56,82.87 v3(2.26,82.87)
N16751240: length 1.6
  TOP w0.102: v1(10.32,62.89) 9.99,63.22 9.99,63.54 9.51,64.02 PR700.2
N16759342: length 12.2
  TOP w0.102: PQ700.2 31.04,63.67 30.83,63.87 v2(30.22,63.87) ; v2(29.64,66.74) 29.97,67.07 PQ702.2 31.84,68 PC700.2 31.11,68.01 28.8,68.01 28.27,68.54 PR703.1
  BOTTOM w0.102: v2(29.64,66.74) 30.22,66.15 v1(30.22,64.82) v2(30.22,63.87)
N16759370: length 13.2
  TOP w0.102: v2(127.51,134.46) 127.16,134.11 PQ703.1 ; v2(127.51,134.46) 126.73,135.23 125.75,135.23 PR712.2 125.26,134.74 PQ703.3 ; v2(127.51,134.46) 127.91,134.46 128.5,133.87 PR714.2 129.18,133.74 v1(129.55,133.38) ; PR709.2 v2(127.75,130.04)
  IN4 w0.109: v2(127.51,134.46) 127.75,134.21 v2(127.75,130.04)
N16759478: length 35.9
  TOP w0.102: v1(34.48,60.52) 33.74,61.25 v2(33.27,61.25)
  TOP w0.254: PR701.2 5.82,61.79 v3(5.43,61.41) ; PQ700.1 33.12,61.41 v2(33.27,61.25)
  IN4 w0.254: v2(33.27,61.25) 33.27,62.19 31.01,64.45 29.38,64.45 29.05,64.12 23.04,64.12 22.36,64.8 13.92,64.8 12.08,62.95 10.01,62.95 8.46,61.41 6.96,61.41 6.45,60.9 5.94,60.9 v3(5.43,61.41)
N16762870: length 9.8
  IN3 w0.127: v2(242.95,20.79) 242.55,20.38 240.66,20.38 v2(238.47,22.58)
  BOTTOM w0.102: v1(238.72,23.41) 238.47,23.16 v2(238.47,22.58) 238.72,22.33 PQ706.3 ; PQ706.6 241.31,20.64 241.51,20.43 PR739.1 242.6,20.43 v2(242.95,20.79)
N16762920: length 19.6
  TOP w0.254: v2(245.18,22.44) 243.24,22.44 240.84,20.04 238.52,20.04 237.46,18.99 237.46,16.66 236.59,15.79 233.91,15.79 233.42,16.27 v2(233.35,16.27)
  BOTTOM w0.102: v2(245.18,22.44) v1(245.18,23.06)
  BOTTOM w0.254: v2(245.18,22.44) 244.91,22.16 PR749.2 245.31,21.25 PU704.1 ; PQ708.6 v2(233.35,16.27)
N16762966: length 9
  IN4 w0.109: v2(241.6,21.53) 245.65,21.53 v2(246.68,20.5)
  BOTTOM w0.102: v1(242.11,22.3) 242.11,22.03 v2(241.6,21.53) 241.36,21.29 PQ706.5 ; PU704.4 247.28,19.9 v2(246.68,20.5)
N16763030: length 7.2
  BOTTOM w0.102: v1(235.57,22.95) PU703.1 236.37,21.68 236.88,21.17 236.88,20.09 PR746.1 PR738.2 PR734.2 PR742.2
N16763050: length 11.3
  BOTTOM w0.102: PC731.1 232.33,17.97 PR740.1 PR743.2 ; PC731.1 230.4,16.85 PU703.5 ; PC731.1 v1(230.81,15.05)
N16763106: length 13
  BOTTOM w0.102: PR734.1 239.24,18.68 240.52,17.4 240.52,16.15 239.78,15.41 PR736.2 PR744.1 PC729.1 237.15,15.41 v1(236.15,16.4) 235.84,16.71 235.38,16.71 234.4,17.69 234.4,18.97 234.57,19.14 PU703.3
N16763148: length 10.1
  IN3 w0.127: v2(235.93,17.15) 235.93,18.57 v2(234.08,20.41)
  BOTTOM w0.102: v2(235.93,17.15) 235.93,17.13 236.79,16.27 PR745.1 PC730.1 PR737.2 239.94,16.27 v1(240.07,16.4) ; PU703.2 v2(234.08,20.41)
N16763200: length 6.6
  BOTTOM w0.102: PU703.6 229.95,19.14 PC732.1 PR748.1 PR747.1 PR741.2 v1(228.4,13.6)
N16790095: length 4.5
  BOTTOM w0.076: 78.4,57.72 78.4,57.96 78.64,58.2 78.64,58.56 78.36,58.84 78.36,59.33 UH1.C26
  BOTTOM w0.102: 78.4,57.72 78.4,56.5 78.73,56.17 78.73,55.73 78.38,55.39 T59.1
N16807572: length 1.1
  TOP w0.102: v2(68.79,76.07) 68.73,76.14 T58.1
  BOTTOM w0.102: UH1.BB2 68.47,75.75 v2(68.79,76.07)
N16845401: length 1.2
  TOP w0.089: T65.1 74.03,74.66 v2(74.35,74.35)
  BOTTOM w0.102: v2(74.35,74.35) 74.54,74.54 UH1.AW17
N16845569: length 1.2
  TOP w0.089: v2(74.34,73.72) 73.98,73.36 T67.1
  BOTTOM w0.102: UH1.AV17 74.56,73.94 v2(74.34,73.72)
N16855849: length 1.4
  TOP w0.102: PR549.1 154.3,162.81 v1(153.83,162.34)
N16857314: length 5.3
  BOTTOM w0.076: UH1.BA2 68.28,75.02 67.69,75.02 67.36,75.35 67.1,75.35 66.9,75.55
  BOTTOM w0.102: T57.1 64.64,77.81 66.9,75.55
N16858942: length 1.2
  TOP w0.089: v2(71.73,66.95) 71.28,66.5 T144.1
  BOTTOM w0.102: UH1.AB10 71.54,67.15 v2(71.73,66.95)
N16863974: length 9.3
  BOTTOM w0.102: UH1.AV43 85.99,73.85 86.34,74.2 86.66,74.2 87.4,74.94 87.4,75.27 87.84,75.71 87.84,76.01 88.01,76.18 88.01,78.2 87.84,78.36 87.84,80.65 T132.1
N16864660: length 7.6
  BOTTOM w0.102: UH1.AY45 86.57,74.68 86.99,75.11 86.99,75.43 87.43,75.88 87.43,76.18 87.6,76.35 87.6,78.03 87.44,78.19 87.44,81.31 T133.1
N16864959: length 10.3
  BOTTOM w0.102: UH1.AV45 86.6,73.85 87.6,74.86 87.6,75.18 88.04,75.62 88.04,75.93 88.21,76.09 88.21,78.28 88.05,78.45 88.05,80.47 88.54,80.96 88.86,80.96 89.66,81.76 T130.1
N16865260: length 9.1
  BOTTOM w0.076: UH1.AW44 86.09,74.38 86.56,74.38 86.83,74.65
  BOTTOM w0.102: T131.1 88.05,81.51 88.05,81.14 87.64,80.73 87.64,78.28 87.81,78.11 87.81,76.26 87.64,76.09 87.64,75.79 87.2,75.35 87.2,75.03 86.83,74.65
N16885932: length 11.7
  BOTTOM w0.102: T134.1 90.11,81.01 90.11,80.29 89.25,79.44 89.25,76.56 88.45,75.76 88.45,75.45 88.04,75.05 88.04,74.72 86.68,73.36 86.32,73.36 86.1,73.15 85.87,73.15 85.57,73.44 UH1.AU42
N16885933: length 8.7
  BOTTOM w0.076: UH1.AU44 86.07,73.55 86.58,73.55 86.91,73.88
  BOTTOM w0.102: 86.91,73.88 87.84,74.81 87.84,75.13 88.25,75.54 88.25,75.84 89.05,76.65 89.05,80.01 T66.1
N16901605: length 5.3
  TOP w0.102: R955.1 285.61,88.66 286.09,89.14 286.98,89.14 287.25,88.87 Q84.3 287.68,87.84 v1(288.48,88.63)
N16903949: length 3.7
  TOP w0.102: v1(24.62,78.77) 24.62,78.41 23.71,77.5 Q80.1 R942.1
N16904000: length 2.7
  TOP w0.102: Q93.1 24.59,73.98 v1(25.21,74.61) 25.56,74.95 Q80.2
N16917464: length 3.2
  BOTTOM w0.102: PR225.1 156.67,24.81 PC217.1 157.56,24.78 PR223.2 157.35,24.57 PQ205.5
N16917466: length 5.8
  BOTTOM w0.102: PR220.1 160.35,24.81 PC219.1 ; v1(161.75,26.82) 161.75,25.28 PR219.2 161.24,24.78 PC219.1 ; PQ204.5 160.47,24.64 PC219.1
N16917470: length 6.6
  BOTTOM w0.102: PQ204.3 159.82,20.85 159.46,20.5 PR213.2 160.22,19.98 PC216.1 ; PQ204.2 160.47,19.85 PC216.1 ; PC216.1 PR217.1 v1(160.41,17.43)
N16917506: length 6
  BOTTOM w0.102: PQ205.2 157.35,20.08 ; 157.35,20.08 PC220.1 PR224.1 v1(157.38,17.86) ; 157.35,20.08 PR221.2 156.54,20.47 156.7,20.63 PQ205.3
N16917526: length 3.3
  BOTTOM w0.102: PQ204.6 161.12,23.72 PR211.1 v1(163.57,24.86)
N16917538: length 1.6
  BOTTOM w0.102: PR218.2 158.47,24.78 158.47,24.32 158,23.85 PQ205.6
N16949390: length 3.6
  TOP w0.076: v2(71.15,68.54) 70.75,68.14 68.43,68.14 T141.1
  BOTTOM w0.102: v2(71.15,68.54) 71.15,68.48 71.54,68.09 UH1.AD10
N16952696: length 2.1
  BOTTOM w0.102: v1(246.54,58.74) R399.2 247.55,57.95 Q28.2
N17008746: length 3.1
  BOTTOM w0.102: R130.2 v1(31.67,97.27)
  BOTTOM w0.254: R130.2 33.15,96.99 U29.17
N17068457: length 1.9
  TOP w0.102: v2(83.77,68.54) 84.12,68.19 84.12,67.62 T148.1
  BOTTOM w0.102: UH1.AD39 83.91,68.4 v2(83.77,68.54)
N17068936: length 1.4
  TOP w0.102: v2(83.16,68.54) 83.69,68.01 T147.1
  BOTTOM w0.102: UH1.AD38 83.31,68.39 v2(83.16,68.54)
N17074316: length 8.5
  TOP w0.102: v2(42.09,107.15) 42.37,107.15 v1(42.57,106.95) 42.7,106.82 45.12,106.82 v2(45.58,107.28)
  BOTTOM w0.102: R721.2 45.57,107.96 Q347.3 v2(45.58,107.28) ; v2(42.09,107.15) 42.09,107.64 Q343.2 42.39,107.95 42.59,107.74 42.59,106.49 42.39,106.29 Q343.5
N17075286: length 2.4
  BOTTOM w0.102: v1(40.32,108.95) R129.1 41.74,108.84 Q343.1
N17075290: length 4.8
  BOTTOM w0.102: v1(42.7,105.14) 43.04,105.49 Q343.4 43.53,106.54 43.53,108.29 42.87,108.95 R132.1
N17075402: length 6.9
  TOP w0.102: PR7.2 5.99,92.85 v1(5.57,92.43)
  TOP w0.254: PR9.1 6.76,96.61 PQ2.3 6.7,95.29 PR7.2
N17103600: length 6.5
  BOTTOM w0.102: UH1.BA45 86.44,75.45 87.03,76.04 87.03,76.35 87.2,76.52 87.2,77.86 87.03,78.02 87.03,81.29 T149.1
N17104124: length 6.2
  BOTTOM w0.102: T150.1 86.27,80.66 86.83,80.1 86.83,77.94 86.99,77.78 86.99,76.67 86.82,76.49 86.82,76.33 UH1.BC45
N17104650: length 4.6
  BOTTOM w0.102: T120.1 85.52,80.68 85.52,77.27 UH1.BE43
N17105178: length 3.3
  BOTTOM w0.102: UH1.BE44 86.09,77.24 86.09,80.21 T121.1
N17139830: length 1.2
  TOP w0.102: v2(81.84,63.07) 81.84,63.26 T122.1
  BOTTOM w0.102: UH1.M33 81.5,63.41 v2(81.84,63.07)
N17139840: length 1.4
  TOP w0.102: T123.1 81.87,62.44 v2(81.86,62.44)
  BOTTOM w0.102: UH1.L33 81.53,62.76 v2(81.86,62.44)
N17164171: length 3.7
  BOTTOM w0.102: UH1.BC30 79.97,76.63 80.3,76.96 80.3,77.83 80.32,77.85 80.32,78.83 80.58,79.1 T124.1
N17164181: length 1.4
  TOP w0.102: v2(78.92,75.58) 79.07,75.73 T125.1
  BOTTOM w0.102: v2(78.92,75.58) 79.41,75.58 UH1.BB29
N17205976: length 3.6
  BOTTOM w0.102: v1(275.02,36.37) 274.65,36.01 274.18,36.01 273.81,35.64 R864.2
  BOTTOM w0.254: JDEG2.10 273.84,35.59 R864.2
N17220570: length 8.5
  TOP w0.076: v2(70.92,73.44) 70.53,73.06 69.49,73.06 69.05,73.51 68.77,73.51 68.32,73.95
  TOP w0.102: RH195.2 v1(66.59,76.75) 66.67,76.67 67,76.67 67.23,76.43 67.23,75.51 67.54,75.21 67.54,74.74 68.32,73.95
  BOTTOM w0.102: v2(70.92,73.44) 70.94,73.42 UH1.AT8
N17319754: length 106.5
  IN1 w0.254: v2(183.69,14.67) 188.11,14.67 190.22,12.56 197.61,12.56 198.85,11.32 206.6,11.32 206.8,11.52 211.5,11.52 212.62,12.64 223.21,12.64 225.78,15.2 225.78,17.18 226.52,17.92 228.63,17.92 232.21,21.5 232.21,25.18 233.12,26.1 265.91,26.1 268.88,29.07 268.88,31.38 267.99,32.27 v2(267.99,32.32)
  BOTTOM w0.254: PQ1003.4 v1(186.16,15.09) 185.24,15.09 PC1004.1 184.52,15.49 v2(183.69,14.67) ; v2(267.99,32.32) 267.97,32.3 PR1004.1
N17649391: length 7.3
  TOP w0.102: PBATT1.7 201.34,7.01 201.11,7.24 v1(200.98,7.24) 199.15,7.24 199.02,7.37 PD3.3
N17657331:
  vias: v1(174.67,24.31)
N17657337: length 30.4
  TOP w0.254: v2(169.92,22.64) 172.36,25.08 174.55,25.08 175.18,25.72 PR1097.1 175.18,27.39 PC1099.2 175.18,27.55 PR1099.2 ; v2(169.92,22.64) 169.19,21.91 PQ1008.4 ; v2(169.92,22.64) 168.38,24.19 162.97,24.19 160.17,21.4 PD1099.1 ; v2(170.46,16.9) 170.46,17.72 170.84,18.1 PQ1009.4
  BOTTOM w0.254: v2(170.46,16.9) v1(170.46,18.43) 170.46,22.11 v2(169.92,22.64)
N17657416: length 3.3
  TOP w0.102: PQ1010.1 172.07,26.17 171.6,25.69 v1(171.6,25.45)
  TOP w0.508: PR1097.2 174.14,25.85 172.87,25.85 172.57,26.15 PQ1010.1
N17657433: length 2.2
  TOP w0.102: v1(172.07,29.32) 172.2,29.2 PR1098.2 173.22,29.06 PQ1010.2
N17657445: length 39.9
  TOP w0.102: v1(157.65,19.97) PD1099.2
  TOP w0.508: PD1099.2 158.22,21.4 v2(158.93,22.11)
  IN3 w0.508: v3(192.43,19.6) 192.23,19.6 186.87,24.96 172.21,24.96 171.42,24.17 160.98,24.17 v2(158.93,22.11)
N17657654: length 108.8
  TOP w0.102: PQ1002.4 184.24,10.19 v1(184.24,8.97)
  TOP w0.254: v2(187.02,16.68) 184.9,16.68 184.25,16.03 184.25,12.26 184.63,11.88 PQ1002.4
  IN1 w0.254: v2(187.02,16.68) 187.02,16.37 190.31,13.08 197.59,13.08 199,11.67 206.31,11.67 206.54,11.9 211.33,11.9 218.95,19.52 224.13,19.52 224.69,18.96 228.98,18.96 231.85,21.83 231.85,25.34 232.97,26.45 265.73,26.45 268.53,29.25 268.53,30.87 v2(267.99,31.41)
  BOTTOM w0.254: PR1006.1 267.97,31.43 v2(267.99,31.41)
N17684555: length 4.4
  BOTTOM w0.102: v1(193.58,22.48) 191.91,22.48 191.15,23.24 PC1005.1
  BOTTOM w0.508: PC1005.1 190.05,23.24 PR1005.2
N17707524: length 1.4
  BOTTOM w0.102: v1(251.1,18.69) 250.73,18.69 250.57,18.86 PQ1071.2
N17707536: length 4
  BOTTOM w0.102: PR1071.2 255.32,22.8 v1(255.59,23.06)
  BOTTOM w0.254: PQ1070.3 256.46,21.23 256.18,21.51 PR1070.1 PR1071.2
N17707538: length 4
  BOTTOM w0.102: PR1072.1 v1(253.54,23.23)
  BOTTOM w0.254: PR1072.1 PR1071.1 254.53,21.78 PQ1070.2
N17707548: length 4.6
  BOTTOM w0.102: v1(252.06,24.22) 252.63,23.65 PR1072.2
  BOTTOM w0.254: PQ1071.6 251.22,21.96 251.52,22.26 252.27,22.26 PR1072.2
N17708032: length 4.2
  TOP w0.102: v1(202.92,10.54) 202.25,9.87 PC5.1
  TOP w0.381: PQ1.2 203.25,8.9 202.82,9.34 PC5.1 PR33.2
N17708061: length 5.3
  TOP w0.102: v1(209.7,7.62) 208.67,6.59 PD5.2
  TOP w0.381: PQ1.1 207.78,7.94 208.13,7.6 PD5.2
N17794318:
  vias: v1(130.63,108.85)
N18022707: length 87.3
  TOP w0.102: Q304.2 40.7,73.34 40.41,73.05 40.41,69.88 39.79,69.25 R762.2 R781.2 41.21,68.1 41.21,67.27 41.88,66.6 41.88,64.2 46.79,59.3 v1(46.79,56.02) v2(46.79,53.94) ; U36.3 72.57,40.4 72.52,40.45 72.52,41.67 v2(72.41,41.77)
  IN3 w0.127: v2(72.41,41.77) 72.06,42.13 64.41,42.13 63.65,41.36 v2(63.65,41.29) 63.63,41.31 59.99,41.31 47.37,53.94 v2(46.79,53.94)
  BOTTOM w0.102: U37.5 54.79,16.97 54.64,17.13 53.64,17.13 53.31,17.46 53.31,24.85 57.73,29.27 57.73,31.83 63.65,37.75 v2(63.65,41.29)
N18028693: length 4.3
  BOTTOM w0.102: D53.2 95.46,164.1 U55.4 95.22,162.57 R433.2 v1(93.18,162.57)
N18381813: length 8.6
  BOTTOM w0.102: Q347.5 44.93,106.39 44.78,106.54 44.4,106.54 44.28,106.42 Q347.6 43.05,104.81 v1(40.84,104.81) 40.21,104.81 39.93,105.09 39.93,106.26 R722.2
N18894456: length 24.8
  TOP w0.254: PR528.2 154.76,174.54 PR525.2 153.77,174.62 v2(154.25,175.1) ; v2(162.05,160.92) 162.18,160.8 162.51,160.8 v1(163.46,161.74) 163.66,161.94 165.23,161.94 165.71,161.46 PH500.2
  IN4 w0.254: v2(154.25,175.1) 155.27,174.08 156.66,174.08 158.62,172.12 158.62,171 161.52,168.11 161.52,161.05 161.77,160.8 161.92,160.8 v2(162.05,160.92)
N18894698: length 8.9
  TOP w0.102: PR526.1 153.1,163.6 153.1,162.98 152.88,162.76 v1(151.53,162.76)
  TOP w0.203: 154.19,166.22 154.55,166.58 PU500.17
  TOP w0.254: PR526.1 v2(153.77,165.09) 153.77,165.8 154.19,166.22
  BOTTOM w0.254: PC511.1 155.1,166.5 154.51,165.9 154.51,165.6 154,165.09 v2(153.77,165.09)
N18894707: length 3
  TOP w0.203: PU500.28 159.03,168.75
  TOP w0.254: PR507.2 160.65,168.09 159.99,168.75 159.03,168.75
N18894708: length 2.8
  TOP w0.203: PU500.30 158.69,169.55
  TOP w0.254: PR514.2 159.9,169.86 v1(159.63,169.58) 159.59,169.55 158.69,169.55
N18894710: length 2.8
  TOP w0.203: PU500.29 158.62,169.15
  TOP w0.254: 158.62,169.15 160.53,169.15 160.68,169 PR509.2
N18894766: length 2.7
  TOP w0.102: v1(146.26,172.02) 147.23,172.99 PC520.2
  TOP w0.254: PR533.1 147.34,173.04 PC520.2
N18894780: length 2.3
  BOTTOM w0.102: PR543.1 v1(150.84,174)
  BOTTOM w0.254: PC527.2 149.48,174.03 PR543.1
N18894784: length 2.6
  TOP w0.102: v1(149.43,175.04) PC526.2
  TOP w0.254: PR541.1 150.44,172.99 PC526.2
N18894793: length 2.8
  TOP w0.203: PU500.9 153.64,170.35 153.44,170.55 v2(153.44,170.88)
  BOTTOM w0.102: v2(153.44,170.88) v1(153.44,171.48)
  BOTTOM w0.254: v2(153.44,170.88) 153.57,170.75 PR529.2
N18894855: length 4.8
  TOP w0.203: PU500.14 153.45,168.35 153.19,168.09 v2(152.17,168.09)
  BOTTOM w0.254: v2(152.17,168.09) v1(152.17,168.8) 151.28,169.69 PC522.1 PR537.1
N18894856: length 2.1
  BOTTOM w0.102: v1(152.21,167.27) 151.65,167.83 PR545.2
  BOTTOM w0.254: PR545.2 151.31,168.69 PC522.2
N18894871: length 26.3
  TOP w0.254: v2(150.57,165.39) 150.57,163.09 153.16,160.5 153.16,158.69 154.13,157.72 154.96,157.72 157.68,155 v1(159.68,155) 166.62,155 167.33,154.29 PH501.2
  BOTTOM w0.254: v2(150.57,165.39) 150.39,165.57 PR551.1
N18894872: length 4.4
  TOP w0.102: v2(149.05,164.91) v1(149.05,164.2)
  TOP w0.254: PC538.1 149.9,165.76 v2(149.05,164.91)
  BOTTOM w0.254: v2(149.05,164.91) PC532.1 149.9,165.53 PR548.2
N18894895: length 5
  TOP w0.203: PU500.16 153.91,167.21 153.77,167.07
  TOP w0.254: 153.77,167.07 v1(152.86,166.16) 152.68,165.98 v2(152.68,165.47) 152.68,164.28 PR531.1
  BOTTOM w0.254: v2(152.68,165.47) 153.2,165.99 PC519.1
N18986312: length 6.4
  BOTTOM w0.102: PR775.1 222.06,32.26 221.41,31.61 v1(221.41,30.91)
  BOTTOM w0.254: PU700.20 225.14,30.05 224.65,30.54
  BOTTOM w0.508: PR775.1 223.43,32.26 224.06,31.62 PC791.1 224.45,30.54 224.65,30.54
N18986344: length 2.4
  BOTTOM w0.254: PU700.9 231.38,28.55 PR766.1
N18986424: length 4.5
  BOTTOM w0.254: PR764.2 PR760.1 PR758.1 v1(230.38,27.62) 229.95,28.05 PU700.10
N18986719: length 5.6
  BOTTOM w0.102: PR704.2 233.15,29.72 v1(233.25,29.62)
  BOTTOM w0.254: PU700.7 230.32,29.55 PC744.2 PR705.2 PR704.2
N18986737: length 1.7
  BOTTOM w0.102: v1(221.3,26.35) 221.78,26.83 PR765.2
N18986745: length 2.6
  BOTTOM w0.254: PR763.1 230.94,29.05 v1(230.44,29.05) PU700.8
N18986747: length 2.6
  BOTTOM w0.254: PR759.1 226.72,25.16 227.35,25.79 v1(227.35,26.16) 227.35,26.51 227.29,26.57 PU700.13
N18986804: length 4.5
  BOTTOM w0.102: PR761.1 228.87,26.16 v1(229.77,26.16)
  BOTTOM w0.254: PU700.12 227.79,25.2 PR761.1
N18989990: length 28.2
  TOP w0.102: v2(244.19,24.66) 245.13,24.66 254.62,15.18 v2(254.62,14.76)
  BOTTOM w0.102: PQ707.6 254.81,14.57 v2(254.62,14.76) ; PR760.2 236.41,26.61 v1(236.75,26.26) 242.59,26.26 v2(244.19,24.66)
N19359738: length 4.9
  BOTTOM w0.102: v1(30.2,39.13) 30.73,39.66 PR100.2
  BOTTOM w0.203: 33.69,38.53 33.72,38.53 33.89,38.36 PU101.4
  BOTTOM w0.254: 33.69,38.53 33.17,39.05 32.54,39.05 PR102.2 31.93,39.66 PR100.2
N19359776: length 3.6
  BOTTOM w0.203: PR118.2 34.67,41.39 v1(34.67,40.55) 35,40.22 35.33,40.22 35.53,40.02 PU101.7
  BOTTOM w0.254: PR119.1 33.91,41.52 PR118.2
N19359778: length 4.2
  BOTTOM w0.102: PR105.1 32.96,39.68 33.49,40.21 33.49,40.86 v1(32.8,41.55)
  BOTTOM w0.203: 33.96,38.88 34.07,38.76 PU101.5
  BOTTOM w0.254: PR105.1 33.22,39.61 33.96,38.88
N19359887: length 6.3
  BOTTOM w0.102: v1(30.4,34.29) 30.58,34.47 30.58,35.64 31.05,36.11 PR101.2
  BOTTOM w0.203: 33.72,37.39 33.89,37.56 PU101.2
  BOTTOM w0.254: 33.72,37.39 33.68,37.35 33.68,37.02 33.27,36.61 32.51,36.61 31.95,36.05 PR104.2 31.42,36.03 31.34,36.11 PR101.2
N19360011: length 3.7
  BOTTOM w0.102: PR106.1 33.22,35.7 33.72,35.7 v1(34.16,35.26)
  BOTTOM w0.203: PU101.1 34.15,37.16 34.03,37.05 34.03,36.92
  BOTTOM w0.254: PR106.1 33.04,36.17 33.44,36.17 34.03,36.77 34.03,36.92
N19871054: length 3.6
  BOTTOM w0.102: PQ1080.5 221.83,50.28 221.51,50.6 PU1081.4 v1(219.69,50.6)
N19871111: length 5.2
  BOTTOM w0.102: PU1081.2 223.54,51.25 PR1081.2 ; PR1081.2 PR1083.2 224.51,50.66 PQ1082.1 ; PR1081.2 v1(224.18,53.11)
N19876513: length 4.8
  TOP w0.102: v1(124.57,129.53) 124.57,128.9 PR713.1 PR715.2 125.82,129.1 125.75,129.16 125.75,129.81 125.26,130.3 PQ703.4
N19877490: length 31.9
  TOP w0.102: v2(29.62,65.39) 29.6,65.39 v1(28.82,64.61)
  TOP w0.254: v2(29.62,65.39) 30.33,66.1 PQ702.1 ; v3(6.2,61.41) 5.82,61.02 PR701.3
  IN4 w0.254: v3(6.2,61.41) 6.55,61.76 8.3,61.76 9.85,63.31 11.93,63.31 13.8,65.18 22.52,65.18 23.21,64.48 28.7,64.48 v2(29.62,65.39)
N20013103:
  vias: v1(51.47,41.03)
N20018440: length 25.8
  IN2 w0.127: v2(223.34,44.35) 223.34,45.14 v2(220.18,48.3)
  BOTTOM w0.102: v2(223.34,44.35) 221.83,45.86 PQ1080.2 ; v1(222.6,62.85) 222.73,62.72 222.73,61.07 PU1080.4 221.69,60.5 220.24,59.06 220.24,56.34 218.67,54.77 218.67,49.81 v2(220.18,48.3)
N20019416: length 1.8
  BOTTOM w0.203: U37.12 57.8,16.17
  BOTTOM w0.254: 57.8,16.17 58.04,15.94 C545.2
N20019477: length 1.9
  BOTTOM w0.203: U37.10 57.85,16.97
  BOTTOM w0.254: C543.2 58.72,17.18 58.06,17.18 57.85,16.97
N20019650: length 3.8
  TOP w0.102: v1(73.48,34.52) 73.29,34.71 73.29,35.66 C435.2
  TOP w0.203: C435.2 72.57,36.39 U36.12
N20019729: length 3.8
  TOP w0.102: C417.2 71.26,35.87 71.26,34.62 v1(71.42,34.46)
  TOP w0.203: C417.2 71.77,36.37 U36.10
N20023566: length 2
  TOP w0.102: C477.2 104.7,39.64 v1(103.81,39.64) U40.12
N20023627: length 2.3
  TOP w0.102: U40.10 103.13,38.84 103.63,38.34 v1(103.83,38.34) 104.42,38.34 C476.2
N20138964: length 13.5
  BOTTOM w0.102: PQ708.3 234.56,13.84 233.59,12.87 227.73,12.87 227.05,13.55 227.05,15.38 PR747.2 227.19,16.1 v1(225.91,16.1)
N20194744: length 90.8
  TOP w0.102: PQ1005.4 185.16,17.46 184.62,16.92 v2(184.4,16.92) 184.07,17.25 PR1026.2
  IN3 w0.127: v2(243.07,17.7) 242.69,17.32 241.48,17.32 232.37,26.43 232.37,34.14 231.3,35.22 220.37,35.22 218.77,33.62 213.83,33.62 213.13,34.32 200.98,34.32 200.11,33.45 198.39,33.45 193.06,28.13 193.06,19.01 191.34,17.29 186.9,17.29 186.54,16.92 v2(184.4,16.92)
  BOTTOM w0.102: v1(244.52,19.14) 244.21,18.83 PQ1083.4 243.14,17.77 v2(243.07,17.7)
N20194878: length 2
  BOTTOM w0.102: v1(243.05,14.66) 242.19,15.52 PQ1083.2
N20195902: length 36.2
  BOTTOM w0.102: PD1010.2 247.66,15.39 247.66,26.89 253.34,32.57 253.34,34.02 255.04,35.72 255.04,38.05 255.54,38.56 v1(256.39,38.56) 256.51,38.56 256.75,38.8 259.77,38.8 260.2,38.37 262.23,38.37 PR1014.2
N20196027: length 23.4
  IN3 w0.127: v2(249.12,29.83) 249.89,29.06 249.89,17.41 v2(249.44,16.97)
  BOTTOM w0.102: v1(244.88,27.83) 245.29,27.83 PR1032.1 PR1030.1 248.04,28.74 v2(249.12,29.83) ; PD1100.2 251.99,15.94 250.97,16.97 v2(249.44,16.97) PQ1011.2
N20202315: length 28
  TOP w0.102: v2(245.96,16.07) 246.35,15.68 249.69,15.68 v2(251.31,17.3)
  IN3 w0.127: v2(243.99,29.64) 244.77,28.87 244.77,17.27 v2(245.96,16.07)
  BOTTOM w0.102: PR1100.2 240.5,30.24 241.1,29.64 v1(242.62,29.64) v2(243.99,29.64) ; v2(245.96,16.07) 246.63,16.07 246.84,15.87 PQ1072.2
  BOTTOM w0.254: v2(251.31,17.3) 250.99,17.62 PQ1011.1
N20202318: length 20.9
  TOP w0.102: v2(249.4,16.09) 248.12,16.09 v2(246.84,17.37)
  IN3 w0.127: v2(247,30.42) 245.9,29.31 245.9,18.31 v2(246.84,17.37)
  BOTTOM w0.102: PR1032.2 246.2,29.86 246.76,30.42 v2(247,30.42) 247.37,30.79 v1(247.37,31)
  BOTTOM w0.254: PD1010.3 249.18,15.87 v2(249.4,16.09) ; PQ1072.1 v2(246.84,17.37)
N20228200: length 18.3
  IN3 w0.127: v2(246.4,30.71) 246.4,30.14 245.67,29.41 245.67,19.76 v2(245.41,19.51)
  BOTTOM w0.102: v1(245.43,30.71) 245.43,30.71 v2(246.4,30.71) 247,31.3 PR1033.1 ; PQ1083.5 242.19,19.57 242.36,19.74 245.18,19.74 v2(245.41,19.51)
N20357244: length 4.5
  TOP w0.102: v1(110.84,31.62) 111.49,32.27 112.37,32.27 R221.2 112.83,31.82 JUSH1.11
N20378177: length 6.4
  BOTTOM w0.102: PR28.1 6.55,136.64 5.49,136.64 5.09,137.03 5.09,137.72 4.17,138.64 U59.6 3.7,138.64 v1(2.78,139.56)
N20503387: length 4.6
  TOP w0.102: v1(208.79,107.65) 206.06,107.65 205.94,107.76 QC1.1 RC20.1
N20515660: length 5.7
  TOP w0.102: v1(206.3,94.03) 206.79,93.54 RD5.2 207.31,93.54 RD51.1 208.18,92.65 RD6.1 206.92,91.39 QD9.1
N20966390: length 6.4
  TOP w0.102: PR10.2 10.01,91.26 v1(9.66,90.92)
  TOP w0.254: PR7.1 6.75,91.98 PL3.1 ; PL3.1 9.97,91.98 PR10.2 ; PL3.1 PQ2.1
N20966408: length 5.1
  TOP w0.102: v1(11.45,90.79) 11.99,91.33 11.99,91.97 11.11,92.85 PR12.2
  TOP w0.254: PQ3.2 10.88,92.87 PR12.2 PR10.1
N20966410: length 8.9
  TOP w0.102: v1(11.45,100.86) 11.94,100.38 PR11.2
  TOP w0.254: PR11.2 11.94,98.36 11.61,98.03 PR13.1 11.61,96.21 PQ3.1 11.53,95.36 11.2,95.03 9.7,95.03 9.32,95.42 PQ2.2
N21091187: length 11.3
  TOP w0.102: v2(239.11,49.24) 239.62,49.75 239.62,50.91 238.45,52.08 234.48,52.08 233.76,52.81 v2(232.38,52.81)
  BOTTOM w0.102: v2(239.11,49.24) 239.04,49.17 U51.B15 ; T155.1 232.04,53.15 v2(232.38,52.81)
N21091217: length 12.9
  IN3 w0.127: v2(246.96,49.17) 247.53,49.17 249.23,50.86 250.19,50.86 251.66,52.32 254.39,52.32 254.86,52.79 256.26,52.79 v2(256.72,53.25)
  BOTTOM w0.102: v2(256.72,53.25) 256.64,53.18 T161.1 ; U51.B37 247.65,49.17 v2(246.96,49.17)
N21091251: length 2.9
  BOTTOM w0.102: U46.A44 232.11,71.16 231.97,71.3 231.63,71.3 230.86,72.07 T164.1
N21091271: length 4
  BOTTOM w0.102: U46.B1 243.24,73.41 244.83,74.99 244.83,76.14 T165.1
N21631508: length 130.2
  IN3 w0.508: v3(180.47,22.29) 180.47,13.35 184.56,9.26 v3(184.56,6.06)
  IN4 w0.508: v3(258.62,37.94) 259.51,37.05 261.8,37.05 264.29,34.56 264.29,26.81 263.3,25.82 263.3,22.01 261.85,20.56 261.85,16.88 257.02,12.05 213.13,12.05 206.32,5.25 185.37,5.25 v3(184.56,6.06)
  BOTTOM w0.102: PQ1004.4 178.19,21.65 v1(177.67,21.13)
  BOTTOM w0.508: PR1009.1 258.93,37.63 v3(258.62,37.94) ; v3(180.47,22.29) 179.83,21.65 PQ1004.4
N22506578: length 3.6
  BOTTOM w0.102: v1(267.04,34.51) 266.47,33.93 PR1008.1
  BOTTOM w0.254: PR1008.1 266.44,33.18 PU1001.28
N22982928: length 2.3
  TOP w0.102: v1(17.18,134) 17,134.18 R944.2 16.11,133.77 15.98,133.63 Q87.1
N23707366: length 1.3
  TOP w0.102: 49.16,42.85 49.16,43.51 v1(48.72,43.96)
N23802801: length 1.7
  BOTTOM w0.102: T166.1 238.7,62.61 239.06,62.98 239.06,63.36 238.98,63.45 U46.A23
N23870914: length 2.5
  TOP w0.102: U60.2 9.9,144.53 R2181.2 9.57,143.45 v1(9.33,143.21)
N23870916: length 2.9
  TOP w0.102: v1(11.34,146.58) 11.34,146.08 10.86,145.6 U60.1 10.01,145.18 9.97,145.23 R2180.2
N23873950: length 2.5
  TOP w0.102: R1970.2 45.69,134.78 JMXM1.55
N23874410: length 3.5
  TOP w0.102: JMXM1.78 51.44,145.84 49.85,147.43 T175.1
N23874460: length 1.9
  TOP w0.102: JMXM1.79 51.69,134.84 T176.1
N24684603: length 1.4
  TOP w0.203: U34.6 108.82,169.66 C539.1
N24685008: length 3.1
  TOP w0.102: v1(42.82,127.13) C436.1 42.26,128.08 41.5,128.85 U35.6
N24685350: length 3.1
  TOP w0.102: C538.2 v1(105.03,170.42)
  TOP w0.203: U42.6 103.23,169.51 103.86,170.14 C538.2
N24685577: length 2.9
  BOTTOM w0.102: v1(271.98,42.82) 272.59,42.22 C541.1
  BOTTOM w0.254: U43.6 272.9,41.54 C541.1
N24685840: length 3
  BOTTOM w0.102: U49.6 13.06,146.16 C542.1 12.83,146.39 12.15,146.39 v1(11.76,146)
N24686108: length 4.2
  TOP w0.102: v1(29.37,35.09) 29.31,35.15 28.9,35.15 28.73,34.98 27.95,34.98 C544.1 27.23,34.25 27.23,33.54 27.69,33.08 U57.6
N24686395: length 2.8
  TOP w0.102: C547.1 v1(103.59,77.46)
  TOP w0.203: C547.1 101.95,77.07 U63.6
N24820283: length 4.9
  TOP w0.508: v2(202.63,52.46) 200.46,52.46 JSATA1.10
  BOTTOM w0.102: R1635.2 v1(205.08,53.02)
  BOTTOM w0.508: R1635.2 203.2,53.02 v2(202.63,52.46)
N24821013: length 4.3
  TOP w0.102: v1(81.53,35.42) 81.27,35.15 R1636.2
  TOP w0.508: R1636.2 80.49,35.05 80.49,32.2
N25627554:
  vias: v1(288.62,145.1)
N32810427: length 1.9
  BOTTOM w0.102: v1(246.43,60.64) RE5.2 CE3.1
N32810440: length 2.2
  BOTTOM w0.102: U39.9 258,60.05 R657.1
N32854162: length 2
  BOTTOM w0.102: C704.1 R756.2 114.29,113.4 v1(114.71,113.82)
N32854418: length 2
  BOTTOM w0.102: v1(102.87,113.08) 103.19,113.4 CE8.1 RE11.2
N32854492: length 2.4
  BOTTOM w0.102: CE9.1 RE12.2 101.73,113.4 v1(102.77,114.44)
N32916170: length 5.8
  IN3 w0.127: v2(242.15,65.47) 244.35,63.28 v2(244.35,62.12)
  BOTTOM w0.102: v2(244.35,62.12) 244.07,61.84 R804.1 ; v2(242.15,65.47) 241.73,65.04 U46.B19
N32917438: length 4.6
  BOTTOM w0.102: U46.B18 242.39,64.81 v1(244.44,62.76) 244.96,62.24 R802.2
N32917691: length 2
  BOTTOM w0.102: R795.2 C713.1 v1(237.59,59.5)
N32917698: length 8.9
  TOP w0.102: v2(228.6,73.09) 229.08,72.61 234.23,72.61 v2(234.32,72.7)
  BOTTOM w0.102: v1(227.89,74.63) R797.2 228.14,73.09 v2(228.6,73.09) ; U46.B49 233.86,72.41 234.16,72.7 v2(234.32,72.7)
N32917710: length 2
  BOTTOM w0.102: v1(232.5,59.59) 232.89,59.98 C712.1 R794.2
N33080426: length 2.9
  BOTTOM w0.102: R423.2 102.61,160.33 Q22.1 102.37,159.66 102.59,159.45 v1(103.17,159.45)
N34391004: length 3.1
  BOTTOM w0.102: Q29.5 Q29.6 204.77,64.58 R513.2 v1(206.07,65.6)
N35432705: length 2.3
  TOP w0.102: v1(133.95,169) 133.75,169.19 R939.1 Q79.1
N35432724: length 4.3
  TOP w0.102: v1(130.43,171.88) 130.71,171.6 Q79.2 130.71,170.09 131.8,169 Q78.1
N35432750: length 2.1
  TOP w0.102: v1(26.06,86.23) 26.26,86.03 R934.1 26.71,85.23 26.74,85.27 Q75.1
N35432775: length 1.4
  TOP w0.102: Q74.3 33.45,85.93 D59.1
N35432783: length 7.8
  TOP w0.102: R932.2 36.37,85.61 v1(36.12,85.36) 35.43,84.67 34.99,84.67 D62.2 D59.2 33.45,84.63 Q74.1 32.17,84.25 Q321.3
N35432801: length 3.7
  TOP w0.102: v1(27.02,83.41) 28.23,84.62 Q75.2 29.09,84.63 Q74.6
N38414754: length 3.5
  BOTTOM w0.102: U45.7 296.02,65.34 295.71,65.65 295.3,65.65 294.99,65.95 R747.1 294.99,67.23 v1(294.58,67.65)
N38606908: length 4.1
  TOP w0.102: v1(22.34,165.6) 21.97,165.96 21.97,166.33 R783.1
  TOP w0.254: U48.7 20.29,165.28 20.67,165.67 21.18,165.67 21.61,166.1 R783.1
N38645812: length 3.3
  BOTTOM w0.102: U625.7 273.31,75.74 273.68,76.11 274.32,76.11 R1207.2 v1(274.72,77.6)
N38645839: length 2.3
  BOTTOM w0.102: U625.24 268.43,75.74 v1(267.78,76.38) 266.88,76.38 R2200.2
N39801641: length 3.5
  TOP w0.102: v1(47.34,134.57) 47.15,134.38 R1971.2 46.19,134.39 JMXM1.57
N39900137: length 3.4
  TOP w0.102: v1(40.58,146.62) 41.01,147.05 R1972.1 41.94,146.62 JMXM1.40
N48118603: length 3.9
  BOTTOM w0.102: R941.1 293.53,104.31 293.79,104.56 v1(293.79,104.9) 293.79,105.42 293.62,105.59 Q318.6
N48711348: length 1.4
  TOP w0.102: v1(163.35,167.26) 163.03,166.94 PR534.1
N51290432: length 5.6
  TOP w0.508: PC501.1 198.28,173.58 v2(198.27,173.6)
  BOTTOM w0.508: v2(198.27,173.6) 198.98,173.6 199.67,172.91 200.11,172.91 v1(200.81,172.21) 200.81,171.11 200.72,171.02 PR502.1
N51302473:
  vias: v1(200.8,171.72)
N53085144: length 2.8
  BOTTOM w0.102: v1(144.96,19.33) PC206.2
  BOTTOM w0.508: PC206.2 146.27,20.01 146.02,20.26 PR200.1
N53085275: length 2
  BOTTOM w0.203: PU200.9 152.42,22.06 v1(152.58,21.91)
  BOTTOM w0.254: v1(152.58,21.91) PR205.2
N53105221: length 2.8
  TOP w0.102: Q86.1 R943.1 28.36,82.09 27.85,82.09 v1(27.53,81.78)
N53105229: length 3.4
  TOP w0.102: v1(34.77,80.96) 34.32,81.41 Q321.1 32.49,81.41 Q86.2
N53866851: length 2.3
  BOTTOM w0.102: v1(246.04,54.39) 245.77,54.66 R885.2 245.21,55.99 C747.1
N63746311: length 13.3
  TOP w0.102: v2(231.72,39.56) 231.75,39.59 232.22,39.59 233.32,40.68 234.28,40.68 235.58,41.97 238.13,41.97 238.96,42.81 v2(239.12,42.81)
  BOTTOM w0.102: U51.B2 238.48,42.69 239.01,42.69 239.12,42.81 v2(239.12,42.81) ; R884.1 233.09,41.11 232.92,40.93 231.82,40.93 231.72,40.83 231.72,39.64 ; 231.72,39.64 231.24,40.12 v1(231.16,40.12) ; 231.72,39.64 v2(231.72,39.56)
N63746359: length 19.1
  TOP w0.102: v2(239.72,45.16) 240.22,44.67 241.12,44.67 242.49,43.29 245.13,43.29 245.72,42.7 245.72,41.82 246.94,40.6 246.94,38.47 248.31,37.1 248.31,36.54 249.2,35.65 v2(249.48,35.65)
  BOTTOM w0.102: v2(239.72,45.16) 239.22,45.67 U51.B8 ; v1(249.78,33.91) 249.48,34.21 249.48,34.29 R1984.1 v2(249.48,35.65)
N66037766: length 7.7
  BOTTOM w0.102: JLOM1.11 60.55,164.84 60.55,163.64 63.73,160.47 v1(64.49,160.47) R1167.2
N66058065: length 4.7
  BOTTOM w0.102: JLOM1.10 v1(65.06,162.64) 65.68,162.02 R1170.2
N66078140: length 5.1
  BOTTOM w0.102: R1171.2 44.88,162.57 v1(45.59,163.28) 47.16,164.85 JLOM1.13
N72304780: length 4.1
  BOTTOM w0.076: UH1.AY1 67.77,74.68 67.34,75.12 67.05,75.12 66.75,75.42
  BOTTOM w0.102: 66.75,75.42 66.28,75.88 65.66,75.88 T126.1
N75612423: length 12.9
  TOP w0.102: v2(96.37,166.33) 96.9,165.81 v1(96.9,163.16) 96.9,162.32 96.52,161.94 96.52,159.49 96.7,159.31 97.78,159.31 98.25,158.84 98.25,157.26 97.74,156.75 JLVDS1.3
  BOTTOM w0.102: R207.1 96.6,166.56 v2(96.37,166.33)
N75638681: length 4.5
  TOP w0.102: R208.2 129.49,152.55 v1(129.49,153.54) JEDP1.3
N83636251: length 6.8
  BOTTOM w0.102: Q110.3 70.09,113.16 R1537.2 v1(72.03,113.4) 72.26,113.4 73,112.66 Q113.2 Q113.5
N83636400: length 2.9
  BOTTOM w0.102: v1(73.95,113.39) 73.65,113.08 Q113.3 73.88,112.14 R1530.2
N83636442: length 2.2
  BOTTOM w0.102: v1(72.35,109.22) Q113.6 72.21,110.38 R1539.2
N85751870:
  vias: v1(41.39,61.07)
N85751893: length 1.3
  TOP w0.102: PC309.1 v1(44.76,51.83)
N90453832: length 2.7
  BOTTOM w0.102: U23.2 127.39,146.9 v1(128.27,147.78) 128.51,148.02 R100.2
N90453843: length 2.9
  BOTTOM w0.102: U23.12 127.27,142.9 v1(128.17,142) 128.88,141.29 R101.2
N94639990: length 3.6
  BOTTOM w0.102: D68.2 100.87,167.12 102.5,167.12 103.15,167.76 U3.4
N97449521: length 2.3
  TOP w0.102: v1(285.96,90.81) 285.95,90.79 Q84.6 285.74,89.52 R956.1
N97693171: length 2
  TOP w0.102: Q335.3 21.07,148.83 21.5,148.4 v1(21.56,148.4) R2157.2
N97693199: length 4.3
  TOP w0.102: Q336.6 17.23,150.9 17.37,150.76 17.68,150.76 17.88,150.97 Q336.5 R2152.2 17.37,152.77 v1(17.37,154.08)
N97693213: length 3.2
  TOP w0.102: Q335.6 19.77,152.02 R2151.2 19.06,152.74 v1(19.06,154.05)
N101024778: length 2.4
  TOP w0.102: v1(19.79,144.22) 19.55,144.46 Q337.3 20.16,145.16 R2159.2
N101024804: length 2.4
  TOP w0.102: v1(17.98,148.06) 18.25,147.79 Q337.6 17.73,146.55 R2154.2
N101696144: length 2.3
  TOP w0.102: v1(1.2,141.42) PR30.1 PQ323.1
N101696146: length 6.1
  TOP w0.102: PR31.1 1.89,138.43 PQ323.2 ; PR31.1 PR29.2 3.22,136.72 PU2.1 ; PR31.1 3.47,137.35 v1(4.29,138.18)
N101696169: length 16.9
  TOP w0.102: v2(8.33,138.95) v1(8.33,138.34) 8.33,134.43 7.75,133.85 5.09,133.85 PU2.3 5.01,134.43 5.79,134.43 5.94,134.58 5.94,135.67 5.56,136.06 3.55,136.06 3.48,135.98 2.54,135.98 PR29.1
  BOTTOM w0.102: PR28.2 PC19.1 8.18,138.8 v2(8.33,138.95)
N101696187: length 4.8
  TOP w0.102: PU2.2 PC20.1 PR26.1 PR27.2 v1(2.97,132.39)
N101982336: length 2.8
  BOTTOM w0.305: PR25.2 9.88,136.16 9.6,135.88 8.38,135.88 PR24.1
N101986272: length 3.8
  BOTTOM w0.102: PR14.1 v1(8.18,134.1)
  BOTTOM w0.305: PR25.3 9.88,135.22 9.63,135.47 8.46,135.47 PR14.1
N106386290: length 2.2
  BOTTOM w0.102: CE1.1 RE1.2 v1(98.53,65.72)
N106390602: length 2.2
  BOTTOM w0.102: CE2.1 RE2.2 v1(99.43,58.48)
N109035766: length 2.4
  BOTTOM w0.102: v1(284.85,60.08) R2190.2 285.96,60.1 Q340.3
N109035794: length 4.2
  BOTTOM w0.102: R2192.2 288.66,64.63 v1(288.3,64.99) ; R2192.2 289.8,64.16 Q339.6 ; R2192.2 289.15,64.45 Q339.5
N109035808: length 2.5
  BOTTOM w0.102: v1(286.14,64.63) R2191.2 287.26,64.62 Q340.6
N110700389: length 4.2
  BOTTOM w0.102: v1(272.13,80.47) R2201.2 271.61,78.87 U625.5
N111303347: length 18
  TOP w0.102: RC54.2 203.22,132.65 205.08,134.51 v1(205.08,136.73) 205.08,139.97 204.73,140.32 204.73,143.75 205.51,144.53 205.51,146.49 205.92,146.9 206.5,146.9 RC10.2
N111311136: length 5.4
  TOP w0.089: v2(184.06,110.31) 183.59,110.78 JCPU1.AC7
  BOTTOM w0.102: T60.1 183.59,114.82 183.59,110.78 v2(184.06,110.31)
N111311586: length 6.1
  TOP w0.089: JCPU1.AG8 187.59,111.78 v2(188.06,111.31)
  BOTTOM w0.089: 188.49,114.62 188.49,111.93 188.06,111.49 v2(188.06,111.31)
  BOTTOM w0.102: 188.49,114.62 188.49,115.38 189.18,116.07 T64.1
N111316295: length 2.4
  TOP w0.254: JCPU1.R27 v2(176.06,131.31)
  BOTTOM w0.102: v2(176.06,131.31) 175.57,130.82 174.76,130.82 T69.1
N111321501: length 5.9
  TOP w0.089: 197.84,103.82 196.61,103.82 JCPU1.AR1
  TOP w0.102: T99.1 199.24,103.82 197.84,103.82
N111321503: length 7
  TOP w0.089: v2(161.06,106.31) 161.52,105.84 JCPU1.A2
  BOTTOM w0.089: 160.95,101.28 160.95,106.19 v2(161.06,106.31)
  BOTTOM w0.102: 160.95,101.28 160.95,100.61 T100.1
N111321505: length 14.2
  TOP w0.089: v2(170.06,110.31) 170.53,109.84 JCPU1.K6
  BOTTOM w0.089: 165.66,101.28 165.66,108.45 165.92,108.71 168.21,108.71 168.6,109.11 168.6,109.56 168.83,109.79 169.54,109.79 v2(170.06,110.31)
  BOTTOM w0.102: 165.66,101.28 165.66,100.47 T94.1
N111321507: length 11.6
  TOP w0.089: v2(166.06,109.31) 166.53,108.84 JCPU1.F5
  BOTTOM w0.089: v2(166.06,109.31) 165.71,109.31 165.33,108.93 165.1,108.93 164.67,108.5 164.67,106.64 164.55,106.53 164.55,105.99 164.67,105.88 164.67,105.27 162.36,102.96 162.36,101.28
  BOTTOM w0.102: T93.1 162.36,100.44 162.36,101.28
N111321509: length 14.6
  TOP w0.089: JCPU1.AM2 192.59,105.78 v2(193.06,105.31)
  BOTTOM w0.102: T95.1 194.77,98.49 193.47,99.78 193.47,104.9 v2(193.06,105.31)
N111321511: length 7.3
  TOP w0.102: T82.1 156.92,139.38 162.91,139.38 163.46,138.84 JCPU1.C35
N111321513: length 7.9
  TOP w0.102: T81.1 156.69,136.79 159.58,136.79 161.15,138.37 162.15,138.37 162.59,138.8 JCPU1.B35
N111321515: length 5
  TOP w0.102: T73.1 158.57,135.5 160.91,137.84 JCPU1.A34
N111321517: length 4.6
  TOP w0.102: T74.1 159.85,137.35 161.34,138.84 JCPU1.A35
N111321521: length 4
  TOP w0.089: JCPU1.AT2 196.7,105.73 197.84,105.73
  TOP w0.102: T71.1 197.84,105.73
N111321546: length 8.2
  TOP w0.102: v2(165.06,124.31) 165.53,123.84 JCPU1.E20
  BOTTOM w0.102: T101.1 160.82,122.87 164.31,122.87 164.57,123.13 164.57,123.82 v2(165.06,124.31)
N111321548: length 12.8
  TOP w0.102: JCPU1.E21 165.53,124.84 v2(165.06,125.31)
  BOTTOM w0.102: T102.1 157.58,119.58 157.58,120.21 160.63,123.25 160.63,124.47 160.98,124.83 164.58,124.83 v2(165.06,125.31)
N111321550: length 11.2
  TOP w0.102: v2(167.03,121.32) 166.11,121.32 JCPU1.E18
  BOTTOM w0.102: T96.1 160.59,121.78 166.58,121.78 v2(167.03,121.32)
N111321552: length 5.4
  TOP w0.102: JCPU1.D23 164.59,126.86 v2(165.05,127.32)
  BOTTOM w0.102: T88.1 168.95,128.8 168.27,128.13 166.17,128.13 165.35,127.32 v2(165.05,127.32)
N111321596: length 7.9
  TOP w0.089: v2(180.06,134.31) JCPU1.W30
  BOTTOM w0.102: T84.1 175.8,129.85 176.3,129.85 176.53,130.07 176.53,130.28 176.99,130.74 176.99,130.75 177.09,130.75 177.47,131.13 177.47,132.4 177.95,132.88 178.38,132.88 179.81,134.31 v2(180.06,134.31)
N111321598: length 7.9
  TOP w0.089: v2(180.06,135.31) 179.59,134.84 JCPU1.W31
  BOTTOM w0.102: v2(180.06,135.31) 180.06,134.99 180.47,134.58 180.47,134.1 180.16,133.8 179.83,133.8 178.48,132.45 178.48,131.13 178.15,130.8 177.85,130.8 177.52,130.47 T83.1
N111321602: length 3.5
  TOP w0.089: v2(180.06,133.31) JCPU1.W29
  BOTTOM w0.102: T75.1 180.47,130.7 180.47,132.9 v2(180.06,133.31)
N111321604: length 3.5
  TOP w0.089: v2(180.04,132.31) 179.59,131.87 JCPU1.W28
  BOTTOM w0.102: v2(180.04,132.31) 179.55,131.83 179.55,129.76 T76.1
N111321610: length 3.4
  TOP w0.089: v2(174.06,113.31) JCPU1.P10
  BOTTOM w0.102: v2(174.06,113.31) 174.47,113.72 T97.1
N111321612: length 2.5
  TOP w0.089: v2(177.06,113.31) JCPU1.U10
  BOTTOM w0.102: v2(177.06,113.31) 177.54,113.79 T98.1
N111321642: length 2.9
  TOP w0.102: v2(192.06,129.31) JCPU1.AL25
  BOTTOM w0.102: v2(192.06,129.31) 191.95,129.2 191.95,128.78 191.5,128.33 T85.1
N111321646: length 4.1
  TOP w0.089: 197.84,104.84 JCPU1.AT1
  TOP w0.102: 197.84,104.84 200.01,104.84 T70.1
N111321650: length 8.7
  TOP w0.102: JCPU1.AM26 192.59,129.78 v2(193.06,129.31)
  BOTTOM w0.102: T89.1 192.8,123.17 193.52,123.89 193.52,128.84 193.06,129.3 v2(193.06,129.31)
N111321654: length 12.9
  TOP w0.102: JCPU1.AR33 v2(196.06,137.31)
  BOTTOM w0.102: T91.1 202.02,146.28 196.52,140.78 196.52,137.77 v2(196.06,137.31)
N111321656: length 12.8
  TOP w0.102: v2(193.06,130.31) 192.59,130.78 JCPU1.AM27
  BOTTOM w0.089: 193.36,121.86 193.33,121.83 192.63,121.83
  BOTTOM w0.102: T92.1 192.63,121.83 ; 193.36,121.86 193.58,122.09 193.58,123.19 194.59,124.19 194.59,129.53 194.28,129.83 193.42,129.83 193.06,130.19 v2(193.06,130.31)
N111321658: length 6.6
  TOP w0.109: v2(162.06,127.31) 162.53,126.84 JCPU1.B23
  BOTTOM w0.102: v2(162.06,127.31) 162.06,127.23 160.17,125.34 160.17,123.77 T78.1
N111321660: length 10.8
  TOP w0.109: JCPU1.C23 163.53,126.84 v2(163.06,127.31)
  BOTTOM w0.102: v2(163.06,127.31) 162.56,126.81 161.92,126.81 160.37,125.26 160.37,123.51 157.07,120.21 T86.1
N111321662: length 5
  TOP w0.102: v2(164.06,127.32) 164.58,127.84 JCPU1.D24
  BOTTOM w0.102: v2(164.06,127.32) 164.44,127.7 165.4,127.7 166.17,128.46 T87.1
N111321667: length 6.9
  TOP w0.102: v2(192.06,134.31) JCPU1.AL30
  BOTTOM w0.102: v2(192.06,134.31) JCPU1.AL30 191.59,130.24 191.21,129.86 190.92,129.86 190.59,129.53 T79.1
N111321671: length 2.5
  TOP w0.102: v2(185.06,113.31) 184.59,113.78 JCPU1.AD10
  BOTTOM w0.089: v2(185.06,113.31) 185.57,113.82 185.57,114.62
  BOTTOM w0.102: 185.57,114.62 185.57,114.88 T72.1
N111327495: length 1.6
  TOP w0.102: JCPU1.V27 v2(179.06,131.31)
  BOTTOM w0.102: T113.1 178.54,130.79 v2(179.06,131.31)
N111327958: length 7.4
  TOP w0.254: v2(192.06,131.31) JCPU1.AL27
  BOTTOM w0.102: v2(192.06,131.31) 192.45,130.91 192.45,126.15 192.23,125.92 191.25,125.92 T151.1
N111328255: length 1.5
  TOP w0.254: v2(191.06,131.31) JCPU1.AK27
  BOTTOM w0.102: T152.1 190.65,130.9 v2(191.06,131.31)
N111328259: length 1.6
  TOP w0.102: JCPU1.AL13 191.5,116.84 v2(191.06,117.27)
  BOTTOM w0.102: T154.1 190.67,117.67 v2(191.06,117.27)
N111329001: length 1.5
  TOP w0.109: JCPU1.L27 171.59,130.89 v2(172.01,131.31)
  BOTTOM w0.102: v2(172.01,131.31) 171.68,130.98 T77.1
N111329005: length 1.4
  TOP w0.102: JCPU1.K27 v2(170.06,130.31)
  BOTTOM w0.102: T110.1 170.06,130.3 v2(170.06,130.31)
N111329010: length 1.6
  TOP w0.254: JCPU1.T27 v2(177.06,131.31)
  BOTTOM w0.254: v2(177.06,131.31) 176.99,131.31 176.43,130.75 T112.1
N111329086: length 9.2
  TOP w0.102: v2(166.01,120.31) 165.59,120.73 JCPU1.E17
  BOTTOM w0.102: T153.1 158.9,118.78 160.91,120.79 165.53,120.79 v2(166.01,120.31)
N111329153: length 8.1
  TOP w0.089: v2(180.06,136.31) JCPU1.W32
  BOTTOM w0.102: T160.1 181.19,129.78 180.75,130.22 180.75,130.85 180.67,130.92 180.67,135.12 180.59,135.19 180.59,135.67 180.06,136.21 v2(180.06,136.31)
N111329155: length 1.9
  TOP w0.102: JCPU1.AL16 v2(192.06,120.31)
  BOTTOM w0.102: T159.1 191.91,120.46 v2(192.06,120.31)
N111329157: length 2.4
  TOP w0.305: JCPU1.N26 v2(174.06,130.31)
  BOTTOM w0.254: v2(174.06,130.31) 174.06,130.13 174.58,129.61 174.58,128.85 T115.1
N111337107: length 9.3
  TOP w0.102: JCPU1.AK33 190.59,136.9 v2(191.05,137.36)
  BOTTOM w0.102: T114.1 190.21,129.77 190.4,129.96 190.4,130.47 190.28,130.58 190.28,130.96 190.47,131.14 190.47,131.15 190.57,131.26 190.57,136.87 191.05,137.34 v2(191.05,137.36)
N111857606: length 10.5
  TOP w0.102: v2(192.06,133.31) JCPU1.AL29
  BOTTOM w0.102: v2(192.06,133.31) 192.06,133.3 192.51,132.85 192.51,131.38 192.66,131.23 192.66,126.05 192.33,125.72 191.79,125.72 191.46,125.39 T80.1
N112476334: length 3.1
  BOTTOM w0.102: JMINI2.49 133.09,169.93 R709.2 v1(132.18,170.04)
N112888653: length 2.2
  TOP w0.102: QC2.3 v1(205.56,109.9) 204.76,109.9 RC101.2
N113400507: length 2.4
  TOP w0.102: U44.7 7.99,148.92 8.66,148.25 8.66,147.87 C25.2
N113732785: length 3.3
  TOP w0.102: v1(175.23,46.47) 174.81,46.89 173.81,46.89 173.54,46.62 RC109.1
  TOP w0.508: RC109.1 CD89.2
N113732859: length 2.4
  TOP w0.102: RC110.1 CD90.2 v1(142.28,83.63)
N113734132: length 2.1
  TOP w0.102: v1(166.98,46.32) RC111.1 CD91.2
N113763540: length 1.9
  BOTTOM w0.102: U54.4 102.67,163.92 102.14,163.92 D65.2
N114165968: length 3.2
  BOTTOM w0.254: U29.11 31.89,92.28 31.68,92.49 v1(31.19,92.49) 31.04,92.65 R406.1 R411.1
N114165997: length 5.4
  BOTTOM w0.102: R404.1 29.75,95.83 28.46,95.83 v1(28.33,95.96)
  BOTTOM w0.254: U29.14 31.46,93.78 30.83,94.4 30.83,95.09 30.61,95.31 R404.1
N114593136: length 6.6
  BOTTOM w0.076: UH1.AA2 68.14,67.04 67.31,67.04 66.45,67.91 66.42,67.91
  BOTTOM w0.102: RH147.1 v1(63.49,67.5) 63.89,67.91 66.42,67.91
N115869863: length 3.2
  BOTTOM w0.102: R1630.2 57.2,59.65 v1(56.73,60.12) ; R1630.2 C290.1 ; R1630.2 57.45,58.87 U18.1
N115914252: length 5.2
  TOP w0.102: JCPU1.AT35 197.24,138.84 200.15,141.75 T157.1
N115914254: length 7.6
  TOP w0.102: T158.1 200.66,143.19 197.79,140.33 197.79,140.32 197.21,139.74 196.49,139.74 JCPU1.AR35

## Copper pours and planes (outline as drawn)
1.5VSP_LX on BOTTOM (solid shape): 105.5,30.06 105.5,27.61 105.26,27.37 105.26,26.23 104.24,25.21 100.81,25.21 100.56,25.46 100.56,26.09 99.97,26.67 98.8,26.67 98.69,26.78 98.69,27.65 98.79,27.75 103.8,27.75 104.6,28.55 104.6,30.1 104.68,30.19 105.37,30.19
1.5VSP_VIN on BOTTOM (solid shape): 111.06,33.3 111.06,33.29 111.13,33.2 111.23,33.12 111.24,33.12 111.39,32.97 111.39,32.16 111.3,32.06 110.85,32.06 110.85,31.56 110.55,31.56 110.55,32.06 110.05,32.06 110.05,31.56 109.75,31.56 109.75,32.06 109.17,32.06 109.14,32.09 106.61,32.09 106.49,32.22 104.73,32.22 104.66,32.3 104.66,32.87 106.23,34.44 109.92,34.44
1.35V_B+ on BOTTOM (solid shape): 139.67,26.48 140.56,26.48 140.56,27.12 140.94,27.12 140.94,26.48 141.83,26.48 141.83,27.12 142.09,27.12 142.09,26.48 144.25,26.48 144.5,26.23 144.5,23.94 143.99,23.43 138.91,23.43 138.15,22.67 133.96,22.67 133.58,23.05 133.58,27.12 134.09,27.62 138.53,27.62
3V_5V_EN on BOTTOM (solid shape): 28.93,42.99 28.93,41.21 29.18,40.96 29.82,40.96 30.07,40.7 30.07,39.54 29.86,39.32 29.86,38.58 29.82,38.55 28.93,38.55 28.68,38.8 28.68,40.3 27.79,41.19 27.79,42.99 28.04,43.24 28.68,43.24
+0.9V_LAN on BOTTOM (solid shape): 111.48,88.08 111.48,86.68 111.35,86.55 108.61,86.55 108.59,86.58 108.28,86.77 107.96,86.58 107.95,86.55 106.65,86.55 106.4,86.81 106.4,87.44 107.14,88.18 111.38,88.18
+0.9V_LAN on IN2 (solid shape): outline of 823 points within 108.69,86.81 116.43,96.84
+0.675V_DDR_VTT on TOP (solid shape): outline of 488 points within 118.97,61.49 126.59,75.5
+0.675V_DDR_VTT on BOTTOM (solid shape): outline of 209 points within 116.43,29.4 148.18,59.25
+0.675V_DDR_VTT on IN2 (solid shape): outline of 916 points within 118.46,50.1 125.7,74.99
+0.675V_P on BOTTOM (solid shape): 147.7,29.81 147.7,29.3 147.73,29.27 148.06,29.27 148.21,29.12 148.21,25.24 148.49,24.96 149.5,24.96 149.68,24.78 149.68,23.64 149.6,23.56 149.58,23.56 149.48,23.66 149.48,24.45 149.25,24.68 148.28,24.68 148.18,24.58 148.18,23.58 148.36,23.41 148.82,23.41 148.87,23.36 148.87,23.22 148.8,23.15 148.03,23.15 147.95,23.23 147.95,23.33 146.84,24.45 146.66,24.45 146.4,24.7 146.4,28.89 146.79,29.27 147.47,29.27 147.5,29.3 147.5,29.81 147.52,29.83 147.67,29.83
+1.05V_M on TOP (solid shape): 85.77,81.85 85.77,80.96 85.39,80.57 85.32,80.55 85.25,80.57 84.94,80.65 84.69,80.46 84.63,80.46 84.61,80.48 84,80.48 84,79.87 84.06,79.81 84,79.74 83.88,79.35 84.14,79.04 84.17,79.02 84.17,77.92 84.17,77.91 84.17,77.8 83.23,76.86 82.39,76.86 82.33,76.92 82.33,77.79 82.02,77.79 82.02,78.4 83.19,79.56 83.19,82.08 83.64,82.53 85.1,82.53
+1.05V_M on BOTTOM (solid shape): outline of 87 points within 48.23,52.12 56.76,56.45
+1.05V_M on IN2 (solid shape): outline of 199 points within 84.05,65.47 90.65,81.98
+1.05V_M on IN2 (solid shape): outline of 1692 points within 55.09,52.64 76.05,66.48
+1.05V_M on IN3 (solid shape): outline of 1350 points within 74.9,62.42 91.03,68.77
+1.05V_MP on BOTTOM (solid shape): outline of 278 points within 40.87,48.71 56.94,59.63
+1.5V_RUN on TOP (solid shape): 48.36,91.89 48.23,91.76 47.47,91.76 47.34,91.89 47.34,93.66 47.73,94.04 48.36,94.04
+1.5V_RUN on TOP (solid shape): 82.4,97.98 82.4,97.22 82.27,97.09 80.11,97.09 79.98,97.22 79.98,97.98 80.24,98.24 82.14,98.24
+1.5V_RUN on TOP (solid shape): 24.36,82.74 24.36,82.23 23.11,80.99 22.96,80.84 22.96,80.33 22.83,80.2 21.94,80.2 21.56,79.82 18.52,79.82 18.49,79.85 18.26,80.07 18.26,80.71 18.52,80.96 20.29,80.96 20.93,81.6 21.59,81.6 23.37,83.38 23.72,83.38
+1.05V_RUN on TOP (solid shape): outline of 202 points within 43.1,61.53 48.11,75.5
+1.05V_RUN on TOP (solid shape): outline of 341 points within 74.26,70.66 77.42,77.2
+1.5V_RUN on TOP (solid shape): outline of 606 points within 69.19,75.88 77.19,84.47
+1.05V_RUN on BOTTOM (solid shape): 50.52,66.1 50.52,62.68 51.58,61.62 51.62,61.56 51.66,61.51 51.66,59.5 51.41,59.25 47.22,59.25 45.69,60.77 45.69,65.47 46.71,66.49 50.14,66.49
+1.05V_RUN on BOTTOM (solid shape): 47.98,84.52 47.98,84.39 47.85,84.27 47.48,84.27 47.27,84.33 47.06,84.27 46.33,84.27 46.2,84.39 46.2,85.15 46.33,85.28 47.22,85.28
+1.05V_RUN on BOTTOM (solid shape): 80.13,66.53 80.21,66.53 80.44,66.3 80.46,66.3 80.46,66.19 80.41,66.14 80.36,66.07 80.32,66.03 80.32,65.87 80.36,65.83 80.39,65.77 80.43,65.73 80.45,65.71 80.45,65.53 80.32,65.39 80.15,65.39 79.9,65.14 79.77,65.14 79.12,65.8 78.97,65.8 78.87,65.9 78.87,66.01 78.97,66.11 79.7,66.11 79.84,66.25 79.84,66.39 79.67,66.56 79.67,66.67 79.76,66.76 79.9,66.76
+1.05V_RUN on BOTTOM (solid shape): 78.36,68.66 78.36,68.55 78.18,68.37 78.18,68.19 78.39,67.98 78.39,67.83 78.29,67.6 78.39,67.37 78.39,66.47 78.3,66.38 78.05,66.38 77.7,66.73 77.7,66.74 76.86,67.58 76.86,67.58 76.7,67.73 75.67,67.73 75.64,67.76 75.54,67.86 75.41,67.92 75.4,67.92 75.19,68.13 75.12,68.19 75.03,68.23 75.02,68.23 74.71,68.54 74.71,69.36 74.87,69.52 77.49,69.52
+1.5V_RUN on BOTTOM (solid shape): outline of 396 points within 92.56,18.91 99.84,51.75
+1.5V_RUN on IN1 (solid shape): 26.01,129.48 26.01,127.06 25.75,126.81 23.85,126.81 23.34,127.32 23.34,129.35 23.85,129.86 25.63,129.86
+1.5V_RUN on IN1 (solid shape): outline of 626 points within 11.66,144.84 28.29,148.65
+1.5V_RUN on IN2 (solid shape): 48.36,93.03 48.36,91.89 48.11,91.63 45.82,91.63 45.31,92.14 45.31,93.41 47.98,93.41
+1.5V_RUN on IN2 (solid shape): 25.37,83.5 23.98,82.11 23.85,82.11 23.21,82.74 23.21,83.76 23.72,84.27 24.74,84.27 24.99,84.52 25.37,84.52
+1.5V_RUN on IN2 (solid shape): outline of 971 points within 70.84,61.28 100.56,89.73
+1.5V_RUN on IN2 (solid shape): outline of 3104 points within 71.98,69.15 86.59,80.07
+1.5V_RUN on IN4 (solid shape): 26.01,129.48 26.01,127.06 25.75,126.81 23.85,126.81 23.34,127.32 23.34,129.35 23.85,129.86 25.63,129.86
+1.5V_RUN on IN4 (solid shape): 82.78,99 82.78,97.09 82.4,96.71 82.4,89.47 81.38,88.46 79.6,88.46 79.35,88.71 79.35,90.87 80.36,91.89 80.36,100.52 81.25,100.52
+1.5V_RUN on IN4 (solid shape): outline of 145 points within 90.91,50.23 98.02,63.36
+1.05V_RUN on IN4 (solid shape): outline of 633 points within 44.04,74.16 49.25,85.63
+1.05V_RUN on VCC: 54.94,37.91 46.43,46.42 41.35,46.42 39.98,47.79 39.98,70.3 39.98,70.95 43.03,74 43.03,84.54 44.27,85.79 49.38,85.79 49.38,84.54 49.38,74 49.38,53.55 55.22,47.71 55.22,46.31 58.29,43.24 60.02,43.24 65.38,48.6 65.38,80.58 86.35,80.58 90.27,76.67 90.27,48.6 90.27,39.94 79.12,39.94 77.08,37.91
+1.5V_RUNP on BOTTOM (solid shape): 106.88,23.95 106.88,20.63 106.48,20.23 101.44,20.23 101.3,20.09 101.3,19.33 100.7,18.74 99.49,18.74 99.42,18.82 99.43,18.83 99.43,19.33 99.97,19.33 99.97,19.88 99.43,19.88 99.43,20.13 99.97,20.13 99.97,20.68 99.42,20.68 99.42,20.68 99.42,22.77 99.86,23.21 99.86,24.19 100.41,24.73 104.62,24.73 106.09,24.73
+1.05VSP_B+ on TOP (solid shape): 34.01,57.85 35.91,57.85 36.55,58.48 38.71,58.48 38.96,58.23 38.96,55.06 38.58,54.67 34.01,54.67 33.76,54.93 33.76,55.06 31.93,56.88 31.88,56.88 31.88,57.21 31.9,57.24 32.41,57.24 32.43,57.26 32.43,57.75 32.41,57.77 31.9,57.77 31.88,57.8 31.88,58.03 31.9,58.05 32.41,58.05 32.43,58.08 32.43,58.53 32.41,58.56 31.9,58.56 31.88,58.59 31.88,58.89 32.1,59.12 32.74,59.12
+1.35V_MEM on TOP (solid shape): 165.45,62.55 165.45,59.5 165.2,59.25 150.09,59.25 149.96,59.37 149.96,62.55 150.21,62.8 165.2,62.8
+1.35V_MEM on TOP (solid shape): outline of 355 points within 148.56,73.47 181.08,98.64
+1.35V_MEM on TOP (solid shape): outline of 967 points within 120.88,23.69 166.34,48.58
+1.35V_MEM on TOP (solid shape): outline of 993 points within 167.69,114.15 189.98,118.3
+1.35V_MEM on BOTTOM (solid shape): 166.22,62.55 166.22,59.63 165.84,59.25 150.21,59.25 149.96,59.5 149.96,62.68 150.09,62.8 165.96,62.8
