# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 149.58,61.02 149.58,59.5 149.33,59.25 128.62,59.25 128.37,59.5 128.37,60.5 148.49,60.5 148.49,60.45 148.5,60.4 148.51,60.34 148.53,60.3 148.56,60.25 148.6,60.21 148.64,60.18 148.69,60.15 148.74,60.13 148.79,60.12 148.84,60.12 148.9,60.12 148.95,60.13 149,60.15 149.04,60.18 149.09,60.21 149.12,60.25 149.15,60.3 149.17,60.34 149.19,60.4 149.2,60.45 149.2,60.5 149.19,60.55 149.17,60.61 149.15,60.65 149.12,60.7 149.09,60.74 149.04,60.77 149,60.8 148.95,60.82 148.9,60.83 148.84,60.83 148.79,60.83 148.74,60.82 148.69,60.8 148.64,60.77 148.6,60.74 148.56,60.7 148.53,60.65 148.51,60.61 148.5,60.55 148.49,60.5 128.37,60.5 128.37,62.55 128.62,62.8 147.8,62.8
GND on TOP (solid shape): 299.74,169.7 298.79,167.4 296.49,166.45 293.19,166.45 293.19,172.7 293.48,173.41 294.19,173.7 299.74,173.7
GND on TOP (solid shape): 21.19,100.23 21.19,99.92 21.08,99.8 20.31,99.8 20.22,99.71 18.66,99.71 18.54,99.6 18.53,99.59 18.33,99.41 18.35,99.15 18.37,99.12 18.3,99.05 18.14,99.05 18.12,99.02 18.1,99.03 17.91,99 17.77,98.88 15.19,98.88 14.95,99.11 13.32,99.11 13.2,99.23 13.2,99.37 13.34,99.51 17.82,99.51 18.16,99.62 18.25,99.96 18.27,100.05 18.35,100.09 20.13,100.09 20.37,100.32 21.1,100.32
GND on TOP (solid shape): outline of 85 points within 13.23,102.5 18.93,106.88
GND on TOP (solid shape): outline of 100 points within 163.93,159.32 206.09,176.09
GND on TOP (solid shape): outline of 119 points within 0.28,113.65 13.17,122.78
GND on TOP (solid shape): 32.95,169 33.03,168.96 33.2,168.82 33.42,168.76 33.41,168.6 33.44,168.45 33.71,167.82 34.37,167.96 34.45,168 34.53,167.96 34.71,167.82 34.93,167.76 35,167.73 35.03,167.66 35.03,167.55 34.9,167.27 35.03,167 35.03,166.68 34.9,166.41 35.03,166.14 35.03,165.54 34.98,165.5 33.43,165.5 33.43,166.21 32.9,166.21 32.9,166.48 31.74,167.63 31.74,167.66 31.78,167.74 31.86,167.76 32.37,167.95 32.45,168.48 32.47,168.62 32.46,168.76 32.47,168.76 32.69,168.81 32.87,168.96
GND on TOP (solid shape): 29.95,169 30.03,168.96 30.2,168.82 30.42,168.76 30.41,168.6 30.44,168.45 30.55,167.94 31.05,167.76 31.13,167.74 31.17,167.66 31.17,167.4 31.63,166.94 31.63,165.6 31.52,165.5 29.87,165.5 29.87,166.13 30.04,166.37 29.97,166.65 29.97,166.84 29.94,166.87 29.91,166.94 29.94,167.02 29.84,167.6 29.34,167.28 29.33,167.23 29.27,167.23 28.77,166.73 28.77,166.21 28.24,166.21 28.24,165.5 26.36,165.5 26.36,165.63 26.31,165.67 26.31,166.94 26.65,167.28 28.38,167.28 28.74,167.64 28.74,167.66 28.78,167.74 28.86,167.76 29.37,167.95 29.45,168.48 29.47,168.62 29.46,168.76 29.47,168.76 29.69,168.81 29.87,168.96
GND on TOP (solid shape): outline of 119 points within 13.19,93.63 21.14,98.28
GND on TOP (solid shape): outline of 313 points within 78.91,155.61 95.23,162.28
GND on TOP (solid shape): outline of 322 points within 100.5,151.23 121.91,163.84
GND on TOP (solid shape): outline of 371 points within 9.75,56.58 22.96,79.72
GND on TOP (solid shape): outline of 883 points within 167.62,117.73 191.19,126.05
GND on TOP (solid shape): outline of 3534 points within 0.26,0.26 305.6,178.95
GND on BOTTOM (solid shape): 92.14,174.7 78.63,174.7 78.63,175.2 92.14,175.2
GND on BOTTOM (solid shape): 64.49,55.06 64.24,54.8 62.84,54.8 62.58,55.06 62.58,57.12 64.49,57.12
GND on BOTTOM (solid shape): 39.56,28.11 39.56,25.29 39.28,25 37.43,25 37.01,25.42 37.01,28.09 37.49,28.58 39.1,28.58
GND on BOTTOM (solid shape): 42.14,38.93 42.14,37.78 41,36.64 40.23,36.64 39.98,36.89 39.98,38.78 40.37,39.18 41.88,39.18
GND on BOTTOM (solid shape): 44.25,51.1 44.25,48.76 43.83,48.33 41.17,48.33 40.4,49.1 40.4,51.29 40.83,51.72 43.62,51.72
GND on BOTTOM (solid shape): 44.42,43.92 44.42,40.32 44.17,40.07 42.02,40.07 40.36,41.73 40.36,44.18 40.79,44.6 43.74,44.6
GND on BOTTOM (solid shape): 66.14,157.16 66.14,154.75 65.89,154.5 64.11,154.5 63.85,154.75 63.85,157.16 64.11,157.42 65.89,157.42
GND on BOTTOM (solid shape): 103.73,51.25 103.73,46.55 103.48,46.29 98.78,46.29 98.53,46.55 98.53,50.2 99.83,51.5 103.48,51.5
GND on BOTTOM (solid shape): 105.96,19.91 105.96,19.18 105.81,19.04 101.63,19.04 101.49,19.18 101.49,20.04 101.52,20.07 105.8,20.07
GND on BOTTOM (solid shape): 109.14,26.67 109.14,25.14 108.73,24.72 106.31,24.72 105.57,25.46 105.57,26.82 105.85,27.1 108.71,27.1
GND on BOTTOM (solid shape): 118.85,66.74 118.85,61.53 118.59,61.28 117.19,61.28 116.94,61.53 116.94,66.74 117.19,66.99 118.59,66.99
GND on BOTTOM (solid shape): 121.77,95.57 121.77,92.65 121.39,92.27 119.1,92.27 118.72,92.65 118.72,95.57 118.97,95.82 121.51,95.82
GND on BOTTOM (solid shape): 284.43,89.86 284.43,88.08 284.11,87.76 280.25,87.76 279.74,88.27 279.74,90.06 280.17,90.48 283.81,90.48
GND on BOTTOM (solid shape): 124.05,139.26 124.05,138.11 123.8,137.86 116.94,137.86 116.81,137.99 116.81,138.75 117.07,139 118.59,139 118.97,139.38 123.93,139.38
GND on BOTTOM (solid shape): 126.47,112.21 126.47,110.81 126.21,110.55 121,110.55 120.75,110.81 120.75,112.21 121,112.46 126.21,112.46
GND on BOTTOM (solid shape): 188.95,62.55 188.95,60.14 189.2,59.88 189.2,59.5 188.95,59.25 167.23,59.25 166.98,59.5 166.98,62.55 167.23,62.8 188.7,62.8
GND on BOTTOM (solid shape): 287.56,54.41 287.56,48.78 287.07,48.29 285.72,48.29 285.6,48.41 285.6,51.97 283.27,54.3 283.27,56.5 283.66,56.89 285.08,56.89
GND on BOTTOM (solid shape): 40.99,65.72 40.99,64.71 40.74,64.45 36.55,64.45 36.42,64.58 36.42,65.34 37.18,66.1 40.61,66.1
GND on BOTTOM (solid shape): 144.25,22.8 144.25,19.62 143.1,18.48 137.39,18.48 137.01,18.86 137.01,21.65 137.26,21.91 137.9,21.91 138.91,22.92 138.91,23.05 143.99,23.05
GND on BOTTOM (solid shape): 288.69,98.63 288.69,95.5 288.68,95.5 288.68,95.01 288.16,94.49 286.09,94.49 285.45,95.13 285.45,98.62 285.74,98.92 288.39,98.92
GND on BOTTOM (solid shape): 62.46,17.72 62.46,14.54 62.08,14.16 59.79,14.16 59.54,14.42 59.54,18.73 59.79,18.99 61.19,18.99
GND on BOTTOM (solid shape): 150.6,27.88 150.6,26.35 150.47,26.23 149.96,26.23 149.83,26.1 149.83,25.21 149.71,25.08 148.69,25.08 148.44,25.34 148.44,28.13 148.69,28.39 150.09,28.39
GND on BOTTOM (solid shape): 203.05,20.26 203.05,18.99 202.79,18.73 195.68,18.73 195.43,18.99 195.43,20.26 195.68,20.51 202.79,20.51
GND on BOTTOM (solid shape): 219.56,25.85 220.45,25.85 220.7,25.59 220.7,23.81 220.45,23.56 216.89,23.56 216.64,23.81 216.64,25.59 216.13,26.1 216.13,26.35 216.25,26.48 218.92,26.48
GND on BOTTOM (solid shape): 272.52,40.58 272.52,39.82 272.64,39.69 274.67,39.69 274.8,39.56 274.8,38.93 274.55,38.67 271.75,38.67 271.5,38.93 271.5,40.45 271.75,40.7 272.39,40.7
GND on BOTTOM (solid shape): 44.68,66.23 44.68,63.69 44.3,63.31 41.88,63.31 41.25,63.95 41.25,65.85 40.99,66.1 40.99,66.49 41.12,66.61 44.3,66.61
GND on BOTTOM (solid shape): 12.67,145.1 12.67,144.27 12.86,144.08 13.51,144.08 15.59,144.08 15.78,143.89 15.78,143.26 15.59,143.07 11.85,143.07 11.66,143.26 11.66,144.91 11.91,145.16 12.61,145.16
GND on BOTTOM (solid shape): 108.47,31.39 108.56,31.35 108.67,31.33 108.69,31.33 108.81,31.2 108.81,29.45 108.52,29.15 107.03,29.15 106.6,29.57 106.6,31.18 106.82,31.39
GND on BOTTOM (solid shape): 34.75,33.02 36.57,33.02 36.66,32.93 36.66,31.92 36.43,31.69 34.94,31.69 34.73,31.48 34.73,30.8 34.52,30.58 33.08,30.58 32.84,30.82 32.84,33 33.01,33.16 34.61,33.16
GND on BOTTOM (solid shape): 76.26,173.38 77.47,172.17 83.19,172.17 84.62,170.74 84.62,165.97 82.07,163.42 69.26,163.42 64.03,168.65 63.65,168.65 63.65,168.62 63.42,168.62 63.15,168.9 63.15,175.2 76.26,175.2
GND on BOTTOM (solid shape): 5.64,141.59 5.64,140.16 5.36,139.88 3.94,139.88 3.65,140.17 3.65,141.23 3.66,141.24 3.67,141.34 3.66,141.44 3.65,141.44 3.65,141.66 3.76,141.77 5.46,141.77
GND on BOTTOM (solid shape): 299.19,64.25 299.19,61.79 299.06,61.66 297.46,61.66 297.38,61.74 297.38,62.5 297.2,62.68 297.08,62.68 296.47,62.68 296.47,62.68 294.61,62.68 294.49,62.8 294.49,64.2 294.74,64.45 298.98,64.45
GND on BOTTOM (solid shape): 149.71,21.35 149.71,19.38 149.6,19.27 149.33,19.27 149.33,19.27 149.18,19.27 149.18,19.27 149.03,19.27 148.97,19.33 148.97,19.6 149.07,19.7 149.07,19.95 149.2,20.08 149.2,20.13 149.45,20.38 149.45,21.34 149.49,21.37 149.68,21.37
GND on BOTTOM (solid shape): 229.34,64.07 229.34,63.06 229.09,62.81 228.68,62.81 228.65,62.81 228.6,62.8 227.18,62.8 226.92,63.06 226.92,63.48 226.93,63.49 226.95,63.61 226.93,63.74 226.92,63.75 226.92,63.95 227.3,64.33 229.08,64.33
GND on BOTTOM (solid shape): 227.04,27.76 227.04,27.71 227.04,26.47 227.05,26.46 227.05,25.85 226.8,25.6 226.02,25.6 225.91,25.72 225.91,26.1 226.54,26.73 226.55,26.93 226.55,27.71 226.54,27.75 226.67,27.88 226.92,27.88
GND on BOTTOM (solid shape): 43.15,165.16 43.15,163.64 41.88,162.37 40.87,162.37 40.61,162.62 40.61,163.01 40.49,163.13 40.49,164.53 40.61,164.66 41.38,164.66 41.4,164.68 41.42,164.68 41.63,164.79 41.73,164.99 41.73,165.01 42.14,165.42 42.9,165.42
GND on BOTTOM (solid shape): 148.18,62.55 148.18,60.9 148.5,60.58 148.5,60.55 148.59,60.22 148.92,60.13 148.95,60.13 149.07,60.01 149.07,59.37 148.94,59.25 128.5,59.25 128.24,59.5 128.24,62.55 128.5,62.8 147.93,62.8
GND on BOTTOM (solid shape): 97.77,156.15 97.77,155.8 97.79,155.78 97.78,155.72 97.78,155.66 97.78,155.38 97.85,155.12 98.05,154.94 98.06,154.94 98.25,154.75 98.25,154.45 98.15,154.35 96.85,154.35 95.89,155.3 95.48,155.3 95.19,155.59 95.19,156.3 95.38,156.49 97.43,156.49
GND on BOTTOM (solid shape): 158.47,170.12 158.47,167.7 158.22,167.45 157.2,167.45 156.69,166.94 156.25,166.94 155.1,166.94 153.26,166.94 153.01,167.2 153.01,167.7 153.26,167.96 153.77,167.96 154,168.19 154.08,168.19 154.08,168.26 154.15,168.34 154.15,169.2 154.15,169.99 154.41,170.24 154.91,170.24 155.01,170.35 155.09,170.35 155.09,170.42 155.17,170.5 155.17,170.88 155.42,171.13 157.45,171.13
GND on BOTTOM (solid shape): 221.08,34.86 221.08,32.83 220.83,32.58 220.06,32.58 219.94,32.7 219.94,33.08 219.68,33.34 219.48,33.34 216.51,33.34 215.75,34.1 214.6,34.1 214.42,34.29 214.39,34.35 214.41,34.42 214.5,34.65 214.43,34.88 214.4,34.91 214.6,35.12 220.83,35.12
GND on BOTTOM (solid shape): 242.67,57.6 242.67,56.96 242.8,56.83 243.81,56.83 244.13,57.15 244.18,57.18 244.22,57.21 245.05,57.21 245.07,57.18 245.1,57.12 245.15,57.06 245.21,57 245.21,56.71 244.96,56.45 244.32,56.45 244.07,56.2 244.07,55.69 244.32,55.44 244.96,55.44 245.21,55.18 245.21,54.8 244.96,54.55 244.45,54.55 243.94,55.06 242.04,55.06 241.65,54.67 240.64,54.67 240.51,54.8 240.51,56.45 240.77,56.71 241.4,56.71 241.65,56.96 241.65,57.47 241.91,57.72 242.54,57.72
GND on BOTTOM (solid shape): 185.65,156.53 186.54,156.53 186.66,156.66 186.66,157.29 186.79,157.42 188.64,157.42 188.64,157.42 191.8,157.42 191.8,157.42 195.17,157.42 196.06,156.53 196.06,153.73 195.81,153.48 192.38,153.48 191.36,152.46 190.09,152.46 189.08,153.48 188.44,153.48 187.55,152.59 187.17,152.59 186.41,153.35 185.9,153.35 185.01,152.46 184.76,152.46 184.5,152.72 184.5,153.1 184.25,153.35 181.2,153.35 180.44,152.59 179.81,152.59 178.92,153.48 178.41,153.48 177.52,152.59 176.88,152.59 176.12,153.35 175.61,153.35 174.85,152.59 174.73,152.59 174.34,152.97 174.34,156.4 175.36,157.42 184.76,157.42
GND on BOTTOM (solid shape): 117.01,54.93 117.09,54.89 117.11,54.8 117.47,54.32 117.84,54.8 117.86,54.89 117.94,54.93 118.46,54.93 118.72,54.67 118.72,51.25 118.46,50.99 116.81,50.99 116.56,51.25 116.56,54.55 116.94,54.93
GND on BOTTOM (solid shape): 205.84,167.58 205.84,160.34 204.95,159.45 199.62,159.45 199.24,159.83 196.44,159.83 195.93,159.32 195.93,158.05 195.55,157.67 194.16,157.67 194.03,157.8 194.03,159.32 193.78,159.58 167.74,159.58 167.49,159.83 167.49,163.13 167.61,163.26 171.58,163.26 172.21,163.89 173.15,163.89 173.79,163.26 177.57,163.26 178.61,164.3 179.25,164.3 180.29,163.26 183.89,163.26 185.04,164.4 185.44,164.4 186.59,163.26 190.47,163.26 190.85,162.88 191.87,162.88 192.38,163.39 192.89,163.39 193.39,162.88 202.56,162.88 204.32,164.63 204.32,166.05 204.69,166.43 204.74,166.47 204.78,166.51 204.82,166.56 204.82,166.6 204.83,166.61 204.85,166.74 204.83,166.87 204.82,166.88 204.82,167.07 204.19,167.7 204.19,167.96 204.32,168.09 205.33,168.09
GND on BOTTOM (solid shape): 300.49,169.7 299.32,166.87 296.49,165.7 293.19,165.7 293.19,172.7 293.48,173.41 294.19,173.7 300.49,173.7
GND on BOTTOM (solid shape): 75.97,159.27 79.12,159.27 79.22,159.2 79.19,159.09 79.12,159.01 79.07,158.91 79.06,158.88 79.01,158.88 78.5,158.37 78.5,155.93 78.43,155.86 76.85,155.86 76.78,155.89 76.75,155.96 76.72,156.08 76.64,156.17 76.64,156.49 77.7,157.55 77.73,157.52 78.3,157.85 77.66,158 77.64,157.98 77.62,157.98 76.29,156.64 76.29,156.17 76.21,156.08 76.19,155.96 76.16,155.89 76.08,155.86 72.01,155.86 71.13,156.74 71.13,159.1 71.76,159.73 75.52,159.73
GND on BOTTOM (solid shape): 67.92,77.51 68.05,77.51 68.17,77.51 68.47,77.21 68.65,77.21 68.65,77.2 69.22,77.2 69.22,76.8 69.17,76.75 69.1,76.75 68.99,76.65 68.92,76.55 68.9,76.43 68.87,76.42 68.83,76.41 68.58,76.34 68.45,76.11 68.42,76.05 68.36,76.02 68.26,75.99 68.17,75.92 68.12,75.83 68.11,75.72 68.2,75.55 68.39,75.48 68.43,75.47 68.45,75.45 68.45,75.43 68.44,75.39 68.4,75.37 68.39,75.37 68.28,75.36 68.2,75.31 68.16,75.28 68.13,75.24 67.78,75.24 67.45,75.57 67.26,75.57 67.11,75.72 67.06,75.72 66.64,76.13 66.64,76.32 66.42,76.55 66.38,76.58 66.39,77.37 66.41,77.44 66.48,77.47 66.74,77.72 67.71,77.72
GND on BOTTOM (solid shape): 68.13,60.37 68.13,60.35 68.16,60.22 68.23,60.11 68.23,59.99 68.22,59.98 68.2,59.74 68.38,59.58 68.43,59.54 68.45,59.47 68.53,59.22 68.77,59.1 68.83,59.08 68.86,59.01 68.87,58.96 68.99,58.8 69.19,58.77 69.31,58.84 69.39,58.96 69.39,59 69.44,59.05 69.5,59 69.55,58.86 69.68,58.77 69.74,58.71 69.74,58.63 69.73,58.6 69.73,58.56 69.73,58.38 69.26,57.92 69.26,57.57 68.86,57.16 67.47,57.16 67.44,57.14 66.65,57.14 66.42,57.37 66.42,58.31 67,58.88 67,59.72 67.01,59.75 67.14,59.88 67.18,59.88 67.48,59.96 67.6,60.25 67.63,60.32 67.7,60.35 68.01,60.35 68.08,60.42
GND on BOTTOM (solid shape): 89.14,159.79 89.14,159.09 88.94,158.88 87.85,158.88 87.36,158.92 87.31,158.43 87.31,158.09 87.22,157.86 87.31,157.63 87.31,156.34 87.02,156.05 86.22,156.05 86.07,155.9 85.89,156.08 85.89,156.99 86.28,157.39 86.28,158.18 85.9,158.56 85.78,158.56 85.77,158.6 85.23,158.85 85.21,158.26 85.26,158.19 85.24,158.12 85.24,158.09 85.22,158.08 85.06,157.75 85.28,157.46 85.34,157.38 85.31,157.29 85.27,157.25 85.27,155.89 84.53,155.89 84.53,155.86 79.13,155.86 79.12,155.87 79.12,157.62 79.17,157.71 79.26,157.72 79.72,157.86 79.61,158.33 79.59,158.36 79.56,158.44 79.6,158.51 79.77,158.79 79.64,159.09 79.6,159.2 79.7,159.27 82.58,159.27 82.83,159.52 86.28,159.52 87.05,160.29 88.65,160.29
GND on BOTTOM (solid shape): 82.14,76.65 82.14,76.24 82.14,76.23 82.22,75.96 82.49,75.9 82.52,75.9 82.56,75.86 82.55,75.83 82.82,75.45 83.08,75.83 83.07,75.85 83.09,75.91 83.14,75.9 83.36,75.92 83.49,76.1 83.5,76.12 83.54,76.16 83.54,76.63 83.65,76.73 83.71,76.67 83.81,76.67 83.81,76.25 83.77,76 83.94,75.83 83.96,75.82 83.98,75.79 83.98,75.77 83.99,75.58 84.1,75.43 84.14,75.33 84.08,75.25 84.05,75.24 83.56,75.24 83.54,75.27 83.29,75.41 83.04,75.25 83.03,75.22 82.93,75.22 82.85,75.15 82.83,75.15 82.64,75.07 82.52,74.9 82.5,74.87 82.44,74.87 82.39,74.81 82.36,74.81 82.29,74.82 82.22,74.8 82.18,74.84 82.17,74.9 82.18,75.04 82.16,75.12 81.99,75.6 81.51,75.42 81.49,75.39 81.45,75.39 81.39,75.46 81.41,75.55 81.46,75.65 81.47,75.77 81.49,75.85 81.58,75.88 81.76,75.94 81.87,76.1 81.87,76.12 81.9,76.14 81.9,76.61 82.04,76.75
GND on BOTTOM (solid shape): outline of 87 points within 70.3,58.76 72.43,60.27
GND on BOTTOM (solid shape): outline of 84 points within 70.08,74.79 72.9,76.7
GND on BOTTOM (solid shape): outline of 91 points within 68.04,60.95 70.09,63.8
GND on BOTTOM (solid shape): outline of 148 points within 74.58,61.06 80.56,62.75
GND on BOTTOM (solid shape): outline of 151 points within 73.31,74.78 79.43,76.82
GND on BOTTOM (solid shape): outline of 136 points within 84.1,70.39 86.76,78.71
GND on BOTTOM (solid shape): outline of 826 points within 167.74,117.73 191.06,126.11
GND on BOTTOM (solid shape): outline of 330 points within 72.58,58.75 83.86,60.9
GND on BOTTOM (solid shape): outline of 4976 points within 0,0 305.6,178.95
GND on IN1 (solid shape): 92.23,174.7 78.59,174.7 78.59,175.2 92.23,175.2
GND on IN1 (solid shape): 64.36,58.1 64.36,55.06 64.11,54.8 62.84,54.8 62.58,55.06 62.58,57.98 62.84,58.23 64.24,58.23
GND on IN1 (solid shape): 98.02,75.38 98.02,73.09 97.76,72.84 94.72,72.84 94.46,73.09 94.46,75.38 94.72,75.63 97.76,75.63
GND on IN1 (solid shape): 121.77,95.57 121.77,92.65 121.39,92.27 119.1,92.27 118.72,92.65 118.72,95.57 118.97,95.82 121.51,95.82
GND on IN1 (solid shape): 240.64,35.88 240.64,34.1 240.51,33.97 237.21,33.97 237.08,34.1 237.08,35.88 237.21,36.01 240.51,36.01
GND on IN1 (solid shape): 76.3,173.44 76.91,172.83 76.91,171.01 70.56,164.66 67.25,164.66 63.15,168.76 63.15,175.2 76.3,175.2
GND on IN1 (solid shape): outline of 3060 points within 0.26,0.26 305.6,178.95
GND on IN2 (solid shape): 64.49,57.98 64.49,55.06 64.36,54.93 62.71,54.93 62.58,55.06 62.58,57.98 62.84,58.23 64.24,58.23
GND on IN2 (solid shape): 98.02,75.38 98.02,73.09 97.76,72.84 94.72,72.84 94.46,73.09 94.46,75.38 94.72,75.63 97.76,75.63
GND on IN2 (solid shape): 121.77,95.57 121.77,92.65 121.39,92.27 119.1,92.27 118.72,92.65 118.72,95.57 118.97,95.82 121.51,95.82
GND on IN2 (solid shape): 240.64,35.88 240.64,34.1 240.51,33.97 237.46,33.97 237.08,34.35 237.08,35.88 237.21,36.01 240.51,36.01
GND on IN2 (solid shape): 196.19,156.15 196.19,153.86 195.93,153.61 191.62,153.61 190.47,152.46 190.09,152.46 189.33,153.23 188.31,153.23 187.55,152.46 187.3,152.46 186.54,153.23 185.52,153.23 185.39,153.1 185.39,152.85 185.01,152.46 184.76,152.46 184.5,152.72 184.5,153.1 184.25,153.35 181.2,153.35 180.44,152.59 179.81,152.59 179.04,153.35 178.28,153.35 177.52,152.59 176.88,152.59 176.12,153.35 175.61,153.35 175.23,152.97 175.23,152.72 175.11,152.59 174.47,152.59 174.34,152.72 174.34,156.15 174.73,156.53 195.81,156.53
GND on IN2 (solid shape): outline of 3967 points within 0.26,0.26 305.6,178.95
GND on IN2 (solid shape): outline of 7734 points within 125.58,51.12 173.33,119.57
GND on IN2 (solid shape): outline of 17748 points within 166.46,51.12 206.09,140.02
GND on IN3 (solid shape): 64.49,57.98 64.49,55.06 64.36,54.93 62.71,54.93 62.58,55.06 62.58,57.98 62.84,58.23 64.24,58.23
GND on IN3 (solid shape): 98.02,75.38 98.02,73.09 97.76,72.84 94.72,72.84 94.46,73.09 94.46,75.38 94.72,75.63 97.76,75.63
GND on IN3 (solid shape): 121.77,95.57 121.77,92.65 121.39,92.27 119.1,92.27 118.72,92.65 118.72,95.57 118.97,95.82 121.51,95.82
GND on IN3 (solid shape): 240.64,35.88 240.64,34.1 240.51,33.97 237.21,33.97 237.08,34.1 237.08,35.88 237.21,36.01 240.51,36.01
GND on IN3 (solid shape): outline of 655 points within 168.05,119.19 191.08,125.21
GND on IN3 (solid shape): outline of 3929 points within 0.26,0.26 305.6,178.95
GND on IN4 (solid shape): 64.49,57.98 64.49,55.06 64.24,54.8 62.84,54.8 62.58,55.06 62.58,57.98 62.84,58.23 64.24,58.23
GND on IN4 (solid shape): 98.02,75.38 98.02,73.09 97.76,72.84 94.72,72.84 94.46,73.09 94.46,75.38 94.72,75.63 97.76,75.63
GND on IN4 (solid shape): 121.77,95.57 121.77,92.65 121.39,92.27 119.1,92.27 118.72,92.65 118.72,95.57 118.97,95.82 121.51,95.82
GND on IN4 (solid shape): 240.64,35.88 240.64,34.1 240.51,33.97 237.21,33.97 237.08,34.1 237.08,35.88 237.21,36.01 240.51,36.01
GND on IN4 (solid shape): outline of 3935 points within 0.26,0.26 305.6,178.95
GND on GND1, GND2: outline of 241 points within 0.26,0.26 305.6,178.95 ; 9 cut-outs
GND on VCC: 67.79,165.29 67.79,165.82 65.14,168.47 63.15,168.47 63.15,175.2 101.51,175.2 101.68,174.84 101.98,174.58 101.98,172.01 100.85,170.88 91.2,170.88 88.28,167.96 84.6,167.96 81.93,165.29 69.81,165.29 69.44,165.55 69.08,165.29
GND on VCC: outline of 123 points within 0.26,159.2 48.44,178.95
GND on VCC: outline of 81 points within 272.36,85.28 305.6,173.44
GND on VCC: outline of 90 points within 127.61,63.87 205.89,160.72
GND on GND3: outline of 357 points within 0.26,0.26 305.6,178.95 ; 9 cut-outs
VDD_1.35V on BOTTOM (solid shape): 150.98,21.4 151.48,21.4 152.63,20.26 152.63,19.24 152.5,19.11 151.74,19.11 151.61,19.24 151.61,19.62 150.6,20.64 150.6,21.26 150.6,21.4 150.68,21.49 150.89,21.49
VDD_1.35V on BOTTOM (solid shape): 148.98,19.14 149.07,19.14 149.12,19.12 149.2,19.04 149.2,18.61 149.33,18.47 149.33,18.46 149.35,18.46 149.83,17.97 149.83,16.7 149.58,16.45 148.82,16.45 148.56,16.7 148.56,18.23 148.31,18.48 148.31,19.11 148.44,19.24 148.69,19.24 148.88,19.24
+BL_PWR_SRC on TOP (solid shape): 97.91,158.59 97.91,157.26 97.7,157.05 97.44,157.05 97.37,156.99 97.37,155.73 97.24,155.6 95.66,155.6 95.5,155.75 95.5,158.58 95.84,158.92 97.59,158.92
+BL_PWR_SRC on TOP (solid shape): 129.18,157.76 129.18,155.05 129.08,154.95 127.21,154.95 127.19,154.98 127.19,155.59 127.23,155.67 127.24,155.75 127.24,156.79 127.23,156.88 127.19,156.96 127.19,157.9 127.42,158.13 128.81,158.13
+BL_PWR_SRC on BOTTOM (solid shape): 129.13,158.1 129.13,157.19 128.9,156.96 128.9,156.35 127.44,156.35 127.4,156.38 127.4,156.94 127.41,156.94 127.41,157.81 127.4,157.81 127.4,158.21 127.46,158.27 128.96,158.27
+BL_PWR_SRC on BOTTOM (solid shape): 99.75,158.52 99.73,158.48 99.69,158.38 99.68,158.26 99.68,157.98 99.69,157.87 99.73,157.77 99.73,156.94 99.4,156.61 95.33,156.61 95.11,156.84 95.11,157.66 95.31,158 95.11,158.34 95.11,158.72 95.44,159.05 99.22,159.05
+BL_PWR_SRC on IN1 (solid shape): outline of 404 points within 95.86,151.7 130.78,158.96
+CAMERA_VDD on TOP (solid shape): 29.69,113.48 29.69,112.71 29.31,112.33 27.91,112.33 27.66,112.59 27.66,113.98 27.28,114.36 27.28,114.75 27.53,115 28.17,115
+CAMERA_VDD on TOP (solid shape): 3.12,131.5 3.12,126.76 2.42,126.06 2.42,125.88 3.53,124.78 5.31,124.78 5.56,124.52 5.56,123.64 5.31,123.38 4.42,123.38 3.15,122.11 2.51,122.11 1.68,122.95 1.68,131.57 1.73,131.62 3,131.62
+CAMERA_VDD on IN1 (solid shape): outline of 506 points within 4.93,113.6 29.56,125.16
+CHAGER_SRC on BOTTOM (solid shape): 216.32,33.28 216.38,33.21 219.43,33.21 219.81,32.83 219.81,32.58 219.94,32.45 220.83,32.45 221.08,32.2 221.08,26.61 220.7,26.23 219.68,26.23 219.3,26.61 216,26.61 215.75,26.86 215.75,30.54 214.98,31.31 212.19,31.31 211.9,31.02 211.9,29.67 211.8,29.57 209.87,29.57 209.65,29.78 209.65,33.59 209.9,33.85 215.75,33.85
+CHAGER_SRC on IN4 (solid shape): outline of 102 points within 211.3,28.51 220.95,33.97
+CRT_VCC on IN1 (solid shape): outline of 290 points within 85.32,165.43 92.68,173.55
+DC1_PWR_SRC on TOP (solid shape): 33.25,55.18 33.25,53.15 31.09,50.99 31.09,48.96 31.47,48.58 31.47,48.26 31.72,48.01 31.72,46.36 31.47,46.1 29.06,46.1 28.68,46.48 28.68,51.34 28.88,51.68 28.68,52.01 28.68,55.18 28.93,55.44 32.99,55.44
+DC1_PWR_SRC on TOP (solid shape): outline of 226 points within 34.99,25.29 41.63,36.01
+DC1_PWR_SRC on BOTTOM (solid shape): 33.12,57.6 33.12,53.28 32.61,52.77 28.29,52.77 27.91,53.15 27.91,57.6 28.42,58.1 32.61,58.1
+DC1_PWR_SRC on IN1 (solid shape): outline of 683 points within 30.33,32.96 52.68,55.94
+DC_IN on TOP (solid shape): 10.26,85.41 10.26,81.34 9.5,80.58 3.4,80.58 3.15,80.84 3.15,82.66 7.19,82.66 7.19,82.61 7.2,82.55 7.22,82.5 7.25,82.45 7.28,82.41 7.32,82.37 7.37,82.34 7.42,82.31 7.47,82.3 7.53,82.29 7.58,82.28 7.64,82.29 7.69,82.3 7.74,82.33 7.79,82.35 7.83,82.39 7.87,82.43 7.9,82.48 7.92,82.53 7.94,82.58 7.95,82.64 7.95,82.69 7.94,82.75 7.92,82.8 7.9,82.85 7.87,82.9 7.83,82.94 7.79,82.98 7.74,83 7.69,83.03 7.64,83.04 7.58,83.05 7.53,83.04 7.47,83.03 7.42,83.02 7.37,82.99 7.32,82.96 7.28,82.92 7.25,82.88 7.22,82.83 7.2,82.77 7.19,82.72 7.19,82.66 3.15,82.66 3.15,84.9 3.91,85.66 10.01,85.66
+DC_IN_SS on TOP (solid shape): 7.72,79.69 7.72,75.76 8.23,75.25 8.23,73.6 8.36,73.47 8.86,73.47 8.99,73.34 8.99,72.71 9.12,72.58 9.63,72.58 9.88,72.33 9.88,67.63 9.75,67.5 5.56,67.5 3.28,69.79 2.01,69.79 1.24,70.55 1.24,79.44 1.75,79.95 7.47,79.95
+DCIN_JACK on TOP (solid shape): 11.15,78.93 11.15,77.41 11.35,77.2 11.35,76.52 12.04,75.83 12.04,74.49 11.78,74.23 10.39,74.23 10.13,74.49 10.13,75.25 9.88,75.5 8.36,75.5 8.1,75.76 8.1,79.19 8.36,79.44 10.64,79.44
+DCIN_JACK on BOTTOM (solid shape): outline of 501 points within 6.32,70.3 23.09,79.31
+DOCK_PWR_BAR on TOP (solid shape): outline of 95 points within 118.59,111.23 129.77,125.54
+DOCK_PWR_BAR on TOP (solid shape): outline of 102 points within 159.23,11.49 167.49,22.42
+DOCK_PWR_BAR on BOTTOM (solid shape): 126.47,116.27 126.47,112.97 126.21,112.71 119.99,112.71 119.73,112.97 119.73,114.11 122.15,116.52 126.21,116.52
+DOCK_PWR_BAR on IN1 (solid shape): outline of 101 points within 119.35,113.86 126.59,125.54
+DOCK_PWR_BAR on IN1 (solid shape): outline of 959 points within 8.36,5.91 164.18,62.17
+DOCK_PWR_BAR on IN2 (solid shape): outline of 10210 points within 2.92,57.72 131.67,125.67
+DOCK_PWR_BAR on IN4 (solid shape): outline of 923 points within 8.36,5.91 164.18,62.17
+DP_VCC on TOP (solid shape): 293.26,141.15 293.26,141.13 293.77,140.71 294.3,141.12 294.31,141.16 295.5,141.16 295.76,140.91 295.76,137.73 295.5,137.48 293.98,137.48 292.8,136.3 289.82,136.3 289.28,136.84 289.28,141.63 289.48,141.83 292.57,141.83
+EDPVDD on TOP (solid shape): 115.92,168.59 115.92,167.07 116.31,166.69 116.31,165.67 116.05,165.42 114.53,165.42 114.27,165.67 114.27,166.43 113.26,167.45 113.26,168.59 113.51,168.85 115.67,168.85
+EDPVDD on TOP (solid shape): 124.69,156.78 124.69,153.65 124.51,153.38 124.6,153.08 124.63,153.01 124.6,152.94 124.48,152.69 124.56,152.43 124.58,152.37 124.56,152.3 124.46,151.99 124.66,151.74 124.69,151.72 124.69,151.58 124.43,151.32 123.04,151.32 122.15,152.2 122.15,152.21 122.06,152.35 121.92,152.44 121.91,152.44 121.64,152.72 121.64,153.73 121.26,154.12 121.26,154.5 121.51,154.75 122.53,154.75 122.78,155 122.78,156.81 122.91,156.93 124.54,156.93
+EDPVDD on IN2 (solid shape): outline of 453 points within 113.77,153.23 123.42,167.07
+LCDVDD on TOP (solid shape): 97.06,169.29 97.06,168.77 96.14,167.86 96.14,167.32 96.14,167.26 96.14,167.03 95.97,166.86 94.9,166.86 94.69,166.65 93.92,166.65 93.8,166.77 93.8,166.78 93.68,166.9 93.68,167.69 94.08,168.09 94.08,169.17 94.28,169.37 96.97,169.37
+LCDVDD on TOP (solid shape): 92.94,159.6 92.94,155.75 92.8,155.61 91.62,155.61 91.53,155.7 91.53,157.65 91.66,158.18 91.13,158.29 91.09,158.27 90.86,158.5 90.86,159.61 90.99,159.73 92.8,159.73
+LCDVDD on IN1 (solid shape): outline of 771 points within 88.37,157.42 97.76,170.5
+LOM_VCT on BOTTOM (solid shape): 114.91,131.13 114.91,129.86 112.88,127.83 112.88,125.87 112.8,125.79 112.17,125.79 112.09,125.87 112.09,131.1 112.37,131.38 114.65,131.38
+MXM_PWR on TOP (solid shape): 23.14,139.21 23.14,138.47 23.14,138.45 23.15,138.45 23.16,138.44 23.67,138.44 23.67,137.96 23.16,137.96 23.14,137.96 23.14,137.94 23.14,137.27 23.14,137.25 23.16,137.25 23.67,137.25 23.69,137.23 23.69,136.79 23.67,136.77 23.16,136.77 23.15,136.76 23.14,136.76 23.14,136.74 23.14,133.29 23.19,133.24 23.67,133.24 23.67,132.75 23.16,132.75 23.14,132.73 23.14,132.07 23.16,132.04 23.65,132.04 23.67,132.02 23.67,131.56 23.16,131.56 23.14,131.53 23.14,130.98 22.53,130.37 19.53,130.37 19.28,130.62 19.28,139.38 19.66,139.76 22.58,139.76
+MXM_PWR on BOTTOM (solid shape): 12.13,135.19 12.16,135.18 12.18,135.14 12.22,134.97 12.34,134.83 12.38,134.75 12.35,134.67 12.66,134.02 12.84,134.72 12.8,134.79 12.83,134.87 12.91,135 12.94,135.14 12.96,135.18 12.99,135.19 21.94,135.19 22.33,134.81 22.33,132.02 22.07,131.76 9.37,131.76 8.96,132.17 8.96,135.19 9.51,135.19 9.52,135.18 9.52,133.82 9.52,133.8 9.52,133.67 9.7,133.49 9.74,133.49 9.75,133.49 9.88,133.46 10,133.49 10.01,133.49 10.06,133.49 10.26,133.69 10.26,135.19
+MXM_PWR_SRC on TOP (solid shape): outline of 265 points within 23.34,129.48 35.66,145.61
+MXM_PWR_SRC on BOTTOM (solid shape): 11.78,138.24 12.01,138.24 12.09,138.15 12.19,138.09 12.26,138.02 12.34,137.97 12.4,137.88 12.36,137.79 12.59,137.09 12.71,137.81 12.65,137.9 12.7,137.99 12.8,138.08 12.86,138.2 12.87,138.24 25.63,138.24 26.01,137.86 26.01,135.7 25.75,135.45 12.79,135.45 12.56,135.52 12.33,135.45 11.15,135.45 10.39,136.21 10.26,136.21 10.24,136.23 10.24,137.58 10.23,137.71 10.19,137.75 10.13,137.83 10.05,137.89 10.03,137.91 10,137.91 9.88,137.94 9.75,137.91 9.74,137.91 9.7,137.91 9.52,137.73 9.52,137.6 9.52,137.58 9.52,136.23 9.5,136.21 8.99,136.21 8.99,138.44 9.17,138.62 11.4,138.62
+PCH_USB_DCPSUS3 on TOP (solid shape): outline of 558 points within 78.33,69.91 83.79,76.39
+PCH_VCCCLK on BOTTOM (solid shape): 80.78,69.33 80.78,69.16 80.59,68.98 80.59,68.85 80.67,68.77 80.69,68.77 80.83,68.63 80.83,68.55 80.72,68.44 80.54,68.44 80.3,68.68 80.21,68.68 79.95,68.43 79.77,68.43 79.66,68.55 79.66,68.62 79.79,68.75 79.83,68.75 79.93,68.85 79.93,68.94 79.67,69.2 79.67,69.31 79.77,69.41 79.89,69.41 80.13,69.16 80.31,69.16 80.48,69.33 80.52,69.36 80.54,69.38 80.58,69.42 80.69,69.42
+PCH_VCCCLK on IN1 (solid shape): 82.65,68.9 82.65,67.38 82.6,67.3 82.51,67.29 82.3,67.31 82.11,67.21 82.04,67.18 81.97,67.21 81.74,67.32 81.5,67.24 81.43,67.22 81.37,67.25 80.89,67.25 80.84,66.77 80.85,66.67 80.76,66.61 80.24,66.61 79.86,66.99 79.86,67.24 79.91,67.33 80.02,67.32 80.59,67.6 80.02,67.88 79.91,67.87 79.86,67.97 79.86,69.03 79.98,69.15 82.4,69.15
+PCH_VCCCLK3_3 on TOP (solid shape): outline of 321 points within 77.44,57.21 81,64.07
+PCH_VCCCLK3_3 on IN1 (solid shape): outline of 86 points within 78.51,62.17 80.87,65.22
+PWR_SRC on TOP (solid shape): 170.92,173.55 170.92,171.01 170.66,170.75 164.31,170.75 164.18,170.88 164.18,173.29 164.69,173.8 170.66,173.8
+PWR_SRC on TOP (solid shape): 7.97,112.71 7.97,110.3 11.4,106.87 11.4,104.71 10.64,103.95 4.93,103.95 1.5,107.38 1.5,112.97 2.01,113.48 7.21,113.48
+PWR_SRC on TOP (solid shape): 4.93,60.9 5.43,60.9 5.43,59.37 5.69,59.12 5.94,59.12 6.2,59.37 6.2,60.9 8.1,60.9 8.36,60.64 8.36,57.85 8.1,57.6 1.75,57.6 1.37,57.98 1.37,60.77 1.88,61.28 4.55,61.28
+PWR_SRC on TOP (solid shape): 30.2,60.39 31.47,60.39 31.75,60.11 31.75,58.46 31.77,58.43 32.28,58.43 32.31,58.41 32.31,58.2 32.28,58.18 31.77,58.18 31.75,58.15 31.75,57.67 31.77,57.65 32.28,57.65 32.31,57.62 32.31,57.39 32.28,57.37 31.77,57.37 31.75,57.34 31.75,56.86 31.6,56.71 28.42,56.71 28.04,57.09 28.04,60.77 28.29,61.02 29.56,61.02
+PWR_SRC on TOP (solid shape): outline of 2535 points within 66.52,98.49 128.12,120.71
+PWR_SRC on BOTTOM (solid shape): 107.42,9.72 107.42,6.8 106.78,6.16 102.59,6.16 101.95,6.8 101.95,9.72 102.34,10.1 107.03,10.1
+PWR_SRC on BOTTOM (solid shape): 208.25,34.48 208.25,30.06 207.69,29.5 204.09,29.5 203.55,30.04 203.55,34.61 203.81,34.86 207.87,34.86
+PWR_SRC on BOTTOM (solid shape): 143.86,30.29 143.86,27.12 143.48,26.73 142.47,26.73 142.47,27.24 142.34,27.37 141.58,27.37 141.58,26.73 141.2,26.73 141.2,27.37 140.31,27.37 140.31,26.73 139.93,26.73 139.8,26.86 139.8,30.29 140.18,30.67 143.48,30.67
+PWR_SRC on BOTTOM (solid shape): 110.46,159.59 110.46,153.04 109.64,152.21 102.28,152.21 99.72,154.76 99.72,156.13 99.93,156.34 102.51,156.34 103.21,155.64 106.65,155.64 108.05,157.04 108.05,159.06 107.61,159.5 106.48,159.5 106.2,159.78 106.2,160.3 108.2,160.3 108.21,160.24 108.22,160.19 108.24,160.14 108.26,160.09 108.3,160.04 108.34,160.01 108.38,159.97 108.43,159.95 108.49,159.93 108.54,159.92 108.6,159.92 108.65,159.92 108.71,159.94 108.76,159.96 108.81,159.99 108.85,160.02 108.89,160.07 108.92,160.11 108.94,160.16 108.96,160.22 108.96,160.27 108.96,160.33 108.96,160.38 108.94,160.44 108.92,160.49 108.89,160.53 108.85,160.58 108.81,160.61 108.76,160.64 108.71,160.66 108.65,160.68 108.6,160.68 108.54,160.68 108.49,160.67 108.43,160.65 108.38,160.63 108.34,160.59 108.3,160.56 108.26,160.51 108.24,160.46 108.22,160.41 108.21,160.36 108.2,160.3 106.2,160.3 106.2,160.65 106.24,160.69 108.63,160.69 108.72,160.78 109.27,160.78
+PWR_SRC on BOTTOM (solid shape): 183.74,26.99 183.74,23.18 183.23,22.67 180.95,22.67 180.86,22.58 180.79,22.55 180.45,22.67 180.2,22.56 179.74,22.1 178.66,22.1 178.42,22.03 178.25,21.83 178.12,21.83 177.7,21.41 177.68,21.41 177.47,20.94 177.95,21.14 177.95,21.16 178.17,21.38 178.25,21.41 178.32,21.37 178.47,21.25 178.66,21.21 179.81,21.21 179.92,21.23 180.03,21.27 180.14,21.27 180.19,21.18 180.19,13.78 179.55,13.15 174.98,13.15 174.34,13.78 174.34,25.59 176.25,27.5 183.23,27.5
+PWR_SRC on BOTTOM (solid shape): outline of 896 points within 1.5,57.47 32.99,62.29
+PWR_SRC on IN1 (solid shape): outline of 1123 points within 107.92,152.95 134.97,163.77
+PWR_SRC on IN3 (solid shape): 126.85,14.42 170.79,14.42 172.95,16.57 178.79,16.57 179.42,15.94 179.42,12 178.92,11.49 121.51,11.49 118.08,14.92 116.53,14.92 116.53,14.92 115.89,15 115.25,14.92 115.25,14.92 113.51,14.92 105.13,6.54 31.85,6.54 30.83,7.56 30.83,9.21 31.22,9.59 99.67,9.59 108.18,18.1 123.16,18.1
+PWR_SRC on IN4 (solid shape): outline of 1390 points within 7.24,100.27 74.01,110.81
+PWR_SRC on IN4 (solid shape): outline of 1842 points within 138.53,12.76 208.25,34.74
+PWR_SRC on IN4 (solid shape): outline of 3098 points within 122.4,106.74 172.44,173.17
+PWR_SRC on VCC: outline of 82 points within 1.02,1.02 179.93,113.35
+PWR_SRC_MXM on TOP (solid shape): 17.5,139.89 17.5,136.72 17.12,136.34 13.82,136.34 13.44,136.72 13.44,140.27 13.69,140.53 16.86,140.53
+PWR_SRC_MXM on TOP (solid shape): outline of 133 points within 8.48,109.54 18.26,119.19
+PWR_SRC_MXM on IN4 (solid shape): outline of 1020 points within 8.99,112.71 19.53,140.78
+SDC_IN on TOP (solid shape): 5.31,67.12 8.23,67.12 8.48,66.87 8.48,64.73 8.38,64.48 8.48,64.23 8.48,62.68 7.72,61.91 6.2,61.91 6.2,63.44 5.94,63.69 5.69,63.69 5.43,63.44 5.43,61.91 2.77,61.91 1.12,63.56 1.12,67.88 1.88,68.64 3.78,68.64
+SM_VREF on IN4 (solid shape): outline of 410 points within 191.62,103.19 195.81,106.49
+SW_LX on TOP (solid shape): 147.55,152.97 147.55,149.16 147.29,148.91 146.02,148.91 144.75,150.18 144.75,152.97 145.01,153.23 147.29,153.23
+SW_LX on TOP (solid shape): 125.07,141.29 125.07,140.99 125.07,140.98 125.04,140.86 125.07,140.73 125.07,140.72 125.07,140.65 125.32,140.4 125.58,140.4 125.7,140.27 125.7,139 125.58,138.88 124.94,138.88 124.18,139.64 124.18,140.95 124.23,141.11 124.2,141.27 124.19,141.3 124.31,141.42 124.94,141.42
+SW_LX on BOTTOM (solid shape): 125.04,141.24 125.04,140.96 125.05,140.95 125.05,140.92 125.14,140.61 125.44,140.5 125.47,140.51 125.7,140.27 125.7,138.24 125.32,137.86 124.31,137.86 124.18,137.99 124.18,139.31 124.18,139.51 124.56,139.89 124.56,139.97 124.56,141.29 124.69,141.42 124.87,141.42
+SW_LX on IN2 (solid shape): 147.93,152.34 147.93,150.56 147.04,149.67 144.28,149.67 143.85,150.1 143.85,152.38 144.07,152.59 147.67,152.59
+SW_LX on IN2 (solid shape): 125.08,141.26 125.08,141.05 125.02,140.99 125.02,140.66 125.53,140.16 125.53,139.21 124.85,138.53 124.28,138.53 123.52,139.29 123.52,140.09 124.29,140.87 124.29,141.26 124.47,141.44 124.9,141.44
+SWR_V12 on TOP (solid shape): 128.88,143.57 128.88,139.64 128.12,138.88 126.21,138.88 125.96,139.13 125.96,142.05 126.85,142.94 126.85,143.7 127.1,143.96 128.5,143.96
+SWR_V12 on TOP (solid shape): 149.83,153.99 149.83,149.04 149.58,148.78 148.06,148.78 147.8,149.04 147.8,152.97 147.29,153.48 145.01,153.48 144.88,153.61 144.88,155 145.13,155.26 148.56,155.26
+SWR_V12 on BOTTOM (solid shape): 125.93,141.24 127.79,141.24 128.7,140.32 128.7,139.21 128.75,139.16 128.75,138.24 128.37,137.86 126.34,137.86 126.08,138.11 126.08,140.4 125.74,140.75 125.74,140.77 125.75,140.91 125.7,141.04 125.7,141.29 125.88,141.29
+SWR_V12 on BOTTOM (solid shape): 124.86,153.62 125.06,153.62 125.07,153.61 125.32,153.61 125.63,153.3 125.63,153.28 125.64,153.14 125.7,153.02 125.7,152.59 125.45,152.34 125.15,152.34 125.12,152.36 124.71,152.48 124.4,152.19 124.4,152.17 123.93,151.7 123.93,150.31 124.43,149.8 124.43,149.28 124.35,149.18 124.31,149.05 124.31,149.04 124.23,148.96 124.23,148.8 124.2,148.76 124.14,148.77 124.09,148.82 124.09,149.58 123.16,150.51 123.16,153.48 123.42,153.73 124.75,153.73
+SWR_V12 on IN2 (solid shape): 129.61,143.43 129.61,141.84 127.56,139.79 126.05,139.79 125.92,139.92 125.92,142.13 127.56,143.76 129.27,143.76
+SWR_V12 on IN2 (solid shape): 147.04,153.86 147.04,153.1 146.79,152.85 143.85,152.85 143.69,153.01 143.69,154.31 143.88,154.5 146.4,154.5
+SWR_V12 on IN2 (solid shape): 125.51,155.63 125.51,153.19 125.69,153.01 125.69,152.68 125.45,152.44 124.53,152.44 123.81,153.16 123.81,155.75 123.96,155.91 125.23,155.91
+USB1_REPEATER_VDD on TOP (solid shape): outline of 1104 points within 261.09,65.6 276.58,81.09
+USB1_REPEATER_VDD on BOTTOM (solid shape): 261.11,79.39 261.11,78.93 261.11,78.91 261.12,78.89 261.12,78.85 261.18,78.85 261.21,78.83 261.47,78.83 261.49,78.85 261.56,78.85 261.56,78.87 261.57,78.88 261.57,79.36 261.59,79.39 262.41,79.39 262.74,79.06 262.74,77.92 262.48,77.66 260.7,77.66 260.45,77.92 260.45,78.45 260.46,78.48 260.5,78.5 260.83,78.85 260.5,79.21 260.46,79.23 260.45,79.26 260.45,79.34 260.53,79.41 261.09,79.41
+V_DDR_REF on BOTTOM (solid shape): 151.23,26.99 151.23,25.21 150.98,24.96 150.09,24.96 149.96,25.08 149.96,25.85 150.09,25.97 150.55,25.97 150.75,26.17 150.75,26.94 150.75,27.01 150.85,27.12 151.1,27.12
+V_DDR_REF on BOTTOM (solid shape): 188.73,31.2 188.73,30.16 188.35,29.78 186.55,29.78 186.28,30.05 186.28,31.03 186.47,31.21 186.5,31.2 186.7,31.22 186.84,31.37 186.85,31.41 188.53,31.41
+V_DDR_REF on BOTTOM (solid shape): outline of 213 points within 196.44,59.25 200.94,71.95
+V_DDR_REF on IN3 (solid shape): outline of 400 points within 150.6,24.83 188.06,30.38
+VCHGR on TOP (solid shape): outline of 115 points within 172.57,17.21 192.25,28.51
+VCHGR on BOTTOM (solid shape): 201.4,18.23 201.4,17.08 200.76,16.45 200.13,16.45 199.62,15.94 198.35,15.94 198.22,15.81 198.22,15.18 198.35,15.05 200,15.05 200,13.78 199.49,13.27 194.16,13.27 193.65,13.78 193.65,17.97 194.16,18.48 201.14,18.48
+VCHGR on IN1 (solid shape): 192.25,26.99 192.25,20 192.3,19.96 192.12,19.37 192.73,19.36 192.8,19.4 192.88,19.37 193.39,18.86 195.45,18.86 195.46,18.83 195.72,18.62 196.04,18.69 196.08,18.72 196.32,18.48 196.32,15.05 195.93,14.67 189.08,14.67 188.19,15.56 188.19,26.99 188.33,27.13 188.43,27.16 188.5,27.08 189.01,26.81 189.21,27.35 189.21,27.45 189.3,27.5 191.74,27.5
+VDISPLAY_VCC on BOTTOM (solid shape): outline of 167 points within 37.06,162.37 42.9,167.45
+VDISPLAY_VCC on IN1 (solid shape): outline of 143 points within 36.17,166.31 41.63,172.4
+VR_CAP on BOTTOM (solid shape): 232.89,48.16 233.37,48.16 233.44,48.1 233.44,47.3 233.34,47.19 232.68,47.19 232.61,47.26 232.61,47.73 232.08,48.26 232.08,48.59 232.15,48.67 232.38,48.67
+VR_CAP on IN3 (solid shape): 232.41,48.69 233.05,48.69 233.45,48.29 233.46,48.29 233.54,48.21 234.67,48.21 234.75,48.18 234.77,48.1 235.13,47.71 235.48,48.1 235.51,48.18 235.58,48.21 236.35,48.21 236.42,48.15 238.75,48.15 238.75,48.1 238.96,47.77 239.34,47.82 239.4,47.84 239.47,47.82 239.69,47.74 239.91,47.81 240.27,47.45 240.27,47.04 240.02,46.79 239.54,46.79 239.46,46.83 239.45,46.93 239.11,47.41 238.78,46.93 238.77,46.83 238.69,46.79 237.26,46.79 237.18,46.82 237.16,46.9 236.8,47.31 236.45,46.9 236.43,46.82 236.35,46.79 234.25,46.79 234.17,46.83 234.15,46.91 233.78,47.38 233.41,46.91 233.39,46.83 233.31,46.79 232.41,46.79 231.98,47.22 231.98,48.54 232.13,48.69 232.41,48.69
BOOT1 on TOP (solid shape): 155.07,167.32 155.07,166.21 154.81,165.95 154.81,164.98 155.01,164.78 155.02,164.78 155.07,164.73 155.47,164.73 155.57,164.63 155.57,163.84 155.45,163.72 154.66,163.72 154.48,163.89 154.48,166 154.84,166.36 154.84,167.32 154.89,167.37 155.01,167.37
BOOT2 on TOP (solid shape): 160.4,167.5 161.03,167.5 161.14,167.4 161.14,166.59 160.98,166.43 160.35,166.43 160.22,166.56 160.22,167.32 159.31,168.24 157.58,168.24 157.53,168.29 157.53,168.42 157.58,168.47 159.43,168.47
BST1_5V on BOTTOM (solid shape): 36.92,34.3 36.92,33.21 36.89,33.19 34.89,33.19 34.77,33.3 34.77,34.25 34.92,34.4 36.82,34.4
BST_+1.05VSP on TOP (solid shape): 38.45,62.8 38.45,62.04 38.33,61.91 37.06,61.91 35.41,60.26 35.15,60.26 35.03,60.39 35.03,62.17 35.91,63.06 38.2,63.06
BST_+1.05VSP on BOTTOM (solid shape): outline of 92 points within 35.03,60.26 38.33,64.33
CHG on BOTTOM (solid shape): 212.83,19.75 212.83,14.54 211.56,13.27 201.65,13.27 201.14,13.78 201.14,15 201.16,15.04 201.19,15.05 202.67,15.05 202.92,15.3 202.92,15.69 202.67,15.94 201.19,15.94 201.16,15.95 201.14,15.99 201.14,16.32 205.71,20.89 211.68,20.89
CPU_B+ on TOP (solid shape): 199.46,165.6 199.46,163.56 199.16,163.26 196.7,163.26 196.57,163.39 196.57,164.02 196.82,164.28 197.46,164.28 198.86,165.67 199.39,165.67
CPU_B+ on TOP (solid shape): 204.72,167.02 204.72,166.51 204.57,166.36 204.32,166.36 204.14,166.18 204.14,164.66 204.65,164.15 204.65,163.59 204.39,163.34 202.59,163.34 202.46,163.46 202.46,163.97 201.9,164.53 201.9,165.93 202.28,166.31 202.94,166.31 203.86,167.22 204.52,167.22
CPU_B+ on TOP (solid shape): 191.24,169.99 191.24,167.45 193.01,165.67 193.01,163.79 192.89,163.67 192.4,163.67 191.82,163.08 191.49,163.08 191.06,163.51 188.82,163.51 188.57,163.77 188.57,165.93 188.31,166.18 186.41,166.18 185.9,166.69 184.63,166.69 184.07,166.13 184.07,165.77 184.48,165.37 184.48,164.43 184.63,164.28 184.63,163.89 184.25,163.51 182.73,163.51 182.47,163.77 182.47,165.93 182.09,166.31 179.93,166.31 179.42,166.82 178.08,166.82 177.39,166.13 177.39,165.77 177.85,165.32 177.85,164.83 178.28,164.4 178.28,163.89 177.9,163.51 176.38,163.51 176.12,163.77 176.12,165.93 175.87,166.18 173.71,166.18 173.07,166.82 172.06,166.82 171.55,166.31 171.55,165.72 171.7,165.57 171.86,165.57 172.01,165.42 172.01,164.71 172.19,164.53 172.19,163.89 171.8,163.51 170.41,163.51 170.03,163.89 170.03,165.93 169.77,166.18 167.23,166.18 166.98,165.93 166.98,164.66 166.72,164.4 164.18,164.4 163.93,164.66 163.93,169.86 164.44,170.37 190.85,170.37
CPU_B+ on BOTTOM (solid shape): outline of 87 points within 197.84,163.26 204.7,167.07
CPU_B+ on BOTTOM (solid shape): outline of 761 points within 164.95,163.13 192.89,171.13
CPU_B+ on IN1 (solid shape): outline of 374 points within 165.2,163.13 204.82,171.9
CPU_B+ on IN2 (solid shape): outline of 195 points within 185.27,163.26 204.82,171.9
DH_1.35V on BOTTOM (solid shape): 133.45,27.5 133.45,26.59 133.3,26.44 132.81,26.44 132.67,26.53 132.51,26.56 131.85,26.56 131.72,26.54 131.6,26.48 131.57,26.46 131.42,26.61 131.42,27.62 131.55,27.75 133.2,27.75
DH_1.35V on BOTTOM (solid shape): 148.87,22.17 148.87,22.01 148.77,21.91 147.98,21.91 147.93,21.91 147.8,21.78 147.8,21.53 147.55,21.27 146.79,21.27 146.66,21.4 146.66,22.04 146.76,22.13 147.39,22.13 147.4,22.13 147.66,22.09 147.88,22.24 148.76,22.24 148.8,22.24
DH_1.35V on IN3 (solid shape): 135.61,26.1 143.74,26.1 147.55,22.29 147.8,22.04 147.8,21.53 147.55,21.27 146.91,21.27 143.1,25.08 134.97,25.08 133.58,26.48 132.56,26.48 132.31,26.73 132.31,27.5 132.43,27.62 134.09,27.62
DH_CHG on BOTTOM (solid shape): 226.11,29.2 226.11,28.97 226.03,28.89 224.89,28.89 224.76,28.77 223.87,28.77 223.75,28.89 223.75,29.15 223.87,29.27 226.03,29.27
DH_CHG on BOTTOM (solid shape): 215.37,30.67 215.37,30.29 215.11,30.04 212.32,30.04 212.06,30.29 212.06,30.93 212.32,31.18 214.86,31.18
DH_CHG on IN3 (solid shape): 213.84,32.07 213.84,29.78 213.46,29.4 212.32,29.4 211.81,29.91 211.81,32.07 211.9,32.16 211.95,32.12 211.95,32.11 212.42,31.85 212.69,32.32 212.7,32.41 212.78,32.45 213.46,32.45
DH_CHG on IN3 (solid shape): 225.53,30.54 225.53,28.26 225.27,28 223.37,28 223.11,28.26 223.11,28.31 223.15,28.39 223.23,28.41 223.67,28.79 223.23,29.17 223.15,29.19 223.11,29.27 223.11,30.54 223.49,30.93 225.14,30.93
DL_1.35V on BOTTOM (solid shape): 140.69,17.84 140.69,17.46 140.44,17.21 137.13,17.21 136.88,17.46 136.88,17.84 137.13,18.1 140.44,18.1
DL_1.35V on BOTTOM (solid shape): 149.33,21.31 149.33,20.51 149.07,20.26 149.07,20.13 148.94,20 148.94,19.96 148.8,19.82 148.8,19.53 148.64,19.37 148.44,19.37 148.31,19.5 148.31,20.13 148.94,20.77 148.94,20.84 148.94,21.31 148.99,21.36 149.27,21.36
DL_1.35V on IN3 (solid shape): 149.15,20.31 149.13,20.27 149.08,20.11 149.11,19.95 149.11,19.88 149.06,19.82 148.87,19.58 148.92,19.27 148.94,19.24 147.12,17.42 147.11,17.42 146.97,17.33 146.88,17.19 146.88,17.18 146.79,17.08 139.55,17.08 139.29,17.34 139.29,17.84 139.55,18.1 146.28,18.1 148.69,20.51 148.94,20.51
DL_CHG on BOTTOM (solid shape): 219.56,23.18 219.56,22.8 219.3,22.54 217.02,22.54 216.76,22.8 216.76,23.18 217.02,23.43 219.3,23.43
DL_CHG on BOTTOM (solid shape): 226.41,27.75 226.41,26.86 225.78,26.23 225.53,26.23 225.27,26.48 225.27,27.5 225.53,27.75 226.03,27.75 226.16,27.88 226.29,27.88
DL_CHG on IN4 (solid shape): 220.19,23.18 220.19,22.29 220.06,22.16 218.16,22.16 218.03,22.29 218.03,23.05 218.29,23.31 220.06,23.31
DL_CHG on IN4 (solid shape): 226.29,27.24 226.29,26.4 226.26,26.33 226.19,26.3 225.97,26.21 225.84,26.01 225.83,25.97 224.64,25.97 224.38,26.23 224.38,27.24 224.64,27.5 226.03,27.5
LG_3V on TOP (solid shape): 34.77,50.74 34.77,49.72 34.52,49.47 34.52,48.58 34.39,48.45 34.01,48.45 33.88,48.58 33.88,49.59 33.63,49.85 33.63,50.74 33.76,50.86 34.64,50.86
LG_3V on BOTTOM (solid shape): 40,40.52 40,40.04 39.17,39.2 38.94,39.2 38.32,38.59 37.85,38.59 37.84,38.59 37.02,38.59 37.01,38.59 36.93,38.67 36.93,38.8 38.7,40.57 38.82,40.55 38.93,40.59 39.94,40.59
LG_3V on IN4 (solid shape): 39.34,41.09 39.34,39.69 38.45,38.8 37.69,38.8 37.51,38.98 37.51,39.51 38.07,40.07 38.07,40.96 38.33,41.21 39.22,41.21
LG_3V on IN4 (solid shape): 35.09,50.67 35.09,50.56 34.9,50.23 35.09,49.9 35.09,48.9 34.71,48.51 33.69,48.51 33.58,48.63 33.56,48.66 33.58,48.7 33.67,49.03 33.47,49.3 33.44,49.32 33.44,49.6 33.44,49.61 33.48,49.77 33.44,49.93 33.44,49.94 33.44,50.57 33.52,50.67 33.57,50.79 33.57,50.81 33.69,50.93 34.83,50.93
LG_5V on BOTTOM (solid shape): 37.96,32.78 37.96,31.88 37.83,31.75 36.97,31.75 36.87,31.85 36.87,32.82 36.92,32.87 37.87,32.87
LG_5V on BOTTOM (solid shape): 38.33,36.89 38.33,35.75 38.2,35.62 37.95,35.62 37.82,35.75 37.82,36.64 37.57,36.89 37.06,36.89 36.99,36.96 36.99,37.24 37.03,37.28 37.95,37.28
LG_5V on IN1 (solid shape): 38.52,33.78 38.52,32.18 38.1,31.76 37.36,31.76 37.17,31.95 37.17,33.74 37.46,34.04 38.26,34.04
LG_5V on IN1 (solid shape): 38.19,37.15 38.38,37.1 38.57,37.15 38.84,37.15 39.22,36.77 39.22,35.32 38.54,34.65 37.7,34.65 37.55,34.8 37.55,35.26 37.82,35.52 37.82,37.02 37.95,37.15
LG_+1.05VSP on TOP (solid shape): 43.28,54.55 43.28,53.15 43.03,52.9 42.39,52.9 42.14,53.15 42.14,54.42 42.39,54.67 43.15,54.67
LG_+1.05VSP on BOTTOM (solid shape): 41.63,63.18 41.83,63.18 42.52,63.18 42.77,62.93 42.77,62.42 42.52,62.17 41.38,62.17 41.25,62.29 41.25,62.55 40.87,62.93 40.49,62.93 39.86,63.55 39.86,64.08 39.98,64.2 40.61,64.2
LG_+1.05VSP on IN3 (solid shape): 43.79,55.18 43.79,53.4 43.53,53.15 42.52,53.15 42.14,53.53 42.14,55.18 42.52,55.56 43.41,55.56
LG_+1.05VSP on IN3 (solid shape): 42.44,62.66 42.44,62.09 42.84,61.7 42.84,61.09 42.58,60.83 41.57,60.83 41.18,61.21 41.18,62.3 41.2,62.4 41.18,62.5 41.18,62.57 41.36,62.75 42.35,62.75
LGATE1 on TOP (solid shape): 168.38,159.07 168.38,158.05 168.25,157.93 166.6,157.93 166.34,158.18 166.34,159.07 166.47,159.2 168.25,159.2
LGATE1 on TOP (solid shape): 174.47,159.07 174.47,157.93 174.34,157.8 172.57,157.8 172.44,157.93 172.44,159.07 172.57,159.2 174.34,159.2
LGATE1 on TOP (solid shape): 156.23,166.36 156.51,166.08 156.6,166.08 156.74,165.93 156.74,165.01 156.67,164.94 156.31,164.94 156.23,165.01 156.23,166.05 156.06,166.23 156.06,167.2 156.11,167.25 156.23,167.25
LGATE1 on IN1 (solid shape): 173.58,159.45 173.58,158.18 173.33,157.93 171.93,157.93 171.68,158.18 171.68,159.45 171.93,159.7 173.33,159.7
LGATE1 on IN1 (solid shape): 168.5,159.2 168.5,157.8 168.12,157.42 165.45,157.42 165.2,157.67 165.2,159.45 165.45,159.7 167.99,159.7
LGATE1 on IN1 (solid shape): 156.82,165.98 156.82,165.09 156.97,164.94 157.04,164.94 157.05,164.93 157.17,164.91 157.3,164.93 157.31,164.94 157.5,164.94 157.91,164.53 157.91,163.87 157.76,163.72 157.28,163.72 156.23,164.76 156.23,165.98 156.36,166.1 156.69,166.1
LGATE2 on TOP (solid shape): 180.95,159.07 180.95,157.93 180.82,157.8 179.04,157.8 178.92,157.93 178.92,159.07 179.04,159.2 180.82,159.2
LGATE2 on TOP (solid shape): 186.92,159.07 186.92,157.93 186.79,157.8 185.01,157.8 184.89,157.93 184.89,159.07 185.01,159.2 186.79,159.2
LGATE2 on TOP (solid shape): 157.63,167.15 158.14,167.15 158.98,166.31 158.98,165.93 158.85,165.8 157.96,165.8 157.25,166.51 157.25,167.32 157.3,167.37 157.4,167.37
LGATE2 on IN1 (solid shape): 186.35,159.32 186.35,158.05 186.09,157.8 184.69,157.8 184.44,158.05 184.44,159.32 184.69,159.58 186.09,159.58
LGATE2 on IN1 (solid shape): 180.19,160.08 180.19,159.7 181.08,158.81 181.2,158.81 181.2,157.67 180.69,157.16 178.92,157.16 178.66,157.42 178.66,160.08 178.92,160.34 179.93,160.34
LGATE2 on IN1 (solid shape): 159.15,166.21 159.25,166.21 159.25,166.2 159.38,166.18 159.51,166.2 159.52,166.21 159.59,166.21 159.61,166.18 160.37,166.18 160.5,166.05 160.5,165.29 160.37,165.16 159.61,165.16 159.6,165.18 159.56,165.14 159.16,165.14 158.85,165.32 158.54,165.14 158.34,165.14 157.55,165.93 157.55,166.56 157.68,166.69 158.67,166.69
LGATE3 on TOP (solid shape): 194.92,158.81 194.92,157.67 194.79,157.54 193.01,157.54 192.89,157.67 192.89,158.81 193.01,158.94 194.79,158.94
LGATE3 on TOP (solid shape): 201.01,158.81 201.01,157.67 200.89,157.54 199.11,157.54 198.98,157.67 198.98,158.81 199.11,158.94 200.89,158.94
LGATE3 on TOP (solid shape): 203.2,171.11 203.2,170.1 203.07,169.98 202.12,169.98 202.07,170.03 201.81,170.03 201.71,170.13 201.71,171.02 201.89,171.2 203.11,171.2
LGATE3 on IN3 (solid shape): 200.79,158.94 200.79,158.15 200.45,157.8 199.21,157.8 199.02,158 199.02,159.09 199.16,159.23 200.5,159.23
LGATE3 on IN3 (solid shape): 203.73,171.18 203.73,169.01 203.69,168.97 202.33,168.97 202.11,169.2 202.11,171.11 202.33,171.33 203.58,171.33
LGATE3 on IN4 (solid shape): 195.43,159.2 195.43,157.8 195.17,157.54 192.76,157.54 192.63,157.67 192.63,159.32 192.89,159.58 195.05,159.58
LGATE3 on IN4 (solid shape): 200.38,159.83 200.38,157.42 200.13,157.16 198.47,157.16 198.22,157.42 198.22,159.32 198.98,160.08 200.13,160.08
