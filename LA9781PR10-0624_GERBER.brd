# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_XDP_WAN_SMBCLK_R2: length 2.7
  BOTTOM w0.102: RH31.2 41.55,87.97 41.96,87.97 42.12,87.81 42.34,87.81 42.48,87.95 JXDP2.53
DDR_XDP_WAN_SMBDAT: length 307.1
  TOP w0.102: v2(126.57,46.6) 126.34,46.83 126.34,47.09 127,47.75 127,48.74 127.14,48.88 JDIMM3.200 ; v2(125.22,69.38) 125.42,69.18 125.73,69.18 126.95,67.95 126.95,65.39 127.14,65.2 JDIMM1.200 127.14,62.9 126.95,62.71 126.95,62.41 127.58,61.79 127.58,61.07 127.76,60.9 v2(127.79,60.9) ; v2(57.63,93.94) 57.83,94.14 57.83,94.29 57.59,94.53 53.76,94.53 47.74,88.51 40.71,88.51 39.98,87.77 39.75,87.77 v2(39.56,87.58) ; U88.6 179.59,41.47 R501.2 179.98,40.55 180.21,40.32 181.01,40.32 181.37,40.69 181.41,40.72 181.41,44.04 181.16,44.29 181.16,44.73 180.52,45.38 180.52,45.58 v2(180.34,45.76)
  IN1 w0.109: v2(180.34,45.76) 180.34,46.03 179.98,46.39 173.38,46.39 172.97,45.98 127.48,45.98 126.86,46.61 126.58,46.61 v2(126.57,46.6) ; v2(133.09,128.13) 132.92,127.96 132.13,127.96 131.11,126.93 131.11,120.74 127.37,117 127.37,96.96 127.17,96.76 127.17,87.72 126.33,86.88 126.33,69.75 125.81,69.24 125.36,69.24 v2(125.22,69.38)
  BOTTOM w0.102: v2(133.09,128.13) 133.3,127.93 133.32,127.93 133.53,128.13 133.53,138.15 131.17,140.5 128.83,140.5 127.92,141.42 126.01,141.42 125.73,141.7 U23.14 ; v2(125.22,69.38) 125.04,69.2 124.92,69.2 124.76,69.36 124.76,69.56 125.37,70.17 126.26,70.17 126.95,70.86 126.95,71.06 127.14,71.25 JDIMM2.200 127.14,73.4 126.95,73.59 126.95,74.29 129.03,76.37 129.03,87.36 125.04,91.35 123.77,91.35 123.24,91.88 123.24,96.12 121.71,97.65 108.87,97.65 106.46,95.24 87.7,95.24 86.17,96.76 60.15,96.76 57.86,94.47 57.86,94.17 v2(57.63,93.94) ; QH4.4 37.74,84.9 37.6,84.92 37.58,84.95 37.58,85.6 39.56,87.58 ; 39.56,87.58 v2(39.56,87.58) ; 39.56,87.58 39.76,87.77 39.95,87.77 RH30.1 ; v2(126.57,46.6) 126.29,46.88 126.29,47.79 124.51,49.57 124.51,52.57 125.96,54.01 125.96,55.95 127.14,57.13 JDIMM4.200 127.14,59.2 126.96,59.38 126.96,59.92 127.58,60.54 127.58,60.69 v2(127.79,60.9)
DDR_XDP_WAN_SMBDAT_R2: length 2.7
  BOTTOM w0.102: RH30.2 41.5,87.74 41.86,87.74 42.03,87.58 42.34,87.58 42.48,87.45 JXDP2.51
DEVICE_DET#: length 254.2
  TOP w0.102: v2(24.84,28.56) 24.26,27.99 JODD1.8
  IN3 w0.127: v2(231.04,38.34) 230.07,38.34 228.73,39.69 224.66,39.69 224.12,39.15 222.46,39.15 219.05,35.75 209.7,35.75 209.45,35.51 198.51,35.51 192.33,29.32 190.17,29.32 188.24,31.26 180.92,31.26 178.3,28.64 166.77,28.64 166.06,27.93 156.71,27.93 154,30.63 144.31,30.63 142.39,32.55 127.48,32.55 125.8,30.87 121.19,30.87 120.89,30.57 118.64,30.57 118.03,31.18 109.88,31.18 107.28,33.78 93.13,33.78 91.92,32.58 89.64,32.58 85.57,28.51 85.57,17.46 77.95,9.84 40.96,9.84 24.84,25.96 v2(24.84,28.56)
  BOTTOM w0.102: U51.B1 238.23,41.94 238.23,41.16 237.44,40.37 236.75,40.37 236.52,40.6 236.07,40.6 235.71,40.96 233.6,40.96 232.38,39.74 R1125.2 231.95,38.95 231.42,38.95 v1(231.28,38.81) 231.04,38.57 v2(231.04,38.34)
DEW1: length 5.7
  BOTTOM w0.102: U26.16 184.87,34.88 184.99,34.76 185.33,34.76 185.95,34.14 R84.2 R90.2 186.41,32.96 186.41,31.64 v1(186.57,31.47)
DEW2: length 4.5
  BOTTOM w0.102: U26.6 182.87,39.81 181.98,40.7 R85.2 R83.2 v1(179.92,41.25)
DGPU_ALERT#: length 262.8
  TOP w0.102: v2(211.17,70.27) 211.2,70.24 211.81,70.24 212.73,69.33 213.13,69.33 213.6,68.85 214.98,68.85 219.69,64.13 220.53,64.13 223.03,61.63 225.65,61.63 226.67,60.62 236.47,60.62 236.73,60.87 238.53,60.87 239.88,62.22 v2(239.9,62.22)
  IN1 w0.109: v2(211.17,70.27) 211.12,70.22 211.12,69.61 211.43,69.3 216.97,69.3 218.18,70.52 229.49,70.52 229.87,70.9 231.21,70.9 231.67,70.45 v2(231.67,70.42)
  BOTTOM w0.102: v2(211.17,70.27) 211.17,70.79 206.89,75.07 206.31,75.07 203.94,77.43 187.74,77.43 184.65,80.53 181.6,80.53 179.16,82.97 169.64,82.97 166.74,85.87 148.2,85.87 147.03,84.7 137.65,84.7 126.47,95.87 126.1,95.87 123.94,98.03 123.85,98.03 122.73,99.15 117.08,99.15 114.98,101.26 107.74,101.26 104.87,98.39 87.08,98.39 76.78,108.68 76.78,115.1 65.81,126.07 65.81,130.6 64.98,131.43 52.53,131.43 47.8,136.16 v1(47.8,136.89) 47.8,138.61 Q5.1 ; RP3.5 239.89,61.72 239.85,61.76 239.85,62.17 v2(239.9,62.22) ; v2(231.67,70.42) 232.05,70.42 232.32,70.16 U46.A42
DGPU_HOLD_RST#: length 155.1
  TOP w0.102: R19.2 110.03,130.77 110.03,128.28 109.56,127.81 U16.1 109.56,125.85 R51.1 109.07,125.36 v2(108.58,125.36) ; v2(116.31,68.44) 116.31,68.24 116.13,68.06 116.13,66.4 115.95,66.22 115.95,59.58 115.59,59.22 113.66,59.22 108.33,53.89 v1(103.54,53.89) 99.11,53.89 v2(99.03,53.96)
  IN1 w0.109: v2(116.31,68.44) 116.31,69.23 112.52,73.01 112.52,77 104.99,84.53 104.99,86.52 104.23,87.28 104.23,91.15 102.38,93 102.38,97.85 103.96,99.43 103.96,105.42 108.15,109.61 108.15,124.93 v2(108.58,125.36)
  BOTTOM w0.076: 72.41,57.09 72.41,57.95 72.66,58.19 UH1.A12
  BOTTOM w0.102: v2(99.03,53.96) 99.03,53.48 98.28,52.72 96.57,52.72 95.89,53.4 86.43,53.4 85.77,52.74 84.91,52.74 84.2,52.03 84.2,50.89 83.92,50.61 83.52,50.61 79.93,47.02 79.93,43.66 80.16,43.43 80.16,41.99 79.63,41.45 77.65,41.45 77.25,41.85 74.12,41.85 73.3,42.66 73.3,44.43 72.39,45.34 72.39,47.18 74.45,49.24 74.45,52.08 74.62,52.26 74.62,53.42 74.34,53.7 74.34,54.62 RH148.2 73.4,55.56 73.16,55.56 72.41,56.31 72.41,57.09
DGPU_PEX_RST#: length 109.2
  TOP w0.102: v2(109.09,143.4) 109.14,143.35 109.14,142.28 112.57,138.85 112.57,132.5 111.96,131.89 111.96,130.7 111.68,130.42 R38.2 R19.1 110.86,130.15 U16.4 ; JMXM1.184 79.94,143.86 79.35,143.27 79.35,141.31 v2(79.18,141.14)
  BOTTOM w0.102: Q4.2 v1(40.34,142.19) 40.34,146.35 43,149.01 67.49,149.01 74.01,142.48 77.84,142.48 v2(79.18,141.14) 79.18,138.29 80.51,136.96 86.37,136.96 88.58,139.17 99.52,139.17 102.35,141.99 102.35,143.63 103.13,144.41 108.08,144.41 v2(109.09,143.4)
DGPU_PWR_EN: length 296.8
  TOP w0.102: JMXM1.44 42.94,144.17 43.17,143.94 43.75,143.94 44.22,143.47 44.22,142.89 44.98,142.13 v2(44.98,141.44) ; v2(93.88,59.09) 93.67,58.89 v1(93.67,57.38) 93.67,55.28 89.64,51.25 RH132.1 RH113.2 88.75,50.55 QC5.1
  IN1 w0.109: v2(96.8,97.93) 96.8,88.18 98.35,86.63 98.35,84.74 97.38,83.78 97.38,80.53 98.32,79.59 98.32,76.57 99.03,75.86 99.03,71.15 97.48,69.6 97.48,66.18 97.18,65.88 97.18,62.06 95.31,60.19 94.97,60.19 v2(93.88,59.09) ; v2(234.93,71.26) 234.5,71.69 234.01,71.69 233.55,72.15 233.55,73.6 232.79,74.36 232.13,74.36 231.95,74.18 231.09,74.18 228.55,71.64 216.43,71.64 214.83,70.04 211.9,70.04 v2(211.61,69.74)
  BOTTOM w0.102: v2(211.61,69.74) 211.12,69.74 210.74,70.12 210.74,70.93 206.81,74.87 206.22,74.87 203.86,77.23 187.66,77.23 184.56,80.33 181.52,80.33 179.08,82.77 169.55,82.77 166.65,85.67 148.28,85.67 147.11,84.49 137.56,84.49 126.39,95.67 126.02,95.67 123.86,97.83 123.77,97.83 122.65,98.95 117,98.95 114.89,101.05 107.83,101.05 104.96,98.18 102.45,98.18 102.19,97.93 v2(96.8,97.93) 96.77,97.9 87.27,97.9 76.58,108.6 76.58,114.9 65.58,125.9 65.58,130.54 64.89,131.23 52.37,131.23 47.37,136.23 47.37,137.96 45.67,139.66 45.67,140.75 v2(44.98,141.44) ; U46.B45 233.79,70.41 234.21,70.83 234.49,70.83 234.93,71.27 v2(234.93,71.26)
DGPU_PWR_EN#: length 30.1
  TOP w0.102: RH328.2 86.51,50.86 QC5.2 85.99,50.75 84.86,49.62 v1(84.86,48.26) 84.86,46.46 v2(84.28,45.88)
  IN1 w0.109: v2(72.41,59.88) 72.11,59.58 72.11,55.5 73.02,54.58 73.02,52.08 75.98,49.12 77.01,49.12 78.49,47.63 82.83,47.63 84.28,46.18 v2(84.28,45.88)
  BOTTOM w0.089: v2(72.41,59.88) 72.66,59.64 UH1.C12
DGPU_PWROK: length 472.4
  TOP w0.102: v2(211.2,83.43) 217.75,83.43 219.05,84.72 222.53,84.72 224.05,83.2 224.59,83.2 226.37,81.42 229.5,81.42 229.7,81.22 236.29,81.22 236.52,80.99 236.78,80.73 236.78,80.73 238.28,79.24 238.28,77.47 238.25,77.45 238.25,77.05 238.56,76.75 238.56,76.06 238.12,75.63 v2(237.97,75.63) ; v2(130.33,121.6) v1(129.8,122.13) 128.8,123.13 128.8,128.74 130.05,129.99 130.05,134.1 128.71,135.43 124.92,135.43 123.77,134.28 122.76,134.28 122.39,133.91 ; R1977.2 42.44,147 JMXM1.42 42.44,144.24 42.94,143.74 43.67,143.74 44.02,143.39 44.02,142.8 44.32,142.5 44.32,141.42 47.27,138.47 48.49,138.47 v2(48.67,138.65) ; R135.1 115.92,133.6 116.1,133.43 U25.1 117.05,133.98 117.35,134.28 119.35,134.28 119.58,134.05 119.58,133.57 U14.1 119.86,133.58 119.86,134.05 120.09,134.28 122.22,134.28 122.39,134.11 122.39,133.91 ; 122.39,133.91 U27.1
  IN1 w0.109: v2(130.33,121.6) 127.07,124.85 127.07,126.23 125.35,127.95 124.18,127.95 124.13,127.9 120.55,127.9 120.06,127.42 118.95,127.42 117.93,128.44 117.93,128.77 117.17,129.53 114.52,129.53 114.29,129.3 109.98,129.3 108.95,130.33 83.84,130.33 83.15,129.64 66.48,129.64 65.02,131.09 53.53,131.09 49.68,134.94 49.68,137.78 48.82,138.65 v2(48.67,138.65) ; v2(220.72,53.87) 220.03,53.18 217.59,53.18 214.14,49.72 199.79,49.72 192.35,42.28 185.95,42.28 185.92,42.31 185.91,42.31 185.74,42.48 166.55,42.48 165.82,41.76 122.81,41.76 120.62,43.95 115.63,43.95 112.54,47.03 107.38,47.03 107.03,47.38 98.72,47.38 98.3,47.8 92.67,47.8 91.04,46.17 85.49,46.17 83.18,48.48 78.84,48.48 77.31,50.01 76.54,50.01 75.95,50.6 75.95,51.38 74.9,52.43 74.9,53.6 74.19,54.31 74.19,54.82 73.94,55.07 73.94,57.11 v2(73.4,57.65)
  IN2 w0.127: v2(237.97,75.63) 236.69,74.35 236.69,71.48 236.02,70.8 233.35,70.8 233.2,70.65 233.2,66.66 220.72,54.19 v2(220.72,53.87)
  BOTTOM w0.076: UH1.C14 73.47,59.21 73.58,59.09 73.58,58.79 73.76,58.61 73.76,58 v2(73.4,57.65)
  BOTTOM w0.102: U46.A56 237.98,75.63 v2(237.97,75.63) ; v2(130.33,121.6) 130.02,121.3 130.02,116.12 131.95,114.19 131.95,107.71 139.67,99.99 145.85,99.99 147.19,98.64 154.89,98.64 156.92,96.61 188.24,96.61 192.25,92.6 195.81,92.6 201.12,87.29 208.21,87.29 211.2,84.3 v2(211.2,83.43)
DGPU_SELECT#: length 265
  TOP w0.102: v2(98.53,148.96) 98.53,149.66 99.47,150.6 v1(99.47,153.56) 99.82,153.91 99.82,158.23 99.63,158.42 99.63,160.63 100.96,161.96 v2(100.96,162.6) ; v2(242.07,66.92) 241.65,67.34 240.92,67.34 240.46,67.8 237.88,67.8 237.39,67.31 237.39,65.3 236.82,64.73 234.83,64.73 234.68,64.58 233.79,64.58 233.11,65.27 229.7,65.27 229.25,64.81 224.54,64.81 223.7,65.65 220.29,65.65 213.99,71.95 211.77,71.95 209.98,73.74 209.98,74.74 v2(209.9,74.82)
  IN4 w0.109: v2(98.53,148.96) 98.53,146.65 97.18,145.3 97.18,143.88 v2(97.08,143.78) 97.05,143.75 97.05,140.5 98.78,138.77 98.78,138.05 103.82,133 103.82,125.82 104.31,125.33 104.31,121.44 103.99,121.12 103.99,114.07 103.35,113.43 103.35,109 103.05,108.7 103.05,104.79 v2(103.43,104.41)
  BOTTOM w0.102: v2(209.9,74.82) 209.9,75.32 207.34,77.89 206.54,77.89 205.75,78.68 198.28,78.68 192.24,84.72 189.23,84.72 188.16,85.79 179.5,85.79 179.4,85.69 169.48,85.69 165.52,89.65 154.11,89.65 152.08,87.62 146.69,87.62 145.57,86.5 139.36,86.5 126.18,99.68 124.54,99.68 123.67,100.55 118.63,100.55 114.72,104.46 105.52,104.46 105.16,104.1 103.73,104.1 v2(103.43,104.41) 103.07,104.05 98.77,104.05 98.69,104.14 U19.39 ; v2(242.07,66.92) 242.1,66.95 242.8,66.95 242.82,66.93 U46.B14 ; U11.27 95.78,148.43 95.86,148.35 96.51,148.35 96.58,148.27 97.99,148.27 98.53,148.81 v2(98.53,148.96) ; v2(100.96,162.6) 101.14,162.78 102.1,162.78 103.09,163.77 103.59,163.77 104.16,164.34 104.16,165.01 104.64,165.48 U3.1 ; U13.27 80.52,144.51 80.86,144.17 80.86,142.88 82.03,141.71 82.03,140.79 83.18,139.64 86.74,139.64 88.1,141 94.35,141 97.08,143.73 v2(97.08,143.78)
DGPU_THERMTRIP#: length 260.6
  TOP w0.102: v2(206.73,74.36) 206.73,71.49 209.09,69.13 209.09,64.01 218,55.11 223.11,55.11 226.54,51.68 226.54,50.99 230.73,46.8 v2(230.73,45.59)
  BOTTOM w0.102: R400.2 226.44,44.5 227.45,45.51 Q115.3 230.65,45.51 v2(230.73,45.59) 230.73,45.9 230.59,46.04 229.12,46.04 R1181.2 ; v2(206.73,74.36) 206.44,74.36 203.78,77.03 187.58,77.03 184.48,80.12 181.43,80.12 179,82.56 169.47,82.56 166.57,85.46 148.37,85.46 147.19,84.29 137.48,84.29 126.3,95.47 125.93,95.47 123.77,97.63 123.68,97.63 122.57,98.74 116.92,98.74 114.81,100.85 107.91,100.85 105.04,97.98 102.53,97.98 101.59,97.04 87.85,97.04 76.38,108.51 76.38,114.75 65.38,125.74 65.38,130.46 64.81,131.03 51.48,131.03 v1(49.22,133.29) 45.67,136.84 41.88,136.84 Q4.1 40.61,137.73 39.7,138.65 39.7,142.76 R11.2
DH_1.35V: length 1.8
  BOTTOM w0.102: v1(132.18,28.83) PQ201.4 132.18,27.04
  vias: v3(133.22,27.39) v3(133.2,26.76) v3(146.91,21.65) v3(147.55,21.65)
DH_CHG: length 12.9
  IN3 w1.016: 213.33,31.81 213.77,32.25 219.53,32.25 221.61,30.16 224.26,30.16
  BOTTOM w0.254: PU700.18 v3(224.66,29.05)
  vias: v1(212.99,31.01) v3(212.44,30.54) v3(213.33,30.54) v3(224,29.02)
DIMM1_SA0: length 11.6
  TOP w0.102: RD8.1 126.21,80.4 126.67,79.95 127.2,79.95 127.8,79.35 v1(127.8,78.94) 127.8,78.61 129.82,76.59 129.82,75.58 128.04,73.8 JDIMM1.197
DIMM1_SA1: length 7.7
  TOP w0.102: v1(124.46,76.77) 125.27,77.58 RD13.2 126.21,76.89 126.84,76.26 JDIMM1.201
DIMM2_SA0: length 14.8
  BOTTOM w0.102: JDIMM2.197 128.04,62.42 127.63,62.01 126.06,62.01 123.54,59.5 117.78,59.5 RD19.2 117.52,58.5 v1(117.09,58.06)
DIMM2_SA1: length 15.1
  BOTTOM w0.102: v1(115.84,58.36) 116.11,58.64 116.11,59.58 116.42,59.88 116.65,59.88 RD20.2 118.38,59.91 123.57,59.91 126.84,63.18 JDIMM2.201
DIMM3_SA0: length 17.5
  TOP w0.102: JDIMM3.197 128.04,60.03 127.76,60.31 127.13,60.31 126.47,59.66 125.56,59.66 124.55,60.67 117.52,60.67 116.98,60.12 116.98,58.52 v1(116.62,58.17) 116.25,57.8 RD26.1
DIMM3_SA1: length 16.9
  TOP w0.102: JDIMM3.201 126.84,59.24 126.62,59.46 125.44,59.46 124.43,60.47 117.66,60.47 117.21,60.01 117.21,57.02 RD27.1 v1(116.25,55.04)
DIMM4_SA0: length 5.9
  BOTTOM w0.102: RD37.2 130.77,46.11 v1(130.47,46.42) 130.05,46.84 129.36,46.84 128.31,47.89 128.31,48.56 128.04,48.83 JDIMM4.197
DIMM4_SA1: length 4.9
  BOTTOM w0.102: RD36.1 v1(128.23,47.27) 128.08,47.27 126.84,48.51 JDIMM4.201
DIS_BAT_PROCHOT#: length 32.5
  IN2 w0.127: v2(224.81,60.62) 224.81,63.49 227.13,65.8 227.13,66.38 229.84,69.1 231.9,69.1 232.28,69.48 232.28,70.45 231.38,71.36 231.38,71.99 231.78,72.39 233.18,72.39 233.67,72.88 233.67,74.22 v2(232.66,75.22)
  BOTTOM w0.102: v2(232.66,75.22) 232.97,74.92 232.97,74.28 233.63,73.62 U46.B51 ; PR1081.1 v1(225.09,54.7) 225.09,55.2 224.81,55.48 v2(224.81,60.62)
DIS_PROCHOT#: length 18.5
  BOTTOM w0.102: PQ706.2 238.03,21.29 237.95,21.2 PC736.1 237.29,21.2 236.7,21.78 v1(236.7,24.14) 236.7,24.31 236.31,24.7 235.71,24.7 234.77,23.76 233.98,23.76 PR716.1 232.97,23.76 231.88,23.76 PR740.2 231.42,22.43 231.67,22.17 231.67,20.94 231.14,20.41 PU703.7 229.87,20.41 228.95,19.5 PC735.1 PR735.1
DISP_ON: length 47.6
  TOP w0.102: JEDP1.2 129.99,156.91 129.69,157.21 129.69,157.84 129.21,158.32 126.4,158.32 126.31,158.41 v2(125.07,158.41) ; v2(98.53,161.3) 98.81,161.3 99.22,160.89 99.22,157.95 98.24,156.97 JLVDS1.2
  IN3 w0.127: v2(98.53,161.3) 98.74,161.09 109.11,161.09 110.01,160.19 123.29,160.19 v2(125.07,158.41)
  BOTTOM w0.102: v2(98.53,161.3) 98.53,161.18 R1138.1 98.98,161.62 D69.1 D64.1 100.23,162.03 D65.1 103,162.03 v1(103.41,161.62)
DK_AC_OFF: length 2.6
  BOTTOM w0.254: PU1001.25 262.47,35.02 263.37,35.93 PR1014.1
DK_AC_OFF_EN: length 2.3
  BOTTOM w0.254: PU1001.22 260.97,34.62 260.82,34.76 v1(260.82,35.32) 260.82,35.41 260.7,35.52 PR1020.1
DK_CSS_GC: length 231.4
  TOP w0.254: v2(209.4,84.49) 209.5,84.6 218.07,84.6 218.88,85.41 224.51,85.41 227.3,82.61 239.57,82.61 241.86,80.33 242.52,80.33 244.91,77.94 244.91,75.71 246.94,73.67 246.94,73.06 249.99,70.02 249.99,66.72 251,65.7 251,58.16 253.54,55.62 253.54,51.27 254.46,50.36 254.46,47.23 254.13,46.9 254.13,45.3 254.02,45.2 254.02,43.19 256.51,40.7 256.51,38.16 256.26,37.9 256.26,36.89 256.82,36.34 256.82,30.26 257.58,29.5 v2(257.58,29.43) ; PR714.1 128.5,128.19 127.99,127.69 120.71,127.69 v1(119.28,126.25) 119.28,123.71 119.63,123.36 119.63,122.19 117.6,120.16 117.6,119.62 117.83,119.39 v2(117.83,117.23)
  BOTTOM w0.254: v2(117.83,117.23) 116.58,115.99 116.58,111.49 122.56,105.51 126.31,105.51 129.11,102.72 129.11,101.78 136.67,94.22 178.17,94.22 180.31,92.09 187.26,92.09 191.07,88.28 193.71,88.28 198.82,83.17 208.61,83.17 209.4,83.96 v2(209.4,84.49) ; v2(257.58,29.43) 257.83,29.68 PU1001.11
DK_PWR_BAR: length 5.4
  BOTTOM w0.102: v1(269.11,29.19) 268.18,30.11 266.93,30.11 PR1007.2
  BOTTOM w0.254: PU1001.33 265.57,30.68 265.68,30.57 PR1007.2
DL_1.35V:
  vias: v1(139.04,17.62) v3(139.67,17.59) v3(140.31,17.59) v3(148.55,19.65) v3(148.8,20.23)
DL_CHG: length 8
  IN4 w1.016: 219.99,22.77 220.01,22.8 221.46,22.8 224.76,26.1 224.76,26.73
  BOTTOM w0.102: v3(219.01,22.94) v1(220.27,22.94)
  vias: v3(218.26,22.92) v3(225.63,27.12) v3(225.65,26.48)
DMI_CRX_PTX_N0: length 114
  TOP w0.089: v2(164.06,124.31) JCPU1.D21
  IN3 w0.089: 160.35,122.93 160.37,122.93 160.41,122.9 160.78,122.9 160.78,122.89 162.2,122.89 162.48,123.18 162.48,123.56 162.83,123.9 163.65,123.9 v2(164.06,124.31)
  IN3 w0.127: v2(76.15,79.39) 76.33,79.21 76.46,79.21 76.66,79.42 76.66,82.01 77.3,82.64 77.3,83.53 84.08,90.31 85.65,90.31 86.71,91.38 107.7,91.38 108.97,92.65 113.16,92.65 116.46,95.95 116.46,96.36 120.83,100.72 121.74,100.72 123.02,102 123.02,102.91 134.81,114.7 149.54,114.7 157.3,122.46 158.72,122.46 159.19,122.93 160.35,122.93
  BOTTOM w0.076: 76.19,77.32 76.19,77.3 76.22,77.28 76.22,76.96 76.09,76.84 76.09,76.69 76.17,76.62 UH1.BD21
  BOTTOM w0.102: v2(76.15,79.39) 75.94,79.39 75.74,79.19 75.74,78.3 76.19,77.85 76.19,77.32
DMI_CRX_PTX_N1: length 113.3
  TOP w0.089: JCPU1.C21 163.4,124.84 163.06,125.19 v2(163.06,125.31)
  IN3 w0.089: 160.58,123.95 160.6,123.95 160.64,123.91 162.23,123.91 162.46,124.14 162.46,124.62 162.72,124.89 162.93,124.89 163.06,125.02 v2(163.06,125.31)
  IN3 w0.127: 160.58,123.95 159.02,123.95 158.34,123.27 156.48,123.27 148.6,115.39 134.53,115.39 115.72,96.58 114.83,96.58 112.93,94.67 110.72,94.67 109.4,93.35 106.25,93.35 106.17,93.28 87.4,93.28 85.21,91.09 83.79,91.09 76.58,83.89 76.58,82.89 75.98,82.29 75.98,80.69 75.54,80.25 75.54,80.07 75.46,79.99 75.29,79.99 v2(75.11,80.18)
  BOTTOM w0.102: UH1.BE20 75.87,77.07 75.79,77.14 75.79,77.28 75.79,77.28 75.79,77.92 75.53,78.18 75.53,80.06 75.41,80.18 v2(75.11,80.18)
DMI_CRX_PTX_N2: length 132.9
  TOP w0.089: v2(162.06,125.31) 162.53,124.84 JCPU1.B21
  IN3 w0.089: 160.41,125.96 160.44,125.96 160.47,125.92 161.24,125.92 161.64,125.52 161.64,125.02 161.76,124.9 161.87,124.9 162.06,125.09 v2(162.06,125.31)
  IN3 w0.127: 160.41,125.96 159.64,125.96 159.53,125.84 158.92,125.84 153.06,131.7 132.5,131.7 129.46,128.66 129.46,118.91 127.69,117.14 127.69,115.74 124.48,112.53 123.34,112.53 118.59,107.79 118.59,101.41 115.19,98 110.36,98 108.07,95.72 107.26,95.72 107.04,95.49 87.2,95.49 84.23,92.52 80.47,92.52 78.33,90.39 77.57,90.39 76.91,89.73 76.91,86.2 74.81,84.09 74.81,83.61 74.07,82.87 74.07,79.79 74.42,79.44 74.42,78.83 74.18,78.59 74.05,78.59 v2(73.91,78.73)
  BOTTOM w0.076: UH1.BD17 74.67,76.61 74.76,76.52 74.89,76.52 74.98,76.62 74.98,76.76 74.77,76.97 74.77,77.4 74.79,77.43 74.79,77.45
  BOTTOM w0.102: 74.79,77.45 74.79,77.64 74.33,78.1 74.33,78.3 73.91,78.71 v2(73.91,78.73)
DMI_CRX_PTX_N3: length 125.5
  TOP w0.089: JCPU1.A21 161.53,124.84 v2(161.06,125.31)
  IN3 w0.127: v2(74.8,81.32) 74.85,81.27 74.99,81.27 75.29,81.57 75.29,82.56 75.9,83.17 75.9,84.19 78.06,86.35 78.06,88.28 81.61,91.83 84.7,91.83 87.6,94.73 107.42,94.73 107.67,94.98 108.51,94.98 110.82,97.29 115.47,97.29 129.14,110.96 129.14,117.54 133.66,122.07 133.66,128.39 136.24,130.98 152.59,130.98 153.84,129.72 153.84,129.23 154.94,128.13 155.63,128.13 158.82,124.93 160.68,124.93 v2(161.06,125.31)
  BOTTOM w0.076: UH1.BE18 75.02,77.07 74.95,77.14 74.95,77.31 75.03,77.39 75.18,77.39 75.22,77.44 75.22,77.54 74.84,77.92 74.84,78.13 74.81,78.15 74.81,78.16
  BOTTOM w0.102: 74.81,78.16 74.81,78.21 74.41,78.61 74.41,80.55 74.4,80.57 74.4,80.9 74.41,80.92 74.41,80.92 v2(74.8,81.32)
DMI_CRX_PTX_P0: length 114
  TOP w0.089: v2(164.06,123.31) JCPU1.D20
  IN3 w0.089: 160.35,122.69 160.37,122.69 160.41,122.72 160.7,122.72 160.71,122.71 162.27,122.71 162.66,123.1 162.66,123.49 162.9,123.73 163.64,123.73 v2(164.06,123.31)
  IN3 w0.127: 160.35,122.69 159.3,122.69 158.82,122.21 157.4,122.21 149.64,114.45 134.91,114.45 123.26,102.81 123.26,101.89 121.84,100.47 120.93,100.47 116.71,96.25 116.71,95.85 113.26,92.4 109.07,92.4 107.8,91.13 86.82,91.13 85.75,90.06 84.18,90.06 77.54,83.43 77.54,82.54 76.91,81.9 76.91,79.31 76.56,78.96 76.31,78.96 v2(76.15,78.8)
  BOTTOM w0.076: 76.41,77.32 76.41,77.3 76.38,77.28 76.38,76.97 76.58,76.77 76.58,76.48 76.44,76.27 UH1.BB21
  BOTTOM w0.102: v2(76.15,78.8) 75.96,78.61 75.96,78.39 76.41,77.94 76.41,77.32
DMI_CRX_PTX_P1: length 113.3
  TOP w0.089: v2(163.06,124.31) 163.53,123.84 JCPU1.C20
  IN3 w0.089: v2(163.06,124.31) 163.06,124.59 162.94,124.71 162.8,124.71 162.63,124.55 162.63,124.07 162.3,123.74 160.64,123.74 160.6,123.7 160.58,123.7
  IN3 w0.127: 160.58,123.7 159.12,123.7 158.44,123.03 156.59,123.03 148.7,115.14 134.63,115.14 115.82,96.33 114.93,96.33 113.03,94.43 110.82,94.43 109.5,93.1 106.35,93.1 106.28,93.03 87.51,93.03 85.32,90.84 83.89,90.84 76.83,83.78 76.83,82.79 76.22,82.18 76.22,80.58 75.79,80.15 75.79,79.97 75.56,79.74 75.28,79.74 v2(75.11,79.57)
  BOTTOM w0.102: UH1.BC20 75.91,76.27 75.78,76.75 75.58,76.95 75.58,77.07 75.58,77.07 75.58,77.83 75.31,78.09 75.31,79.36 v2(75.11,79.57)
DMI_CRX_PTX_P2: length 132.8
  TOP w0.089: v2(162.06,124.31) 162.53,123.84 JCPU1.B20
  IN3 w0.089: v2(162.06,124.31) 162.06,124.52 161.86,124.71 161.68,124.71 161.46,124.93 161.46,125.45 161.16,125.74 160.47,125.74 160.44,125.71 160.41,125.71
  IN3 w0.127: 160.41,125.71 159.74,125.71 159.63,125.6 158.82,125.6 152.96,131.45 132.61,131.45 129.71,128.56 129.71,118.81 127.94,117.03 127.94,115.64 124.58,112.28 123.44,112.28 118.84,107.68 118.84,101.3 115.29,97.75 110.46,97.75 108.18,95.47 107.36,95.47 107.14,95.24 87.3,95.24 84.33,92.27 80.57,92.27 78.44,90.14 77.67,90.14 77.16,89.62 77.16,86.09 75.06,83.99 75.06,83.5 74.32,82.77 74.32,79.9 74.67,79.55 74.67,78.73 74.28,78.34 74.14,78.34 v2(73.94,78.14)
  BOTTOM w0.076: 74.58,77.45 74.58,77.43 74.6,77.4 74.6,76.97 74.37,76.74 74.37,76.5 74.69,76.18 UH1.BB17
  BOTTOM w0.102: 74.58,77.45 74.58,77.55 73.98,78.14 v2(73.94,78.14)
DMI_CRX_PTX_P3: length 125.6
  TOP w0.089: JCPU1.A20 161.53,123.84 v2(161.06,124.31)
  IN3 w0.127: v2(161.06,124.31) 160.68,124.68 158.71,124.68 155.52,127.88 154.84,127.88 153.59,129.12 153.59,129.62 152.49,130.73 136.35,130.73 133.91,128.29 133.91,121.96 129.39,117.44 129.39,110.86 115.57,97.04 110.92,97.04 108.61,94.73 107.77,94.73 107.52,94.48 87.71,94.48 84.81,91.58 81.71,91.58 78.31,88.18 78.31,86.25 76.15,84.09 76.15,83.07 75.54,82.46 75.54,81.46 74.81,80.73 v2(74.8,80.73)
  BOTTOM w0.076: 75.03,78.16 75.03,78.14 75,78.12 75,77.99 75.39,77.61 75.39,77.01 75.17,76.64 75.17,76.24 UH1.BC18
  BOTTOM w0.102: v2(74.8,80.73) 74.62,80.56 74.62,78.7 75.03,78.3 75.03,78.16
DMI_CTX_PRX_N0: length 119.2
  TOP w0.089: JCPU1.D18 v2(165.06,122.31)
  IN3 w0.089: 76.96,75.18 76.96,75.17 76.93,75.14 76.93,74.68 76.73,74.48 76.56,74.48 v2(76.34,74.26) ; v2(165.06,122.31) 165.34,122.03 165.66,121.71 165.66,121.07 165.3,120.71 160.63,120.71 160.5,120.84 160.35,120.84 160.32,120.8 160.31,120.8
  IN3 w0.127: 76.96,75.18 76.96,76.65 78.28,77.97 78.28,81.32 85.53,88.56 86.59,88.56 87.6,89.57 115.62,89.57 117.2,91.15 121.31,91.15 122.46,92.3 122.46,95.91 126.24,99.69 126.24,103.85 135.48,113.09 150.21,113.09 157.92,120.8 160.31,120.8
  BOTTOM w0.102: UH1.AW22 76.54,74.26 v2(76.34,74.26)
DMI_CTX_PRX_N1: length 125.8
  TOP w0.089: v2(163.06,121.31) 163.53,120.84 JCPU1.C17
  IN3 w0.089: v2(163.06,121.31) 163.06,121.81 163.19,121.94 163.4,121.94 163.62,121.72 164.25,121.72 164.64,122.11 164.64,122.43 164.91,122.7 165.35,122.7 165.86,122.19 165.86,120.94 165.46,120.54 165.46,120.15 165.24,119.93 160.85,119.93 160.48,120.3 160.34,120.3 160.3,120.34 160.28,120.34 ; v2(76.33,73.01) 76.54,72.8 76.74,72.8 76.86,72.92 76.86,73.9 77.29,74.33 77.29,74.83 77.25,74.86 77.25,74.87
  IN3 w0.127: 160.28,120.34 158.07,120.34 150.39,112.66 135.66,112.66 127.49,104.48 127.49,100.19 122.91,95.62 122.91,92.06 121.08,90.23 117.45,90.23 116,88.78 108.66,88.78 108.31,88.43 104.52,88.43 103.89,89.06 88.92,89.06 87.57,87.71 85.29,87.71 78.72,81.14 78.72,77.71 77.4,76.39 77.4,75.43 77.25,75.28 77.25,74.87
  BOTTOM w0.102: v2(76.33,73.01) 76.06,72.75 UH1.AR20
DMI_CTX_PRX_N2: length 146.5
  TOP w0.089: v2(162.06,121.31) 162.53,120.84 JCPU1.B17
  IN3 w0.089: 74.72,75.75 74.72,75.74 74.75,75.71 74.75,72.89 74.98,72.66 75.17,72.66 v2(75.33,72.49) ; v2(162.06,121.31) 162.68,121.93 162.68,122.51 162.89,122.72 164.26,122.72 164.64,123.1 164.64,124.55 163.3,125.9 161.9,125.9 161.29,126.51 160.52,126.51 160.49,126.54 160.46,126.54
  IN3 w0.127: 160.46,126.54 159.22,126.54 153.35,132.41 132.17,132.41 128.76,128.99 128.76,119.24 126.6,117.08 126.6,115.64 124.28,113.32 123.11,113.32 116.61,106.82 116.61,100.42 114.93,98.74 109.75,98.74 108.43,97.42 102.46,97.42 101.44,96.4 86.81,96.4 83.69,93.28 79.73,93.28 78.43,91.98 77.24,91.98 76.03,90.77 76.03,86.53 72.95,83.45 72.95,77.64 74.72,75.87 74.72,75.75
  BOTTOM w0.102: UH1.AP17 74.99,72.15 v2(75.33,72.49)
DMI_CTX_PRX_N3: length 111.5
  TOP w0.089: v2(161.06,121.31) 161.53,120.84 JCPU1.A17
  IN3 w0.089: v2(75.33,74.31) 75.56,74.54 75.74,74.54 75.94,74.74 75.94,75.12 75.97,75.15 75.97,75.38 76.01,75.41 76.01,75.42
  IN3 w0.127: 76.01,75.42 76.01,77.44 77.6,79.03 77.6,81.62 85.27,89.3 86.01,89.3 87.1,90.39 108.02,90.39 108.81,91.17 114.04,91.17 117.44,94.58 117.44,95.97 121.01,99.54 122,99.54 124,101.54 124,102.57 135.19,113.77 149.93,113.77 157.66,121.5 159.84,121.5 160.12,121.78 160.66,121.78 161.06,121.38 v2(161.06,121.31)
  BOTTOM w0.102: UH1.AV20 75.7,73.94 v2(75.33,74.31)
DMI_CTX_PRX_P0: length 119.1
  TOP w0.089: JCPU1.D17 v2(165.06,121.31)
  IN3 w0.089: v2(76.35,74.88) 76.35,74.87 76.56,74.66 76.65,74.66 76.75,74.76 76.75,75.14 76.72,75.17 76.72,75.18 ; 160.31,121.05 160.33,121.05 160.37,121.02 160.58,121.02 160.7,120.89 165.23,120.89 165.48,121.15 165.48,121.64 165.26,121.86 165.1,121.86 165.02,121.78 165.02,121.35 v2(165.06,121.31)
  IN3 w0.127: 160.31,121.05 157.82,121.05 150.11,113.34 135.38,113.34 125.99,103.95 125.99,99.79 122.21,96.01 122.21,92.41 121.21,91.4 117.1,91.4 115.52,89.82 87.5,89.82 86.49,88.81 85.42,88.81 78.03,81.42 78.03,78.07 76.72,76.75 76.72,75.18
  BOTTOM w0.102: UH1.AY22 76.57,74.88 v2(76.35,74.88)
DMI_CTX_PRX_P1: length 125.8
  TOP w0.089: JCPU1.C18 163.53,121.84 v2(163.06,122.31)
  IN3 w0.089: v2(163.06,122.31) 163.25,122.12 163.47,122.12 163.69,121.9 164.18,121.9 164.46,122.18 164.46,122.5 164.84,122.87 165.43,122.87 166.04,122.26 166.04,120.87 165.64,120.47 165.64,120.08 165.31,119.76 160.77,119.76 160.4,120.13 160.34,120.13 160.3,120.09 160.28,120.09 ; 77.5,74.87 77.5,74.85 77.47,74.82 77.47,74.26 77.04,73.83 77.04,72.84 76.82,72.63 76.52,72.63 v2(76.32,72.43)
  IN3 w0.127: 160.28,120.09 158.18,120.09 150.49,112.41 135.76,112.41 127.74,104.38 127.74,100.09 123.16,95.51 123.16,91.96 121.18,89.99 117.55,89.99 116.1,88.53 108.76,88.53 108.41,88.18 104.41,88.18 103.78,88.81 89.02,88.81 87.68,87.47 85.39,87.47 78.97,81.04 78.97,77.61 77.65,76.29 77.65,75.32 77.5,75.18 77.5,74.87
  BOTTOM w0.102: UH1.AP20 76.04,72.15 v2(76.32,72.43)
DMI_CTX_PRX_P2: length 146.5
  TOP w0.089: v2(162.06,122.31) 162.53,121.84 JCPU1.B18
  IN3 w0.089: 74.96,75.75 74.96,75.74 74.93,75.71 74.93,72.96 75.06,72.84 75.13,72.84 75.18,72.89 75.3,72.89 75.33,72.92 v2(75.33,73.08) ; 160.46,126.29 160.49,126.29 160.52,126.33 161.21,126.33 161.82,125.72 163.22,125.72 164.46,124.48 164.46,123.18 164.18,122.9 162.82,122.9 162.5,122.58 162.5,122 162.18,121.68 161.77,121.68 161.67,121.78 161.67,122.06 161.92,122.31 v2(162.06,122.31)
  IN3 w0.127: 160.46,126.29 159.12,126.29 153.25,132.16 132.28,132.16 129.01,128.89 129.01,119.14 126.85,116.98 126.85,115.53 124.38,113.07 123.21,113.07 116.86,106.72 116.86,100.31 115.04,98.49 109.85,98.49 108.53,97.17 102.56,97.17 101.55,96.15 86.92,96.15 83.79,93.03 79.83,93.03 78.54,91.73 77.34,91.73 76.27,90.67 76.27,86.43 73.2,83.35 73.2,77.74 74.96,75.97 74.96,75.75
  BOTTOM w0.102: v2(75.33,73.08) 75,72.75 UH1.AR17
DMI_CTX_PRX_P3: length 111.5
  TOP w0.089: v2(161.06,122.31) 161.53,121.84 JCPU1.A18
  IN3 w0.089: v2(75.33,74.94) 75.56,74.71 75.67,74.71 75.77,74.81 75.77,75.2 75.79,75.22 75.79,75.38 75.76,75.41 75.76,75.42
  IN3 w0.127: 75.76,75.42 75.76,77.55 77.35,79.14 77.35,81.73 85.17,89.55 85.91,89.55 86.99,90.64 107.92,90.64 108.71,91.42 113.94,91.42 117.19,94.68 117.19,96.08 120.9,99.78 121.89,99.78 123.75,101.64 123.75,102.68 135.09,114.02 149.82,114.02 157.55,121.75 159.74,121.75 160.01,122.03 160.78,122.03 v2(161.06,122.31)
  BOTTOM w0.102: v2(75.33,74.94) 75.74,74.54 UH1.AW20
DMI_IREF: length 2.6
  TOP w0.102: RH98.1 73.33,77.9 v1(72.9,78.33)
  TOP w0.254: RH98.1 73.71,77.28 v2(73.99,77.56)
  BOTTOM w0.254: UH1.BE16 74.28,77.17 73.99,77.47 v2(73.99,77.56)
DMI_RCOMP: length 4.1
  TOP w0.089: 73,75.27 73.01,75.29 73.01,75.96 73.32,76.26 RH100.2
  TOP w0.102: RH100.2 73.81,75.78 73.81,75.3 74.16,74.95 v2(74.35,74.95) ; v1(72.63,74.91) 73,75.27
  BOTTOM w0.102: v2(74.35,74.95) 74.54,75.13 UH1.AY17
DMIC0: length 76
  TOP w0.102: v2(17.91,80.52) 17.41,80.02 17.41,79.16 15.95,77.7 JIO1.85 ; JCAM1.13 9.65,126.3 18.87,126.3 24.05,121.12 27.08,121.12 v2(27.3,121.35)
  IN1 w0.109: v2(24.08,104.51) 23.77,104.2 20.57,104.2 18.62,102.25 18.62,96.69 14.71,92.77 14.71,87 17.76,83.94 17.76,82.17 17.47,81.88 17.47,80.95 v2(17.91,80.52)
  BOTTOM w0.102: v2(24.08,104.51) v1(24.98,105.41) 25.47,105.91 25.47,119.76 26.86,121.15 27.1,121.15 v2(27.3,121.35)
DMIC_CLK: length 74.7
  TOP w0.102: JCAM1.11 10.86,126.1 18.79,126.1 23.97,120.92 27.15,120.92 v2(27.3,120.76) ; JIO1.83 16.26,78.3 17.21,79.25 17.21,81.05 17.93,81.78 v2(18.05,81.78)
  IN1 w0.109: v2(18.05,81.78) 17.97,81.85 17.97,84.03 14.92,87.08 14.92,92.6 18.83,96.52 18.83,102.16 20.66,103.99 24.2,103.99 v2(24.74,104.53)
  BOTTOM w0.102: v2(24.74,104.53) 25.69,105.49 25.69,119.69 26.95,120.94 27.13,120.94 v2(27.3,120.76)
DOCK_AC_OFF: length 409.2
  TOP w0.102: v1(87.94,124.45) 88.05,124.35 v2(88.44,124.35)
  IN1 w0.109: v2(88.44,124.35) 87.6,123.5 87.6,122.85 85.11,120.36 83.58,120.36 79.82,116.6 67.78,116.6 61.66,110.47 53.46,110.47 45.94,102.96 26.06,102.96 24.47,101.37 20.61,101.37 19.24,100 19.24,81.48 23.89,76.84 24.87,76.84 29.25,72.45 35.48,72.45 36.15,73.12 39.76,73.12 42,70.88 43.34,70.88 49.64,64.57 49.64,62.83 49.91,62.56 49.91,62.55 49.97,62.49 49.97,47.97 67.57,30.37 68.46,30.37 70.65,28.18 90.85,28.18 95.3,32.63 98.98,32.63 99.41,32.2 108.87,32.2 110.41,30.65 116.33,30.65 118.1,28.88 123.41,28.88 125.21,30.68 153.89,30.68 156.67,27.9 177.45,27.9 178.3,28.75 192.41,28.75 200.69,37.02 204.82,37.02 206.23,38.44 218.44,38.44 223.39,33.49 234.43,33.49 v2(234.81,33.11)
  IN3 w0.127: v2(234.81,33.11) 235.88,32.04 235.88,28.49 236.51,27.86 236.51,23.12 241.36,18.26 243.11,18.26 246.59,14.78 250.73,14.78 v2(251.14,15.19)
  BOTTOM w0.102: JDOCK1.2 81.74,125.36 82.17,124.93 87.86,124.93 v2(88.44,124.35) ; PR1031.2 240.9,28.74 239.16,30.48 236.89,30.48 234.81,32.56 v2(234.81,33.11)
  BOTTOM w0.254: PD1010.1 251.11,15.22 v2(251.14,15.19)
DOCK_AC_OFF_EC: length 55.9
  TOP w0.102: v2(255.6,38.04) 252.45,41.19 250.95,41.19 250.26,41.87 250.26,42.36 252.22,44.31 252.22,50.1 251,51.32 251,55.37 250.52,55.85 250.52,57.36 250.11,57.77 250.11,64.81 247.85,67.07 244.73,67.07 244.47,67.32 244.47,68.67 244.42,68.72 244.42,70.02 244.85,70.45 244.85,71.46 241.81,74.51 v2(241.81,75.63)
  BOTTOM w0.102: U46.A63 241.48,75.3 v2(241.81,75.63) ; v2(255.6,38.04) 255.69,38.13 257.59,38.13 v1(257.85,38.38) 258.06,38.6 259.61,38.6 260.7,37.5 PR1020.2 PR1018.1
DOCK_DCIN_IS+: length 18.7
  TOP w0.102: v2(118.41,128.54) 118.62,128.74 120.66,128.74 v1(120.88,128.52) 121.44,127.97 126.22,127.97 PR715.1 126.74,128.49 127.93,128.49 128.22,128.78 128.22,131.95 128.13,132.04 127.3,132.04 127.16,131.9 PQ703.6
  BOTTOM w0.102: v2(118.41,128.54) 117.75,128.54 116.74,127.52 JDOCK1.134
DOCK_DCIN_IS-: length 8.7
  TOP w0.102: v2(117.8,127.98) v1(117.8,128.5) 117.8,128.56 118.18,128.94 123.61,128.94 PR713.2
  BOTTOM w0.102: v2(117.8,127.98) 117.24,127.41 JDOCK1.136
DOCK_DET#: length 169.1
  TOP w0.102: v2(234.9,69.13) 234.9,69.28 234.59,69.58 234.01,69.58 233.32,68.9 231.06,68.9 230,67.83 228.92,67.83 228.69,68.06 224.56,68.06 221.51,71.11 217.02,71.11 215.37,72.76 212.11,72.76 210.92,73.95 210.92,75.71 211.78,76.57 211.78,80.33 v2(209.85,82.26)
  BOTTOM w0.102: v2(209.85,82.26) 209.85,84.65 209.32,85.18 198.36,85.18 194.17,89.37 191.52,89.37 187.71,93.18 180.76,93.18 178.55,95.39 155.53,95.39 153.52,97.4 150.36,97.4 149.27,96.3 136.13,96.3 130.2,102.24 130.2,103.17 126.46,106.91 122.75,106.91 117.73,111.93 117.73,113.51 v1(119.91,115.69) 120.17,115.95 120.17,119.7 119.21,120.65 119.21,121.38 119.89,122.06 119.89,123.41 119.07,124.22 119.07,125.29 120.14,126.35 120.14,127.53 121.83,129.22 D32.2 121.88,131.26 R755.2 ; U46.B41 233.91,68.41 234.09,68.59 234.45,68.59 234.9,69.03 v2(234.9,69.13)
DOCK_DET_R#: length 7.5
  BOTTOM w0.102: D32.1 v1(119.26,130.04) 118.82,129.59 118.82,128.33 118.74,128.25 JDOCK1.142 118.74,125.84 118.87,125.72 119.11,125.72 119.24,125.84 JDOCK1.144
DOCK_HP_DET: length 329.5
  TOP w0.102: JIO1.65 15.1,83.7 15.27,83.53 16.94,83.53 v2(17.35,83.12)
  IN4 w0.109: v2(17.35,83.12) 17.35,83.07 16.73,82.45 15.62,82.45 14.85,81.68 14.85,79.3 14.94,79.21 14.94,75.44 20.69,69.69 22.21,69.69 22.3,69.6 22.54,69.6 22.55,69.59 26.29,69.59 26.47,69.41 30.06,69.41 30.81,70.16 34.17,70.16 35.22,69.1 38.29,69.1 40.32,67.07 41.69,67.07 43.36,65.4 43.36,64.67 47,61.03 47,55.96 50.81,52.16 50.81,47.51 61.63,36.68 75.81,36.68 77.08,35.41 96.04,35.41 97.11,36.49 101.87,36.49 103.38,37.99 112.89,37.99 113.32,37.56 120.28,37.56 121.28,36.56 166.78,36.56 167.46,35.88 173.98,35.88 174.53,35.33 180.78,35.33 181.46,36.01 188.04,36.01 189.13,37.09 189.72,37.09 189.72,37.09 189.89,37.09 192.08,39.28 198.36,39.28 200.43,41.34 204.47,41.34 204.8,41.01 207.15,41.01 208.62,42.48 219.5,42.48 221.87,40.12 222.63,40.12 227.43,35.32 229.16,35.32 230.83,33.65 231.96,33.65 232.86,32.75 234.57,32.75 234.72,32.61 244.73,32.61 246.92,34.8 249.34,34.8 250.6,36.06 250.6,38.92 251.29,39.62 251.29,40.66 251.92,41.29 251.92,43.09 251.63,43.38 251.63,49.16 253.69,51.22 253.69,53.89 255.24,55.44 255.24,58.36 254.63,58.97 v2(254.51,58.97)
  BOTTOM w0.102: v2(254.51,58.97) 254.71,59.17 254.71,61.07 252.58,63.21 v1(252.58,68.67) 252.58,68.99 250.56,71.01 248.55,71.01 247.86,70.32 246.07,70.32 245.87,70.52 244.85,70.52 244.68,70.35 244.19,70.35 244,70.16 U46.A7
DOCK_LOM_ACTLED_YEL#: length 41.9
  TOP w0.102: U32.19 117.58,102.56 118.44,103.42 118.44,104.75 116.72,106.46 v1(116.43,106.46) 115.93,106.46 v2(115.9,106.49)
  IN3 w0.127: v2(108.58,124.75) 109.9,126.07 117.87,126.07 119.17,124.78 119.17,123.77 119.8,123.14 119.8,121.99 118.99,121.18 118.99,117.74 115.9,114.64 v2(115.9,106.49)
  BOTTOM w0.102: JDOCK1.100 108.24,125.78 108.08,125.62 108.08,125.26 v2(108.58,124.75)
DOCK_LOM_SPD10LED_GRN#: length 41
  TOP w0.102: v2(104.49,102.63) 104.63,102.76 105.76,102.76 106.06,103.06 U32.40
  BOTTOM w0.102: v2(104.49,102.63) 101.37,102.63 98.5,99.76 90.14,99.76 v1(84.97,104.93) 81.35,108.55 81.35,111.27 81.94,111.85 81.94,116.33 82.54,116.93 82.54,117.56 82.24,117.86 JDOCK1.3
DOCK_LOM_SPD100LED_ORG#: length 57.8
  TOP w0.102: U32.20 117.79,103.06 118.24,103.5 118.24,104.66 117.01,105.89 v2(115.9,105.89) ; v2(97.89,122.7) v1(98.69,122.7)
  IN3 w0.127: v2(97.89,122.7) 97.66,122.47 97.66,119.88 99.95,117.59 99.95,115.59 100.03,115.51 100.03,114.38 100.89,113.53 100.89,109.44 104.16,106.16 105.38,106.16 106.78,104.76 115.26,104.76 115.9,105.4 v2(115.9,105.89)
  BOTTOM w0.102: JDOCK1.4 82.24,125.87 82.98,125.13 88.31,125.13 89.41,124.04 96.16,124.04 97.51,122.7 v2(97.89,122.7)
DOCK_LOM_TRD0+: length 28.7
  TOP w0.089: U32.22 115.1,107.24 114.74,107.59 114.43,107.59 v2(114.31,107.71)
  IN3 w0.114: v2(114.31,107.71) 114.47,107.71 114.58,107.61 114.58,107.38 114.48,107.28 113.73,107.28 112.58,108.43 111.58,108.43 110.56,109.46 110.56,116.11 109.5,117.16 109.5,122.17 109.61,122.28 109.61,122.64 109.5,122.75 109.5,123.09 109.61,123.2 109.61,123.55 109.5,123.66 109.5,124.12 109.73,124.35 109.96,124.35 110.08,124.22 v2(110.08,124.02)
  BOTTOM w0.089: JDOCK1.104 109.24,124.47 109.66,124.05 110.04,124.05 v2(110.08,124.02)
DOCK_LOM_TRD0-: length 28.6
  TOP w0.089: v2(114.31,106.8) 114.22,106.89 114.22,107.15 114.32,107.25 114.6,107.25 114.76,107.1 114.76,105.14 114.6,104.98 U32.23
  IN3 w0.114: v2(110.08,124.75) 110.04,124.71 109.57,124.71 109.13,124.27 109.13,117.01 110.19,115.95 110.19,109.3 111.43,108.06 112.42,108.06 113.58,106.91 114.2,106.91 v2(114.31,106.8)
  BOTTOM w0.089: v2(110.08,124.75) 110.21,124.63 110.21,124.52 110.08,124.4 109.8,124.4 109.58,124.62 109.58,125.67 109.74,125.83 JDOCK1.106
DOCK_LOM_TRD1+: length 29.4
  TOP w0.089: U32.26 113.1,107.3 114.23,108.43 114.23,110.18 113.51,110.91 112.39,110.91 112.09,110.6 111.54,110.6 v2(111.49,110.66)
  IN3 w0.114: v2(111.48,123.94) 111.4,124.02 111.4,124.13 111.5,124.24 112.07,124.24 112.57,123.74 112.57,123.35 112.46,123.24 112.46,122.88 112.57,122.77 112.57,122.43 112.46,122.32 112.46,121.96 112.57,121.85 112.57,116.47 112.03,115.93 112.03,110.44 111.79,110.21 111.38,110.21 111.29,110.3 111.29,110.45 v2(111.49,110.66)
  BOTTOM w0.089: v2(111.48,123.94) 111.44,123.98 111.03,123.98 110.58,124.43 110.58,125.7 110.74,125.87 JDOCK1.110
DOCK_LOM_TRD1-: length 29.4
  TOP w0.089: v2(111.48,109.79) 111.38,109.9 111.38,110.09 111.55,110.26 112.23,110.26 112.53,110.57 113.36,110.57 113.89,110.04 113.89,108.57 112.76,107.44 112.76,105.19 112.6,105.03 U32.27
  IN3 w0.114: v2(111.48,124.65) 111.52,124.61 112.22,124.61 112.94,123.89 112.94,116.32 112.4,115.78 112.4,110.29 111.95,109.84 111.53,109.84 v2(111.48,109.79)
  BOTTOM w0.089: JDOCK1.112 111.24,125.76 111.15,125.67 111.05,125.67 110.92,125.54 110.92,124.58 111.17,124.32 111.45,124.32 111.58,124.45 111.58,124.55 v2(111.48,124.65)
DOCK_LOM_TRD2+: length 27.8
  TOP w0.089: U32.31 110.6,105.03 110.44,105.19 v3(110.44,106.49) 110.44,106.98 113,109.54 113.21,109.54 113.32,109.43 113.32,109.27 v2(113.18,109.13)
  IN3 w0.114: v2(113.56,125.31) 113.61,125.27 114.04,125.27 114.49,124.81 114.49,121.15 115.19,120.45 115.19,116.52 114.96,116.3 114.96,110.29 113.85,109.18 113.22,109.18 v2(113.18,109.13)
  BOTTOM w0.089: JDOCK1.122 113.74,125.87 113.99,125.63 113.99,125.12 113.78,124.92 113.63,124.92 113.46,125.08 113.46,125.21 v2(113.56,125.31)
DOCK_LOM_TRD2-: length 27.8
  TOP w0.089: v2(113.18,110.02) 113.04,109.89 112.86,109.89 110.1,107.13 U32.32
  IN3 w0.114: v2(113.56,124.5) 113.41,124.65 113.41,124.75 113.56,124.9 113.88,124.9 114.12,124.66 114.12,120.99 114.82,120.3 114.82,116.67 114.59,116.45 114.59,110.44 113.7,109.55 113.12,109.55 112.97,109.7 112.97,109.82 v2(113.18,110.02)
  BOTTOM w0.089: v2(113.56,124.5) 113.64,124.57 113.92,124.57 114.33,124.98 114.33,125.77 114.24,125.86 JDOCK1.124
DOCK_LOM_TRD3+: length 35.1
  TOP w0.089: U32.35 108.6,107.11 109.84,108.36 109.84,110.87 109.4,111.31 108.96,111.31 v2(108.87,111.39)
  IN3 w0.114: v2(108.87,111.39) 109.01,111.39 109.14,111.27 109.14,111.09 109.03,110.97 108.5,110.97 108.23,111.24 108.23,111.78 108.34,111.89 108.34,112.25 108.23,112.36 108.23,112.7 108.34,112.81 108.34,113.17 108.23,113.28 108.23,123.55 107.91,123.88 107.91,125.43 109.67,127.18 111.86,127.18 112.95,128.27 114.9,128.27 114.98,128.18 v2(114.98,127.96)
  BOTTOM w0.089: v2(114.98,127.96) 114.93,127.96 114.83,128.06 114.83,128.14 114.98,128.29 115.23,128.29 115.4,128.12 115.4,127.68 115.24,127.52 JDOCK1.128
DOCK_LOM_TRD3-: length 35.1
  TOP w0.089: U32.36 108.1,105.06 108.26,105.22 108.26,107.26 109.5,108.5 109.5,110.72 109.26,110.97 108.88,110.97 108.74,110.8 108.74,110.68 v2(108.87,110.55)
  IN3 w0.114: v2(108.87,110.55) 108.82,110.61 108.34,110.61 107.86,111.08 107.86,123.4 107.54,123.72 107.54,125.58 109.51,127.55 111.7,127.55 112.79,128.64 114.93,128.64 v2(114.98,128.69)
  BOTTOM w0.089: JDOCK1.130 115.74,128.27 115.38,128.63 115.04,128.63 v2(114.98,128.69)
DOCK_MIC_DET: length 298.7
  TOP w0.102: JIO1.67 15.17,83.1 15.66,82.61 16.28,82.61 v2(16.74,83.07)
  IN3 w0.127: v2(202.34,40.88) 203.12,40.88 205.4,43.17 206.7,43.17 210.38,46.84 210.38,48.14 213.94,51.7 220.29,51.7 220.99,52.4 223.1,52.4 225.5,54.8 225.5,57.81 228.51,60.82 234.64,60.82 234.8,60.97 244.55,60.97 245.69,62.12 245.69,63.13 246.4,63.84 246.4,67.65 245.36,68.69 243.54,68.69 v2(242.17,70.07)
  IN4 w0.109: v2(16.74,83.07) 16.33,82.66 13.58,82.66 12.42,81.5 12.42,80.57 14.1,78.89 14.1,75.11 20.35,68.87 21.87,68.87 21.97,68.77 25.95,68.77 26.13,68.59 38.51,68.59 40.24,66.86 41.61,66.86 43.15,65.31 43.15,64.58 46.79,60.94 46.79,55.87 50.6,52.07 50.6,47.42 61.54,36.47 75.72,36.47 76.99,35.2 96.12,35.2 97.2,36.28 101.96,36.28 103.46,37.78 112.81,37.78 113.23,37.35 117.46,37.35 119.7,35.12 167.55,35.12 168.1,35.67 173.89,35.67 174.44,35.12 180.89,35.12 181.5,35.73 188.54,35.73 188.65,35.62 189.65,35.62 189.89,35.86 189.89,36.77 192.2,39.07 198.45,39.07 198.46,39.08 198.59,39.08 200.39,40.88 v2(202.34,40.88)
  BOTTOM w0.102: v2(242.17,70.07) 242.33,69.91 U46.B8 ; v2(202.34,40.88) v1(202.34,40.25)
DOCK_POR_RST#: length 179.4
  TOP w0.102: v2(208.35,83.68) 207.8,83.12 207.8,79.04 208.84,78 208.84,76.08 208.28,75.53 208.28,73.31 210.23,71.35 210.23,69.91 211.45,68.69 212.88,68.69 213.69,67.88 213.69,67.25 215.54,65.39 215.81,65.39 218.98,62.23 218.98,61.02 220.6,59.4 225.3,59.4 229.59,55.11 236.12,55.11 237.51,53.71 239.55,53.71 v2(240.16,53.1)
  BOTTOM w0.102: JDOCK1.140 118.24,125.85 117.33,124.94 117.33,123.22 117.42,123.13 117.42,121.76 119.56,119.62 119.56,116.93 117.32,114.69 117.32,111.76 122.75,106.32 v1(123.58,106.32) 126.47,106.32 129.79,103 129.79,102.07 135.99,95.87 149.55,95.87 150.67,96.99 153.34,96.99 155.42,94.91 178.46,94.91 180.59,92.77 187.55,92.77 191.36,88.96 194,88.96 198.67,84.29 207.75,84.29 v2(208.35,83.68) ; RP7.8 241.78,54.09 C737.1 240.16,53.35 v2(240.16,53.1) 240.16,53 241.3,51.85 U51.A21
DOCK_PSID: length 125.1
  TOP w0.102: v2(35.08,108.8) 35.93,109.65 45.24,109.65 50.73,115.15 60.77,115.15 62.58,116.97 80.68,116.97 82.36,118.64 91.1,118.64 93.32,120.87 96.02,120.87 97.29,119.6 103.52,119.6 105.09,121.17 105.09,123.22 106.07,124.19 107.54,124.19 109.57,122.16 v1(110.82,122.16) 111.17,122.16 112,122.99 v2(113.55,122.99) ; v2(9.68,101.74) 9.19,101.74 7.86,100.41 PU1.1
  IN1 w0.109: v2(35.08,108.8) 33.81,107.54 16.41,107.54 10.62,101.74 v2(9.68,101.74)
  BOTTOM w0.102: JDOCK1.135 117.24,119.68 113.93,122.99 v2(113.55,122.99)
DOCK_PWR_BTN#: length 174.6
  TOP w0.102: v2(231.14,39.56) 231.14,40.86 229.69,42.3 229.69,46.11 226.57,49.24 225.86,49.24 222.38,52.72 220.6,52.72 219.63,53.68 219.63,53.94 219.23,54.34 215.82,54.34 208.41,61.76 208.41,68.69 205.61,71.49 205.61,82.23 207.02,83.64 207.12,83.64 v2(207.14,83.66)
  BOTTOM w0.102: JDOCK1.139 118.24,117 116.86,115.63 116.86,111.61 122.68,105.79 126.43,105.79 129.39,102.83 129.39,101.9 136.78,94.5 178.29,94.5 180.42,92.37 187.38,92.37 191.19,88.56 193.83,88.56 198.73,83.66 v1(204.84,83.66) v2(207.14,83.66) ; v2(231.14,39.56) 231.14,39.38 230.55,38.8 230.55,38.16 230.81,37.91 232.84,37.91 C733.1 R825.2
DOCK_PWR_SW#: length 281.3
  IN1 w0.109: v2(58.39,83.55) 57.96,83.12 57.96,80.27 56.6,78.91 56.18,78.91 54.16,76.88 50.58,76.88 50.01,76.31 50.01,74.59 51.9,72.7 52.57,72.7 53.67,71.6 53.67,65.8 53.47,65.6 53.47,59.91 52.68,59.12 52.68,47.62 64.33,35.97 65.3,35.97 67.72,33.54 90.83,33.54 91.83,34.54 109.32,34.54 111.19,32.67 116.98,32.67 117.29,32.36 154.69,32.36 157.29,29.76 176.57,29.76 178.23,31.42 191.95,31.42 199.25,38.71 204.15,38.71 205.59,40.16 219.45,40.16 220.06,39.54 228.97,39.54 229.41,39.1 230.07,39.1 v2(230.53,39.56)
  BOTTOM w0.102: U10.1 41.74,103.58 40.79,102.63 40.79,99.98 41.92,98.85 v1(46.84,98.85) 47.28,98.85 59.36,86.78 59.36,84.52 v2(58.39,83.55) ; v2(230.53,39.56) 230.2,39.23 230.2,37.88 230.38,37.71 234.31,37.71 234.75,38.14 234.75,38.93 R825.1 C734.1 R819.2 238.71,39.38 239.8,40.48 U51.A63
DOCK_SMB_ALERT#: length 316.7
  TOP w0.102: v2(209.27,82.82) 209.4,82.69 217.91,82.69 218.54,83.33 222.27,83.33 226.01,79.59 235.38,79.59 v2(235.43,79.54) ; v2(266.7,53.48) 264.39,51.17 264.39,39.03 267.37,36.04 267.37,28.04 264.73,25.4 264.73,21.77 263.24,20.28 263.24,19.13 257.39,13.27 243.58,13.27 241.88,14.97 237.49,14.97 236.66,14.15 232.07,14.15 227.96,18.25 227.96,20.03 226.77,21.22 219.76,21.22 219.63,21.1 218.31,21.1 215.29,18.07 215.29,14.29 211.76,10.76 206.86,10.76 205.48,9.39 205.48,8.88 203.91,7.3 PQ1.3
  IN3 w0.127: v2(235.43,79.54) 235.43,80.02 236.1,80.69 236.1,82.07 237.14,83.1 241.65,83.1 242.54,82.22 248.58,82.22 252.72,78.08 256.3,78.08 263.85,70.52 263.85,65.62 266.75,62.73 267.99,62.73 268.73,61.99 268.73,55.51 v2(266.7,53.48)
  BOTTOM w0.102: JDOCK1.133 116.74,117.94 116.15,117.35 v1(116.15,114.73) 116.15,111.53 122.45,105.23 126.2,105.23 128.83,102.6 128.83,101.67 136.55,93.94 178.06,93.94 180.19,91.81 187.15,91.81 190.96,88 193.6,88 198.7,82.89 209.19,82.89 v2(209.27,82.82) ; v2(235.43,79.54) 235.51,79.46 235.51,77.89 R763.2 236.07,76.92 235.48,76.33 U46.A51
DOCK_SMB_CLK: length 176.3
  TOP w0.102: v2(239.11,43.73) 239.1,43.74 237.96,43.74 237.23,43.02 235.86,43.02 235.69,42.84 235.03,42.84 234.32,42.13 232.36,42.13 231.82,42.66 231.65,42.66 v2(231.47,42.84) 231.29,42.66 230.74,42.66 230.33,43.07 230.33,46.74 226.74,50.33 225.91,50.33 224.48,51.75 224.48,52.38 221.96,54.9 217.92,54.9 208.87,63.95 208.87,69.03 206.04,71.86 206.04,81.63 206.49,82.08 207.03,82.08 v2(207.21,81.9)
  BOTTOM w0.102: JDOCK1.127 115.24,117.8 115.38,117.67 115.38,111.69 122.32,104.75 126.07,104.75 126.56,104.26 128.4,102.42 128.4,101.49 136.37,93.51 177.81,93.51 179.94,91.38 186.84,91.38 190.65,87.57 193.42,87.57 198.91,82.08 207.03,82.08 v2(207.21,81.9) ; U51.B4 239.05,43.67 239.11,43.73 v2(239.11,43.73) ; R841.2 231.95,42.36 v2(231.47,42.84)
DOCK_SMB_DAT: length 174.3
  TOP w0.102: v2(207.21,82.49) 207.03,82.31 206.4,82.31 205.81,81.73 205.81,71.76 208.64,68.93 208.64,63.85 217.82,54.67 221.87,54.67 224.26,52.29 224.26,51.66 225.81,50.1 226.64,50.1 230.1,46.65 230.1,42.98 230.64,42.43 231.73,42.43 232.26,41.9 234.42,41.9 235.12,42.61 236.16,42.61 v2(236.17,42.6)
  BOTTOM w0.102: v2(207.21,82.49) 207.03,82.31 199,82.31 193.51,87.8 190.75,87.8 186.94,91.61 180.03,91.61 177.9,93.74 136.47,93.74 128.62,101.58 128.62,102.52 126.16,104.98 v3(125.8,104.98) 122.41,104.98 115.6,111.79 115.6,117.67 115.74,117.8 JDOCK1.129 ; 236.17,42.61 v2(236.17,42.6) ; 236.17,42.61 235.64,42.61 R838.2 ; 236.17,42.61 236.97,43.42 U51.A3
DOCKED: length 262.2
  TOP w0.102: v2(113.08,100.19) 113.13,100.24 113.13,100.65 113.1,100.68 U32.13 ; v2(35.97,145.12) 35.97,145.83 35.76,146.04 31.29,146.04 30.89,145.63 25.86,145.63 24.47,147.02 Q326.2
  IN4 w0.109: v2(113.08,100.19) 113.59,100.7 115.06,100.7 115.19,100.57 116.86,100.57 119.41,103.12 120.5,103.12 125.07,98.55 125.07,96.48 130.79,90.76 166.86,90.76 171.65,85.97 174.74,85.97 183.26,77.44 197.65,77.44 205.71,69.38 205.71,68.47 207.08,67.09 207.96,67.09 211.4,63.65 218.37,63.65 219.48,64.77 228.2,64.77 230.73,67.3 231.24,67.3 v2(232,68.05)
  BOTTOM w0.102: v2(35.97,145.12) v1(36.44,144.65) 38.35,142.74 38.35,139.21 41.12,136.44 45.49,136.44 51.1,130.82 64.65,130.82 65.18,130.3 65.18,125.66 76.17,114.66 76.17,108.43 87.76,96.84 101.68,96.84 102.62,97.78 105.13,97.78 106.5,99.15 110.69,99.15 111.73,100.19 v2(113.08,100.19) ; U46.A38 232.1,68.16 v2(232,68.05)
DOCKED#: length 5.2
  TOP w0.102: U9.45 27,150.26 26.39,149.64 R518.2 26.9,148.48 26.9,147.66 26.74,147.51 26.74,147.04 Q326.1
DP_A_MXM_AUX_Q: length 8.3
  BOTTOM w0.102: Q340.5 286.61,63.55 286.39,63.78 285.62,63.78 285.41,63.56 285.41,62.55 Q340.2 286.61,60.77 v1(287.07,60.31) 287.3,60.08 R2193.2 288.5,60.32 Q339.3
DP_CFG0: length 6.7
  TOP w0.102: U9.44 26.6,150.26 25.5,149.16 R64.2 R61.2 24,148.37 24,147.93 23.43,147.36 23.43,146.89 23.18,146.63 v1(22.57,146.63)
DP_CFG1: length 3.5
  TOP w0.102: U9.29 24.93,156.84 v1(24.1,157.67) R72.2 R73.2
DP_MB_P14: length 19
  TOP w0.102: R801.2 v1(296.11,133.29) 296.76,133.29 298.3,134.82 298.3,141.16 295.71,143.75 JDP1.14
DP_RP_CEXT: length 3.9
  BOTTOM w0.102: C87.1 v1(280.28,70.49) 280.36,70.57 280.36,71.34 281.07,72.04 U22.2
DP_RP_CFG0: length 3.4
  BOTTOM w0.102: U22.5 280.61,73.54 v1(280.29,73.22) R77.1 R76.2
DP_RP_CFG1: length 3.6
  BOTTOM w0.102: U22.40 286.42,69.75 v1(286.71,69.46) 287.25,68.92 R78.2 R79.1
DP_RP_PEQ: length 4.4
  BOTTOM w0.102: R81.1 R80.2 279.83,71.44 v1(280.3,71.91) 280.36,71.97 280.36,72.73 280.67,73.04 U22.4
DP_RP_REXT: length 2.5
  BOTTOM w0.102: U22.7 v1(280.41,74.54) 280.29,74.54 279.98,74.23 R75.2
DPC_CA_DET: length 64.3
  TOP w0.102: v2(78.89,114.72) 78.87,114.75 70,114.75 v2(68.17,112.92) 65.58,110.33 61.26,110.33 60.93,110 v1(60.93,105.74) 60.93,104.1 59.87,103.04 55.68,103.04 v2(54.92,103.8) U20.1 ; v2(57.2,106.36) 56.87,106.03 U20.4
  IN3 w0.127: v2(54.92,103.8) 54.92,104.11 57.17,106.36 v2(57.2,106.36)
  BOTTOM w0.102: Q110.2 C1174.1 68.65,113.4 v2(68.17,112.92) ; v2(78.89,114.72) 79.5,115.33 79.5,117.34 80.44,118.28 80.44,119.47 81.33,120.36 81.33,121.53 81.02,121.83 81.02,123.64 81.33,123.94 81.33,125.44 81.05,125.72 81.05,129.05 81.76,129.76 R492.2 82.37,130.44 82.37,129.88 82.74,129.51 JDOCK1.6
DPC_CA_DET#: length 19.2
  TOP w0.102: v2(55.57,112.23) 55.57,112.23 U20.13 ; v2(57.61,112.21) 57.52,112.12 U20.10
  IN1 w0.109: v2(57.61,112.21) 57.56,112.15 55.65,112.15 v2(55.57,112.23)
  BOTTOM w0.102: R1532.2 Q110.5 Q110.6 68.79,111.33 68.53,111.6 v1(60.97,111.6) 58.22,111.6 v2(57.61,112.21)
DPC_DOCK_AUX: length 9.3
  TOP w0.102: U20.2 55.57,104.41 55.75,104.23 56.34,104.23 56.54,104.03 56.54,103.96 56.37,103.8 v2(56.36,103.8)
  BOTTOM w0.102: v2(56.36,103.8) 56.47,103.91 v3(56.47,108.05) 56.47,109.21 56.87,109.61 56.87,110.1 C387.1
DPC_DOCK_AUX#: length 9.3
  TOP w0.102: v2(56.95,103.8) 56.84,103.8 56.77,103.87 56.77,104.1 56.92,104.25 57.41,104.25 57.52,104.36 U20.5
  BOTTOM w0.102: v2(56.95,103.8) 56.94,103.8 56.7,104.03 v3(56.7,105.69) 56.7,109.12 57.1,109.51 57.1,110.07 C388.1
DPC_DOCK_LANE_C_N0: length 1.3
  BOTTOM w0.102: R2173.2 83.46,132.3 83.46,132.62 C438.1
