# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.35V_MEM on BOTTOM (solid shape): 128.75,26.23 128.75,25.87 128.75,24.4 129.18,23.96 129.18,23.79 129.16,23.76 128.6,23.76 128.52,23.76 128.5,23.74 128.5,23.25 128.45,23.2 128.07,23.2 128.04,23.23 128.04,23.74 128.01,23.76 127.4,23.76 127.35,23.76 127.34,23.75 127.31,23.75 127.31,23.72 127.3,23.71 127.3,23.23 127.28,23.2 126.85,23.2 126.82,23.23 126.82,23.66 126.82,23.74 126.8,23.76 126.16,23.76 126.11,23.81 124.03,23.81 123.98,23.76 123.32,23.76 123.29,23.74 123.29,23.23 123.27,23.2 122.83,23.2 122.81,23.23 122.81,23.66 122.81,23.74 122.8,23.75 122.78,23.76 122.2,23.76 122.15,23.76 122.13,23.75 122.1,23.75 122.1,23.72 122.1,23.71 122.1,23.23 122.07,23.2 121.64,23.2 121.61,23.23 121.61,23.64 121.61,23.74 121.59,23.76 121.49,23.76 120.55,23.76 120.5,23.81 120.5,24.19 122.91,26.61 128.37,26.61
+1.35V_MEM on BOTTOM (solid shape): outline of 105 points within 167.87,115.76 188.82,118.3
+1.35V_MEM on BOTTOM (solid shape): 155.09,48.58 155.17,48.55 155.2,48.48 155.24,48.32 155.34,48.2 155.38,48.12 155.34,48.03 155.26,47.56 155.73,47.44 155.83,47.43 155.88,47.34 156.18,46.71 156.88,46.67 157.39,46.62 157.79,46.94 158.27,47.32 157.77,47.67 157.73,47.72 157.68,47.77 157.68,48.35 157.63,48.4 157.61,48.52 157.7,48.58 164.95,48.58 165.33,48.2 165.33,45.78 164.95,45.4 149.83,45.4 149.58,45.66 149.58,48.32 149.83,48.58
+1.35V_MEM on BOTTOM (solid shape): outline of 347 points within 149.71,73.47 165.45,82.87
+1.35V_MEM on IN2 (solid shape): outline of 11205 points within 146.79,46.8 189.71,113.6
+1.35V_MEM on IN3 (solid shape): outline of 2135 points within 168.2,113.78 190.71,118.49
+1.35V_MEM on IN4 (solid shape): outline of 1787 points within 168.08,114.06 189.67,118.75
+1.35V_MEM on VCC: 152.73,39.31 149.45,42.59 149.45,48.3 148.44,49.32 148.44,61.17 149.33,62.06 149.33,65.19 148.31,66.21 148.31,72.24 147.36,73.19 147.36,73.96 145.26,76.05 145.26,85.86 148.95,89.55 149.68,89.55 151.21,91.07 151.77,91.07 153.24,92.55 154.26,92.55 159.72,98.01 162.74,98.01 165.5,100.77 165.5,100.93 165.51,100.93 165.71,100.93 168.02,103.24 168.33,103.24 169.04,103.95 169.16,103.95 169.39,104.18 169.39,108.6 169.39,108.7 168.63,109.46 168.63,118.25 168.68,118.3 187.63,118.3 187.81,118.12 187.81,115.81 187.55,115.56 187.55,114.16 187.37,113.98 186.99,113.98 186.79,113.78 186.79,104.15 188.97,101.94 189.08,101.84 189.08,101.79 188.95,101.67 188.95,92.27 179.62,82.94 179.47,82.94 169.16,72.64 169.16,71.72 168.35,70.91 168.35,68.16 167.56,67.38 167.56,64.63 168.3,63.89 169.26,63.89 169.26,61.64 167.61,59.99 167.61,56.85 168.38,56.09 168.38,42.59 167.94,42.15 165.1,39.31
+1.35V_MEN_P on TOP (solid shape): 127.56,21.3 127.56,13.68 126.95,13.07 122.22,13.07 121.77,13.53 121.77,21.3 122.22,21.76 127.1,21.76
+1.35V_MEN_P on BOTTOM (solid shape): 146.02,27.37 146.02,25.78 146,25.76 145.85,25.51 146,25.27 146.02,25.25 146.02,24.45 145.9,24.32 145.9,23.94 145.39,23.94 145.39,23.43 145.9,23.43 145.9,23.18 145.01,23.18 144.88,23.31 144.88,26.2 145.02,26.44 144.88,26.68 144.88,27.37 145.13,27.62 145.77,27.62
+1.35V_MEN_P on BOTTOM (solid shape): outline of 139 points within 110.76,17.59 129.16,27.27
+1.35V_MEN_P on IN3 (solid shape): 138.02,27.62 145.77,27.62 146.02,27.37 146.02,27.12 145.77,26.86 144.88,26.86 144.63,27.12 137.64,27.12 134.97,29.78 130.28,29.78 127.23,26.73 121.13,26.73 120.75,26.35 120.75,25.72 120.62,25.59 120.37,25.59 120.24,25.72 120.24,26.73 120.88,27.37 126.72,27.37 129.77,30.42 135.23,30.42
+3.3V_ALW on TOP (solid shape): 111.73,173.67 111.73,172.72 111.56,172.55 109.3,172.55 109.19,172.66 109.19,173.67 109.45,173.93 111.48,173.93
+3.3V_ALW on TOP (solid shape): 101.7,74.23 101.7,74.16 101.7,73.63 101.7,73.58 101.7,72.96 101.45,72.71 100.56,72.71 100.3,72.96 100.3,74.11 100.56,74.36 101.57,74.36
+3.3V_ALW on TOP (solid shape): 101.95,166.94 102.84,166.94 102.97,166.82 102.97,166.18 102.52,165.73 102.47,165.69 102.43,165.64 102.21,165.42 100.61,165.42 100.21,165.02 97.28,165.02 97.08,165.23 97.08,165.88 97,165.96 97,168.09 97.64,168.72 100.18,168.72
+3.3V_ALW on TOP (solid shape): 73.76,41.97 74.33,41.97 75.03,41.27 75.03,40.58 74.78,40.32 74.22,40.32 74.22,40.32 74.01,40.32 73.76,40.07 73.76,39.94 73.51,39.69 73,39.69 72.87,39.82 72.87,40.45 72.74,40.58 72.74,41.64 72.75,41.65 72.77,41.77 72.75,41.9 72.74,41.9 72.74,41.97 73,42.23 73.51,42.23
+3.3V_ALW on TOP (solid shape): outline of 153 points within 99.54,28.83 110.82,38.55
+3.3V_ALW on TOP (solid shape): outline of 191 points within 54.96,43.75 61.19,56.83
+3.3V_ALW on TOP (solid shape): outline of 450 points within 150.21,20.51 161.01,31.43
+3.3V_ALW on BOTTOM (solid shape): 55.6,15.81 55.6,14.67 55.47,14.54 54.71,14.54 54.2,15.05 54.2,15.69 54.46,15.94 55.47,15.94
+3.3V_ALW on BOTTOM (solid shape): 251.18,69.61 251.18,67.88 251.13,67.83 249.71,67.83 249.66,67.88 249.66,69.79 249.91,70.04 250.75,70.04
+3.3V_ALW on BOTTOM (solid shape): 276.2,38.29 276.2,37.28 275.94,37.02 273.4,37.02 273.28,37.15 273.28,38.42 273.35,38.49 276,38.49
+3.3V_ALW on BOTTOM (solid shape): 15.21,142.62 15.21,141.42 15.09,141.29 13.56,141.29 13.46,141.39 13.46,141.49 13.44,141.49 13.44,142.81 13.5,142.88 14.96,142.88
+3.3V_ALW on BOTTOM (solid shape): 248.39,75.38 248.39,74.36 248.13,74.11 246.86,74.11 246.66,74.31 246.66,74.61 246.68,74.64 247.17,74.64 247.22,74.69 247.22,75.07 247.19,75.1 246.68,75.1 246.66,75.12 246.66,75.43 246.99,75.76 248,75.76
+3.3V_ALW on BOTTOM (solid shape): 230.22,76.39 230.22,75.45 230.22,75.38 230.35,75.25 230.35,73.34 229.84,72.84 229.34,72.84 228.91,73.26 228.85,73.34 228.77,73.4 228.7,73.47 228.7,74.23 228.95,74.49 228.95,76.14 229.34,76.52 230.1,76.52
+3.3V_ALW on BOTTOM (solid shape): 155.8,21.53 155.8,20.64 155.55,20.38 154.72,20.38 154.71,20.39 154.58,20.41 154.46,20.39 154.45,20.38 154.15,20.38 154.02,20.51 154.02,21.15 154.28,21.4 154.66,21.4 154.76,21.5 154.77,21.51 155.04,21.78 155.55,21.78
+3.3V_ALW on BOTTOM (solid shape): 255.75,54.04 255.75,53.02 255.62,52.9 254.1,52.9 253.03,53.96 252.42,53.96 252.35,54.04 252.35,54.27 252.4,54.32 252.86,54.32 252.91,54.37 252.91,54.75 252.88,54.78 252.37,54.78 252.35,54.8 252.35,55.11 252.42,55.18 254.61,55.18
+3.3V_ALW on BOTTOM (solid shape): 109.62,31.89 109.62,31.43 109.62,31.43 109.62,31.38 109.65,31.36 110.13,31.36 110.16,31.38 110.16,31.43 110.17,31.43 110.17,31.9 110.18,31.92 110.39,31.92 110.41,31.89 110.41,31.38 110.44,31.36 110.92,31.36 110.95,31.38 110.95,31.43 110.97,31.43 110.97,31.92 111.23,31.92 111.43,31.71 111.43,29.39 110.95,28.91 109.38,28.91 109.12,29.17 109.12,31.82 109.22,31.92 109.6,31.92
+3.3V_ALW on BOTTOM (solid shape): 254.46,38.13 254.46,36.49 253.14,35.17 253.13,35.17 253.01,35.09 252.93,34.97 252.93,34.96 252.83,34.86 251.05,34.86 250.8,35.12 250.8,35.88 251,36.08 251.09,36.1 251.17,36.03 251.83,35.98 251.37,36.46 251.28,36.47 251.23,36.55 251.23,36.94 251.69,37.4 252.7,37.4 253.59,38.29 254.29,38.29
+3.3V_ALW on BOTTOM (solid shape): 60.68,47.44 60.68,43.63 57.38,40.32 53.21,40.32 53.16,40.37 53.16,40.88 53.19,40.91 53.59,40.91 53.67,40.91 53.69,40.93 53.69,41.54 53.69,41.59 53.68,41.6 53.68,41.62 53.67,41.62 53.64,41.64 53.16,41.64 53.16,42.1 53.59,42.1 53.67,42.1 53.69,42.13 53.69,42.74 53.69,42.81 53.67,42.84 53.19,42.84 53.16,42.86 53.16,43.35 53.44,43.63 54.33,43.63 54.71,44.01 54.71,45.91 54.46,46.17 53.67,46.17 53.64,46.19 53.64,46.6 53.64,46.67 53.62,46.7 53.01,46.7 52.93,46.7 52.91,46.67 52.91,46.6 52.91,46.16 52.88,46.14 52.5,46.14 52.45,46.19 52.45,46.6 52.45,46.67 52.42,46.7 51.81,46.7 51.74,46.7 51.71,46.67 51.71,46.6 51.71,46.16 51.69,46.14 50.93,46.14 50.65,46.42 50.65,47.69 51.03,48.07 60.04,48.07
+3.3V_ALW on IN1 (solid shape): outline of 272 points within 28.68,85.79 36.42,89.59
+3.3V_ALW on IN1 (solid shape): outline of 1100 points within 153.39,4.76 211.43,24.45
+3.3V_ALW on IN2 (solid shape): 69.78,62.8 70.02,62.7 70.26,62.79 70.28,62.8 70.39,62.8 70.4,62.79 70.64,62.7 70.87,62.79 70.89,62.8 71,62.8 71.01,62.79 71.23,62.73 71.44,62.8 71.73,62.8 71.98,62.55 71.98,62.47 71.94,62.39 71.84,62.38 71.64,62.41 71.45,62.32 71.38,62.29 71.32,62.32 71.1,62.4 70.87,62.32 70.81,62.3 70.74,62.33 70.51,62.43 70.27,62.34 70.2,62.32 70.14,62.34 69.55,62.08 70.13,61.8 70.2,61.82 70.26,61.8 70.49,61.71 70.71,61.79 70.78,61.81 70.85,61.78 71.09,61.68 71.33,61.78 71.4,61.8 71.47,61.78 71.65,61.7 71.84,61.73 71.94,61.73 71.98,61.64 71.98,61.53 71.84,61.39 71.76,61.36 71.69,61.39 71.37,61.51 71.1,61.31 71.08,61.28 70.39,61.28 70.07,61.47 69.76,61.28 69.66,61.28 69.58,61.31 69.56,61.39 69.33,61.78 68.91,61.64 68.87,61.6 68.81,61.66 68.81,62.42 69.19,62.8
+3.3V_ALW on IN2 (solid shape): outline of 725 points within 251.18,27.88 275.69,39.94
+3.3V_ALW on IN2 (solid shape): outline of 944 points within 227.94,72.33 268.45,83.88
+3.3V_ALW on IN2 (solid shape): outline of 2899 points within 11.66,122.75 124.05,142.56
+3.3V_ALW on IN4 (solid shape): outline of 929 points within 54.84,36.77 100.94,47.94
+3.3V_ALW on VCC: outline of 108 points within 27.15,30.8 302.83,176.18
+3.3V_ALW_PCH on TOP (solid shape): 66.8,41.29 66.8,38.49 66.6,38.29 64.29,38.29 63.52,39.05 63.52,39.36 65.76,41.59 66.5,41.59
+3.3V_ALW_PCH on BOTTOM (solid shape): 57.91,65.6 58.9,65.6 59.03,65.47 59.03,64.32 58.98,64.27 58.98,63.89 58.9,63.82 58.39,63.82 57,65.22 57,65.57 57.15,65.72 57.79,65.72
+3.3V_ALW_PCH on BOTTOM (solid shape): 57.89,62.5 59.03,62.5 59.16,62.37 59.16,60.84 59,60.69 58.22,60.69 57.9,61.01 57.88,61.05 57.9,61.08 57.83,61.64 57.28,61.53 56.49,61.53 56.23,61.79 56.23,63.31 56.36,63.44 56.95,63.44
+3.3V_ALW_PCH on IN2 (solid shape): outline of 2416 points within 51.41,47.82 79.35,71.57
+3.3V_ALW_PCH on IN4 (solid shape): outline of 445 points within 75.92,64.58 80.62,69.91
+3.3V_ALW_PCH_JTAG on IN3 (solid shape): 59.03,70.55 59.03,68.14 58.77,67.88 57.89,67.88 57.63,68.14 57.63,70.55 57.89,70.8 58.77,70.8
+3.3V_ALW_PCH_PWR on TOP (solid shape): 68.73,41.11 68.73,39.97 69.34,39.36 69.77,39.36 70.76,38.37 71.42,38.37 71.47,38.32 71.47,37.61 71.35,37.48 67.26,37.48 66.95,37.78 66.95,39.26 67.51,39.26 67.51,39.82 66.95,39.82 66.95,40.07 67.51,40.07 67.51,40.63 66.95,40.63 66.95,41.09 67.26,41.39 68.45,41.39
+3.3V_ALW_U46 on BOTTOM (solid shape): 247.12,76.39 247.12,76.14 246.51,75.53 246.51,75.02 246.56,74.97 247.04,74.97 247.06,74.94 247.06,74.79 247.04,74.77 246.53,74.77 246.51,74.74 246.51,74.38 246.35,74.23 245.59,74.23 245.46,74.36 245.46,75.63 246.48,76.65 246.86,76.65
+3.3V_ALW_U46 on IN2 (solid shape): outline of 2127 points within 235.18,61.79 248.26,79.57
+3.3V_ALW_U51 on BOTTOM (solid shape): 252.22,55.03 252.22,54.67 252.25,54.65 252.78,54.65 252.78,54.47 252.75,54.45 252.35,54.45 252.27,54.45 252.26,54.43 252.25,54.43 252.25,54.35 252.22,54.32 252.22,53.99 252.25,53.96 252.25,53.92 252.29,53.92 252.37,53.84 252.4,53.84 252.51,53.72 252.5,53.69 252.47,53.55 252.5,53.42 252.49,53.32 252.41,53.28 252.14,53.28 252.14,53.3 251.38,53.3 251.38,53.23 251.18,53.02 251.18,52.64 251.1,52.57 250.11,52.57 249.91,52.77 249.91,53.28 250.16,53.53 250.16,54.29 250.42,54.55 251.18,54.55 251.81,55.18 252.07,55.18
+3.3V_ALW_U51 on IN2 (solid shape): outline of 1834 points within 234.67,40.45 252.7,54.93
+3.3V_LAN on TOP (solid shape): 105.13,94.43 105.13,93.66 105,93.54 103.22,93.54 102.97,93.79 102.97,94.43 103.22,94.68 104.88,94.68
+3.3V_LAN on TOP (solid shape): 101.7,77.92 101.7,76.41 101.7,76.36 101.7,75.88 101.57,75.76 99.67,75.76 99.24,76.19 99.24,77.86 99.54,78.17 101.45,78.17
+3.3V_LAN on TOP (solid shape): 105.69,90.74 105.69,89.36 105.85,89.19 106.15,89.19 106.27,89.07 106.27,88.84 106.02,88.58 105.26,88.58 105,88.84 105,90.74 105.13,90.87 105.56,90.87
+3.3V_LAN on BOTTOM (solid shape): 119.1,90.97 119.1,87.57 118.85,87.31 117.58,87.31 117.07,87.82 115.29,87.82 115.16,87.95 115.16,88.71 115.54,89.09 115.54,89.22 115.86,89.22 115.86,89.98 115.54,89.98 115.54,90.18 116.71,91.35 118.72,91.35
+3.3V_LAN on IN1 (solid shape): outline of 1967 points within 103.86,86.55 119.35,106.36
+3.3V_LAN on IN2 (solid shape): 120.12,90.11 120.12,87.82 119.1,86.81 117.19,86.81 116.81,87.19 116.81,90.74 117.32,91.25 118.97,91.25
+3.3V_LAN on IN2 (solid shape): outline of 127 points within 99.16,76.52 106.53,89.47
+3.3V_LAN on IN2 (solid shape): outline of 512 points within 103.99,171.01 113.77,174.94
+3.3V_LAN_OUT on IN4 (solid shape): outline of 486 points within 107.29,89.22 118.08,97.47
+3.3V_M on TOP (solid shape): 108.81,43.5 108.81,42.61 108.53,42.33 107.97,42.33 107.95,42.3 107.95,41.8 107.92,41.77 107.72,41.77 107.69,41.8 107.69,42.28 107.64,42.33 107.19,42.33 107.14,42.28 107.14,41.8 107.11,41.77 106.93,41.77 106.88,41.82 106.88,42.3 106.86,42.3 106.83,42.33 106.3,42.33 106.15,42.48 106.15,43.37 106.4,43.63 108.69,43.63
+3.3V_M_PWR on TOP (solid shape): 106.75,41.67 106.76,41.66 106.76,41.65 106.78,41.65 106.81,41.62 107.24,41.62 107.29,41.67 107.29,42.18 107.54,42.18 107.54,41.64 107.57,41.62 108.05,41.62 108.08,41.64 108.08,42.18 108.43,42.18 108.43,40.45 108.18,40.2 103.48,40.2 103.2,39.92 102.46,39.92 102.39,39.99 102.39,40.48 102.49,40.58 103.1,40.58 103.61,41.09 105.26,41.09 106.35,42.18 106.75,42.18
+3.3V_MXM on TOP (solid shape): 116.43,145.61 116.43,144.21 116.18,143.96 112.88,143.96 112.88,143.95 110.51,143.95 110.33,144.13 110.29,144.13 110.21,144.21 110.21,144.23 110.22,144.26 110.22,144.3 110.22,145.49 110.39,145.66 112.7,145.66 112.75,145.61 114.15,145.61 114.4,145.86 116.18,145.86
+3.3V_MXM on TOP (solid shape): 106.91,167.02 106.93,166.99 107.39,166.99 107.42,167.02 107.42,167.5 107.44,167.53 107.69,167.53 107.69,167.02 107.72,166.99 108.25,166.99 108.43,166.82 108.43,163.51 108.18,163.26 106.19,163.26 105.63,163.82 106.32,163.82 106.33,163.76 106.34,163.71 106.36,163.66 106.39,163.61 106.42,163.56 106.46,163.52 106.5,163.49 106.55,163.47 106.61,163.45 106.66,163.44 106.72,163.44 106.77,163.44 106.83,163.46 106.88,163.48 106.93,163.51 106.97,163.54 107.01,163.58 107.04,163.63 107.06,163.68 107.08,163.73 107.09,163.79 107.09,163.85 107.08,163.9 107.06,163.95 107.04,164 107.01,164.05 106.97,164.09 106.93,164.13 106.88,164.16 106.83,164.18 106.77,164.19 106.72,164.2 106.66,164.2 106.61,164.19 106.55,164.17 106.5,164.14 106.46,164.11 106.42,164.07 106.39,164.03 106.36,163.98 106.34,163.93 106.33,163.87 106.32,163.82 105.63,163.82 105.51,163.94 105.51,165.16 106.04,165.7 106.04,166.87 106.17,166.99 106.63,166.99 106.63,167.53 106.91,167.53
+3.3V_MXM on IN2 (solid shape): 113.97,145.78 113.97,144.42 113.82,144.27 109.14,144.27 108.88,144.54 108.88,145.78 109.33,146.24 113.51,146.24
+3.3V_MXM on IN2 (solid shape): 108.51,164.54 108.51,162.56 108.17,162.22 108.16,162.21 108.13,162.2 108.1,162.19 108.07,162.2 108.04,162.21 108.01,162.24 107.96,162.27 107.91,162.29 107.86,162.31 107.81,162.32 107.75,162.32 107.7,162.31 107.65,162.3 107.6,162.28 107.55,162.25 107.51,162.22 107.47,162.18 107.46,162.15 106.37,162.15 105.83,162.7 105.83,163.82 106.32,163.82 106.33,163.76 106.34,163.71 106.36,163.66 106.39,163.61 106.42,163.56 106.46,163.52 106.51,163.49 106.55,163.47 106.61,163.45 106.66,163.44 106.72,163.44 106.77,163.44 106.83,163.46 106.88,163.48 106.93,163.51 106.97,163.54 107.01,163.58 107.04,163.63 107.06,163.68 107.08,163.73 107.09,163.79 107.09,163.85 107.08,163.9 107.06,163.95 107.04,164 107.01,164.05 106.97,164.09 106.93,164.13 106.88,164.16 106.83,164.18 106.77,164.19 106.72,164.2 106.66,164.2 106.61,164.19 106.55,164.17 106.51,164.14 106.46,164.11 106.42,164.07 106.39,164.03 106.36,163.98 106.34,163.93 106.33,163.87 106.32,163.82 105.83,163.82 105.83,164.35 106.31,164.83 108.22,164.83
+3.3V_MXM on IN4 (solid shape): outline of 406 points within 0.99,137.1 10.9,143.96
+3.3V_MXM_PWR on TOP (solid shape): outline of 82 points within 105.89,167.12 110.95,171.26
+3.3V_MXM_PWR on IN4 (solid shape): 111.86,171.01 111.86,168.59 111.48,168.21 108.18,168.21 107.92,168.47 107.92,169.51 109.71,169.51 109.71,169.45 109.72,169.4 109.74,169.35 109.77,169.3 109.8,169.25 109.84,169.21 109.89,169.18 109.94,169.16 109.99,169.14 110.05,169.13 110.1,169.13 110.16,169.13 110.21,169.15 110.26,169.17 110.31,169.2 110.35,169.23 110.39,169.27 110.42,169.32 110.45,169.37 110.46,169.42 110.47,169.48 110.47,169.54 110.46,169.59 110.45,169.64 110.42,169.69 110.39,169.74 110.35,169.78 110.31,169.82 110.26,169.85 110.21,169.87 110.16,169.88 110.1,169.89 110.05,169.89 109.99,169.88 109.94,169.86 109.89,169.83 109.84,169.8 109.8,169.76 109.77,169.72 109.74,169.67 109.72,169.62 109.71,169.56 109.71,169.51 107.92,169.51 107.92,171.01 108.18,171.26 111.61,171.26
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 58.14,15.43 59.03,15.43 59.16,15.3 59.16,14.29 58.9,14.03 57.12,14.03 56.87,14.29 56.87,15.81 56.95,15.89 57.68,15.89
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 72.49,21.65 72.49,17.72 72.36,17.59 70.97,17.59 70.84,17.72 70.84,19.24 70.97,19.37 70.97,19.58 70.97,19.65 70.97,21.05 70.97,21.12 70.97,21.65 71.09,21.78 72.36,21.78
+3.3V_PCIE_FLASH on IN4 (solid shape): outline of 910 points within 56.62,13.4 91.79,30.93
+3.3V_PCIE_NVM on TOP (solid shape): 16.61,150.94 16.61,150.29 16.57,150.28 16.3,149.91 16.57,149.55 16.61,149.54 16.61,148.9 16.57,148.89 16.32,148.62 16.42,148.26 16.61,148.06 16.61,147.13 16.48,147 14.32,147 14.25,147.03 14.22,147.1 13.84,147.46 13.46,147.1 13.43,147.03 13.36,147 12.8,147 12.55,147.26 12.55,150.81 13.05,151.32 16.23,151.32
+3.3V_PCIE_NVM on BOTTOM (solid shape): 16.69,147.94 16.69,146.32 15.98,145.61 15.98,144.46 15.72,144.21 13.56,144.21 13.44,144.34 13.44,145.48 13.56,145.61 13.56,146.24 14.32,147 14.32,148.02 14.45,148.15 16.48,148.15
+3.3V_PCIE_NVM on BOTTOM (solid shape): 10.04,150.79 10.13,150.79 10.15,150.79 10.39,150.56 10.39,147.89 10.64,147.64 10.7,147.64 10.71,147.63 10.86,147.59 11.01,147.61 11.04,147.62 11.28,147.38 11.28,144.61 10.44,143.77 10.37,143.74 10.3,143.77 9.77,143.75 9.76,143.23 9.79,143.16 9.76,143.09 8.56,141.9 3.79,141.9 3.68,142 3.68,143.27 3.87,143.47 5.68,143.47 5.77,143.41 5.76,143.3 6.06,142.68 6.35,143.3 6.34,143.41 6.43,143.47 6.8,143.47 6.86,143.53 6.88,143.52 7.43,143.66 7.57,144.21 7.57,144.23 7.75,144.42 7.75,144.74 7.75,144.75 7.77,144.89 7.75,145.04 7.75,145.05 7.75,145.65 7.75,145.66 7.77,145.81 7.75,145.96 7.75,145.96 7.75,146.06 7.78,146.13 7.85,146.17 8.2,146.55 7.85,146.93 7.78,146.96 7.75,147.03 7.75,147.41 9.12,148.78 9.12,150.43 9.5,150.81 9.94,150.81
+3.3V_PCIE_NVM on IN4 (solid shape): outline of 1932 points within 9.12,145.86 34.77,160.72
+3.3V_PCIE_WWAN on TOP (solid shape): outline of 733 points within 256.64,51.12 260.58,66.1
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 260.45,41.72 262.48,41.72 262.61,41.59 262.61,40.58 262.23,40.2 261.43,40.2 261.42,40.2 260.64,40.2 260.38,40.45 259.05,40.45 258.8,40.7 258.8,41.34 258.55,41.59 258.55,42.61 258.8,42.86 259.31,42.86
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 285.1,52.02 285.1,47.16 283.97,46.03 279.39,46.03 278.48,45.12 278.48,41.59 277.85,40.96 276.2,40.96 275.94,40.7 275.94,40.07 275.69,39.82 274.73,39.82 274.73,39.82 273.4,39.82 273.28,39.94 273.28,42.1 272.46,42.91 272.25,42.91 272.24,42.94 271.98,43.1 271.73,42.94 271.71,42.91 271.32,42.91 270.99,43.24 270.99,45.15 270.61,45.53 268.83,45.53 268.58,45.78 268.58,46.67 268.83,46.93 271.63,46.93 271.75,47.05 274.29,47.05 274.8,47.56 274.8,48.58 274.8,48.59 274.8,49.72 275.56,50.48 277.18,50.48 279.44,52.74 284.38,52.74
+3.3V_PCIE_WWAN on IN4 (solid shape): outline of 789 points within 257.4,39.94 284.33,52.26
+3.3V_RUN on TOP (solid shape): 9.88,117.79 9.88,117.41 7.85,115.38 7.08,115.38 6.45,116.02 6.45,116.52 8.74,118.81 8.86,118.81
+3.3V_RUN on TOP (solid shape): 20.41,67.46 22.24,67.46 22.45,67.25 22.45,65.09 22.26,64.9 18.45,64.9 18.32,65.02 18.32,67.56 18.45,67.69 20.18,67.69
+3.3V_RUN on TOP (solid shape): 72.09,45.63 72.44,45.63 72.62,45.46 72.62,44.13 72.59,44.11 71.01,44.11 70.71,44.41 70.71,45.4 70.92,45.61 71.4,45.61 71.45,45.66 72.06,45.66
+3.3V_RUN on TOP (solid shape): 286.62,142.72 286.62,138.21 288.09,136.75 288.09,134.09 287.67,133.67 286.49,133.67 285.29,134.86 285.29,142.7 285.57,142.98 286.37,142.98
+3.3V_RUN on TOP (solid shape): 69.19,45.63 69.59,45.63 70.05,45.17 70.05,44.11 70.08,44.08 70.08,43.88 69.95,43.75 67.92,43.75 67.66,44.01 67.66,45.53 67.79,45.66 68.37,45.66 68.37,45.66 69.16,45.66
+3.3V_RUN on TOP (solid shape): 1.9,145.25 1.9,144.82 1.9,144.72 1.93,144.69 2.34,144.69 2.36,144.72 2.36,144.82 2.36,145.23 2.39,145.25 2.67,145.25 2.74,145.25 3.02,144.97 3.02,143.45 2.64,143.07 1.5,143.07 1.24,143.32 1.24,145.1 1.42,145.28 1.88,145.28
+3.3V_RUN on TOP (solid shape): 80.75,39.69 80.75,35.88 80.62,35.76 79.95,35.76 79.79,35.6 79.79,34.67 79.61,34.48 78.08,34.48 77.82,34.74 77.82,36.51 77.16,37.17 77.16,38.11 77.14,38.14 76.63,38.14 76.61,38.16 76.61,38.39 76.63,38.42 77.09,38.42 77.14,38.42 77.14,38.47 77.14,38.47 77.14,38.9 77.14,38.92 77.11,38.93 76.63,38.93 76.61,38.95 76.61,39.18 76.63,39.21 77.11,39.21 77.13,39.22 77.14,39.23 77.14,39.89 77.32,40.07 80.36,40.07
+3.3V_RUN on TOP (solid shape): outline of 137 points within 76.78,44.57 82.6,52.64
+3.3V_RUN on TOP (solid shape): outline of 209 points within 60.35,76.85 68.92,83.88
+3.3V_RUN on BOTTOM (solid shape): 239.75,60.39 241.53,60.39 242.29,59.63 242.29,59.37 242.04,59.12 238.48,59.12 238.23,59.37 238.23,60.14 238.35,60.26 238.35,60.77 238.48,60.9 239.24,60.9
+3.3V_RUN on BOTTOM (solid shape): 260.2,57.47 260.2,56.07 260.07,55.94 258.8,55.94 258.65,56.1 258.65,56.58 258.67,56.6 259.18,56.6 259.21,56.63 259.21,57.04 259.18,57.06 258.67,57.06 258.65,57.09 258.65,57.34 258.9,57.6 260.07,57.6
+3.3V_RUN on BOTTOM (solid shape): 262.36,80.71 262.36,79.69 262.2,79.54 261.47,79.54 261.44,79.52 261.44,78.98 261.42,78.96 261.26,78.96 261.24,78.98 261.24,79.52 261.21,79.54 260.48,79.54 260.32,79.69 260.32,80.51 260.65,80.84 262.23,80.84
+3.3V_RUN on BOTTOM (solid shape): outline of 206 points within 11.15,99.51 21.18,117.41
+3.3V_RUN on BOTTOM (solid shape): outline of 218 points within 129.26,147.51 153.77,157.8
+3.3V_RUN on BOTTOM (solid shape): outline of 395 points within 172.69,28.51 188.19,46.29
+3.3V_RUN on BOTTOM (solid shape): outline of 437 points within 118.97,60.26 128.24,78.04
+3.3V_RUN on BOTTOM (solid shape): outline of 584 points within 66.39,36.51 91.03,53.15
+3.3V_RUN on IN1 (solid shape): outline of 130 points within 80.62,93.41 84.05,106.62
+3.3V_RUN on IN1 (solid shape): outline of 333 points within 202.67,66.49 210.16,81.22
+3.3V_RUN on IN1 (solid shape): outline of 968 points within 119.23,70.8 126.97,104.59
+3.3V_RUN on IN1 (solid shape): outline of 967 points within 39.78,147.13 66.14,154.62
+3.3V_RUN on IN1 (solid shape): outline of 1120 points within 274.8,82.49 301.34,137.86
+3.3V_RUN on IN2 (solid shape): outline of 104 points within 68.17,43.88 78.72,46.42
+3.3V_RUN on IN2 (solid shape): outline of 1325 points within 57.89,71.18 83.92,95.7
+3.3V_RUN on IN2 (solid shape): outline of 1386 points within 174.62,45.28 207.87,67.76
+3.3V_RUN on IN2 (solid shape): outline of 2187 points within 15.59,65.16 23.98,101.03
+3.3V_RUN on IN2 (solid shape): outline of 2799 points within 63.73,151.12 106.53,169.61
+3.3V_RUN on IN2 (solid shape): outline of 4511 points within 232,35.12 260.96,80.96
+3.3V_RUN on IN2 (solid shape): outline of 6514 points within 72.11,44.13 132.43,70.68
+3.3V_RUN on IN2 (solid shape): outline of 12437 points within 1.37,104.08 77.7,163.64
+3.3V_RUN on IN3 (solid shape): outline of 734 points within 114.27,54.42 124.18,77.66
+3.3V_RUN on IN3 (solid shape): outline of 3702 points within 104.62,156.32 163.42,176.09
+3.3V_RUN on IN4 (solid shape): 124.69,98.49 124.69,94.55 124.43,94.3 124.43,93.03 124.18,92.77 122.27,92.77 122.02,93.03 122.02,95.24 123.37,95.24 123.37,95.19 123.37,95.13 123.39,95.08 123.41,95.03 123.44,94.99 123.48,94.95 123.52,94.92 123.57,94.89 123.62,94.87 123.67,94.86 123.72,94.86 123.78,94.86 123.83,94.87 123.88,94.89 123.92,94.92 123.96,94.95 124,94.99 124.03,95.03 124.05,95.08 124.07,95.13 124.08,95.19 124.08,95.24 124.07,95.29 124.05,95.34 124.03,95.39 124,95.43 123.96,95.47 123.92,95.51 123.88,95.53 123.83,95.55 123.78,95.57 123.72,95.57 123.67,95.57 123.62,95.55 123.57,95.53 123.52,95.51 123.48,95.47 123.44,95.43 123.41,95.39 123.39,95.34 123.37,95.29 123.37,95.24 122.02,95.24 122.02,95.7 118.85,98.87 118.85,102.3 119.48,102.93 120.24,102.93
+3.3V_RUN on VCC: 281.51,65.34 270.46,76.39 200.99,76.39 206.4,81.8 206.4,113.38 200.38,119.4 200.38,119.42 197.97,121.84 197.97,156.25 197.18,157.04 164.92,157.04 160.73,161.23 154.55,161.23 153.01,159.68 153.01,158.84 159.49,152.36 159.49,151.6 159.49,116.88 158.75,116.14 144.39,116.14 140.1,111.85 139.6,111.98 135.74,108.12 135.74,107.48 127.63,99.4 127.23,99.4 126.75,99.89 91.52,99.89 87.07,104.33 83.9,104.33 75.77,112.46 74.75,112.46 73.63,113.58 73.63,151.6 75.14,153.1 138.13,153.1 139.29,154.26 139.29,176.18 213.32,176.18 213.32,172.22 208.92,172.22 208.86,172.16 207.91,171.63 207.38,170.68 207.32,170.62 207.32,161.78 207.38,161.72 207.91,160.77 208.86,160.24 208.92,160.18 213.32,160.18 213.32,119.93 213.33,119.93 213.6,115.84 214.32,111.8 213.75,111.07 213.72,110.14 214.96,106.42 216.58,102.85 216.93,102.41 217.42,102.12 217.51,102.03 218.17,102.03 242.25,84.19 271.66,89.99 275.99,85.66 282.08,85.66 283.48,84.27 302.83,84.27 302.83,65.34
+3.3V_RUN_PS8513 on TOP (solid shape): outline of 94 points within 1.24,144.84 4.42,148.65
+3.3V_RUN_PS8513 on IN4 (solid shape): outline of 523 points within 1.12,145.86 8.99,151.58
+3.3V_RUN_PWR on TOP (solid shape): 77.01,39.33 76.58,39.33 76.5,39.33 76.5,39.32 76.48,39.32 76.48,39.31 76.48,38.82 76.5,38.8 77.01,38.8 77.01,38.55 76.58,38.55 76.5,38.55 76.48,38.52 76.48,38.04 76.48,38.02 76.5,38.02 76.5,38.01 77.01,38.01 77.03,37.99 77.03,36.54 76.99,36.54 76.99,35.4 76.47,34.89 75.77,34.89 75.6,34.85 75.46,34.74 74.84,34.74 74.65,34.79 74.46,34.74 73.66,34.74 73.59,34.78 73.51,34.8 73.47,34.8 73.47,35.74 73.13,36.08 73.13,36.64 72.87,36.89 72.87,38.29 72.95,38.37 74.6,38.37 75.92,39.69 77.01,39.69
+3.3V_RUN_TPM on BOTTOM (solid shape): 258.67,62.68 258.67,61.15 258.42,60.9 257.68,60.9 257.64,60.91 257.15,61.41 257.15,62.68 257.4,62.93 258.42,62.93
+3.3V_RUN_TPM on BOTTOM (solid shape): 258.55,59.63 258.55,57.46 258.52,57.46 258.52,57.37 258.49,57.34 258.49,56.96 258.52,56.93 259.03,56.93 259.05,56.91 259.05,56.76 259.03,56.73 258.62,56.73 258.52,56.73 258.49,56.71 258.49,56.15 258.29,55.94 257.91,55.94 257.66,56.2 257.66,57.24 257.78,57.37 257.9,57.75 257.66,58.07 257.66,58.44 257.81,58.75 257.66,59.05 257.66,59.63 257.78,59.75 258.42,59.75
+3.3V_RUN_TPM on IN1 (solid shape): 258.67,63.06 258.67,61.91 258.45,61.69 248.61,61.69 248.39,61.91 248.39,62.68 248.75,63.04 248.78,63.01 249.17,62.94 249.41,63.26 249.42,63.3 252.98,63.3 252.99,63.31 258.42,63.31
+3.3V_RUN_TPM on IN3 (solid shape): outline of 425 points within 251.94,57.09 258.55,62.68
+3.3V_SPI on TOP (solid shape): outline of 573 points within 99.8,54.55 115.92,70.8
+3.3V_SUS on TOP (solid shape): 23.09,79.57 23.09,78.93 22.96,78.8 22.33,78.8 22.07,78.55 22.07,78.04 21.94,77.92 20.55,77.92 20.34,78.12 18.53,78.12 18.5,78.15 18.47,78.2 18.45,78.24 18.44,78.29 18.44,78.31 18.44,78.34 18.45,78.37 18.56,78.48 20.22,78.48 20.42,78.68 20.42,79.31 20.67,79.57 21.69,79.57 22.07,79.95 22.71,79.95
+3.3V_SUS on TOP (solid shape): 109.57,39.31 109.57,36.89 108.94,36.26 108.3,36.26 108.13,36.44 108.13,37.12 107.62,37.12 107.59,37.15 107.59,37.35 107.62,37.38 108.1,37.38 108.13,37.4 108.13,37.81 108.13,37.88 108.12,37.91 108.1,37.91 108.03,37.91 107.62,37.91 107.59,37.94 107.59,38.16 107.62,38.19 108.13,38.19 108.15,38.21 108.15,38.67 108.18,38.7 108.18,39.31 108.3,39.43 109.45,39.43
+3.3V_SUS on TOP (solid shape): 118.59,33.21 118.59,32.2 118.34,31.94 116.43,31.94 116.18,32.2 115.56,32.2 115.46,32.24 115.35,32.25 114.46,32.25 114.35,32.24 114.25,32.2 113.21,32.2 113.21,32.22 112.72,32.22 112.5,32.45 112.5,33.05 112.64,33.2 112.71,33.3 112.75,33.42 112.75,33.47 114.21,33.47 114.33,33.41 114.46,33.39 115.35,33.39 115.48,33.41 115.6,33.47 115.92,33.47 116.05,33.59 118.21,33.59
+3.3V_SUS on BOTTOM (solid shape): outline of 229 points within 107.8,32.83 116.69,39.43
+3.3V_SUS on IN2 (solid shape): 24.74,79.26 24.74,78.8 22.33,78.8 22.07,79.06 22.07,79.82 22.58,80.33 23.67,80.33
+3.3V_SUS on IN2 (solid shape): 107.92,39.56 109.57,39.56 109.7,39.43 109.7,38.8 109.57,38.67 107.8,38.67 107.42,39.05 107.42,39.69 107.8,39.69
+3.3V_SUS_PWR on TOP (solid shape): 108,38.65 108,38.32 107.47,38.32 107.44,38.29 107.44,37.81 107.47,37.78 107.97,37.78 108,37.76 108,37.53 107.47,37.53 107.44,37.5 107.44,37.05 107.47,37.02 107.47,37 107.48,37 107.49,37 108,37 108,36.64 106.4,36.64 106.02,37.01 103.32,37.01 103.06,37.28 102.61,37.28 102.39,37.5 102.39,38.47 102.46,38.55 103.1,38.55 103.48,38.16 103.62,38.16 103.83,38.06 104.05,38.16 104.49,38.16 106.65,38.16 107.16,38.67 107.97,38.67
+3.3V_VCCPRTCSUS on IN1 (solid shape): outline of 272 points within 68.68,61.53 71.98,63.82
+3.3V_WLAN on TOP (solid shape): 103.22,170.63 103.22,169.99 102.97,169.74 102.97,168.47 102.84,168.34 100.94,168.34 100.18,169.1 100.18,170.5 100.43,170.75 103.1,170.75
+3.3V_WLAN on IN1 (solid shape): outline of 1614 points within 99.92,164.53 137.9,173.04
+3.3V_WLAN on IN2 (solid shape): outline of 2163 points within 106.27,156.02 137.77,172.91
+3VALWP on BOTTOM (solid shape): outline of 271 points within 34.77,40.07 54.46,49.34
+3VALWP on IN1 (solid shape): 44.42,45.02 46.84,45.02 47.98,43.88 47.98,41.97 47.6,41.59 38.84,41.59 37.95,42.48 37.95,47.94 38.33,48.32 41.12,48.32
+3VALWP on IN3 (solid shape): outline of 123 points within 37.06,41.96 50.14,48.71
+3VALWP on IN4 (solid shape): 43.03,47.31 44.93,47.31 46.27,45.97 46.27,44.56 48.23,42.6 48.23,42.36 47.6,41.72 41.76,41.72 38.07,45.4 38.07,48.58 38.58,49.09 41.25,49.09
+5V_ALW on TOP (solid shape): 108.56,173.55 108.56,172.78 108.3,172.53 105.76,172.53 105.51,172.78 105.51,173.55 105.76,173.8 108.3,173.8
+5V_ALW on TOP (solid shape): 15.09,73.6 15.09,68.06 14.93,67.91 12.83,67.91 12.55,67.63 10.51,67.63 10.26,67.88 10.26,72.2 11.78,73.72 14.96,73.72
+5V_ALW on TOP (solid shape): 105.38,166.82 105.38,166.31 105,165.93 103.86,165.93 103.61,166.18 103.61,166.82 103.85,167.05 103.91,167.05 103.91,167.07 105.13,167.07
+5V_ALW on TOP (solid shape): 31.21,32.7 31.21,32.66 31.33,32.54 31.33,31.22 31.17,31.05 29.95,31.05 29.69,31.31 29.69,32.58 29.88,32.76 30.65,32.76 30.79,32.9 31.02,32.9
+5V_ALW on TOP (solid shape): 112.48,170.11 112.48,166.29 111.86,165.67 110.59,165.67 110.34,165.93 110.34,166.94 110.46,167.07 110.46,168.29 111.07,168.9 111.07,169.69 111.06,169.7 111.06,169.73 110.6,170.2 110.6,170.55 110.82,170.78 111.81,170.78
+5V_ALW on TOP (solid shape): 19.97,156.12 20.14,155.94 20.38,155.9 20.41,155.9 21.06,155.26 21.06,154.5 20.8,154.24 19.26,154.24 19.06,154.33 18.85,154.24 17.75,154.24 17.25,154.75 17.25,155.64 17.75,156.15 19.96,156.15
+5V_ALW on TOP (solid shape): 39.22,130.24 39.22,129.35 38.97,129.1 38.48,129.1 38.44,129.1 38.17,129.1 37.95,129.17 37.74,129.11 37.72,129.1 37.69,129.1 37.44,128.84 37.44,128.46 37.57,128.33 38.07,128.33 38.2,128.46 39.09,128.46 39.22,128.33 39.22,127.83 38.96,127.57 37.72,127.57 37.71,127.61 37.34,127.9 36.97,127.61 36.96,127.57 36.3,127.57 36.04,127.83 36.04,129.22 36.55,129.73 36.55,130.24 36.8,130.49 38.96,130.49
+5V_ALW on BOTTOM (solid shape): 12.8,142.69 12.8,141.67 12.55,141.42 12.55,140.78 12.17,140.4 10.9,140.4 10.51,140.78 10.51,142.43 10.9,142.81 12.67,142.81
+5V_ALW on BOTTOM (solid shape): 56.36,20.64 56.36,18.73 55.6,17.97 55.6,17.34 55.47,17.21 54.81,17.21 54.71,17.31 53.85,17.31 53.57,17.59 53.57,20.64 53.82,20.89 56.11,20.89
+5V_ALW on BOTTOM (solid shape): 295.63,56.07 297.15,56.07 297.15,56.58 297.28,56.71 298.17,56.71 298.42,56.45 298.42,53.53 297.92,53.02 292.58,53.02 292.33,53.28 292.33,56.2 292.84,56.71 295.63,56.71
+5V_ALW on BOTTOM (solid shape): 52.81,24 52.81,12.18 52.61,11.98 50.29,11.98 50.07,12.2 50.07,13.56 50.08,13.57 50.62,13.57 50.62,15.52 50.6,15.54 50.11,15.54 50.07,15.58 50.07,18.99 50.1,19.02 50.62,19.02 50.62,20.98 50.08,20.98 50.07,20.99 50.07,23.85 50.37,24.14 52.67,24.14
+5V_ALW on IN1 (solid shape): 106.65,166.69 106.65,165.16 106.27,164.78 104.24,164.78 103.73,165.29 103.73,165.82 105.15,165.82 105.16,165.77 105.17,165.71 105.19,165.66 105.22,165.61 105.25,165.57 105.29,165.53 105.34,165.5 105.39,165.47 105.44,165.45 105.49,165.44 105.55,165.44 105.61,165.45 105.66,165.46 105.71,165.48 105.76,165.51 105.8,165.55 105.84,165.59 105.87,165.64 105.89,165.69 105.91,165.74 105.92,165.8 105.92,165.85 105.91,165.91 105.89,165.96 105.87,166.01 105.84,166.06 105.8,166.1 105.76,166.14 105.71,166.16 105.66,166.19 105.61,166.2 105.55,166.21 105.49,166.2 105.44,166.19 105.39,166.18 105.34,166.15 105.29,166.12 105.25,166.08 105.22,166.04 105.19,165.99 105.17,165.93 105.16,165.88 105.15,165.82 103.73,165.82 103.73,166.56 104.11,166.94 105.94,166.94 106.4,166.94
+5V_ALW on IN1 (solid shape): outline of 84 points within 109.07,165.16 111.99,167.2
+5V_ALW on IN1 (solid shape): outline of 1291 points within 9.63,61.53 41.12,72.07
+5V_ALW on IN2 (solid shape): 192.89,29.91 192.89,28.39 192.63,28.13 188.31,28.13 188.06,28.39 188.06,29.27 188.44,29.66 190.22,29.66 190.73,30.16 192.63,30.16
+5V_ALW on IN2 (solid shape): 84.05,37.15 84.05,34.33 83.92,34.05 84.05,33.76 84.05,32.7 83.67,32.32 82.27,32.32 82.02,32.58 82.02,36.01 82.14,36.13 82.14,37.02 82.52,37.4 83.79,37.4
+5V_ALW on IN2 (solid shape): outline of 4788 points within 28.29,14.16 56.11,67.5
+5V_ALW on IN3 (solid shape): outline of 434 points within 27.28,14.16 56.11,33.85
+5V_ALW on IN3 (solid shape): outline of 2485 points within 66.27,151.83 113.38,176.21
+5V_ALW on IN4 (solid shape): outline of 411 points within 40.11,145.61 69.32,153.48
+5V_ALW on VCC: outline of 116 points within 1.02,1.22 302.83,167.96
+5V_ALW_ESATA on TOP (solid shape): 19.91,162.24 19.91,161.48 20.67,160.72 20.67,160.45 20.62,160.26 20.67,160.07 20.67,159.83 21.06,159.45 21.06,157.93 20.04,156.91 17.75,156.91 17.63,157.04 17.63,157.8 18.01,158.18 18.01,160.85 18.39,161.23 18.9,161.23 19.15,161.48 19.15,162.24 19.28,162.37 19.79,162.37
+5V_ALW_FUSE on BOTTOM (solid shape): 297.15,62.42 297.15,61.53 297.66,61.02 297.66,57.09 297.53,56.96 293.22,56.96 292.58,57.6 292.58,59.25 293.22,59.88 294.11,59.88 294.16,59.93 294.19,59.93 294.58,60.32 294.62,60.37 294.65,60.43 294.99,60.77 295.76,60.77 296.39,61.41 296.39,62.42 296.52,62.55 297.03,62.55
+5V_ESATA_PWR on TOP (solid shape): 20.29,168.09 20.29,165.8 19.94,165.44 19.94,164.53 19.81,164.4 19.25,164.4 19.12,164.53 19.12,165.44 19.02,165.55 18.52,165.55 17.5,166.56 17.5,168.09 17.75,168.34 20.04,168.34
+5V_ESATA_PWR on BOTTOM (solid shape): 20.29,167.83 21.82,167.83 22.07,167.58 22.07,163.89 21.69,163.51 19.4,163.51 19.02,163.89 19.02,164.78 14.72,169.09 15.29,170.13 14.17,169.75 14.02,170.12 13.69,170.34 13.69,172.4 13.94,172.66 15.47,172.66
+5V_HDD on TOP (solid shape): 204.44,60.01 204.44,57.34 204.19,57.09 199.11,57.09 198.86,57.34 198.86,60.26 199.24,60.64 203.81,60.64
+5V_HDD on TOP (solid shape): 97.26,51.12 97.26,48.96 96.75,48.45 94.59,48.45 94.08,48.96 94.08,50.69 94.16,50.91 94.09,51.13 94.46,51.5 96.87,51.5
+5V_HDD on TOP (solid shape): 90.68,38.9 90.68,37.53 90.7,37.5 90.7,37.07 90.71,37.06 90.73,37.05 91.24,37.05 91.24,36.77 90.73,36.77 90.7,36.77 90.7,36.74 90.7,36.28 90.7,36.26 90.73,36.26 91.21,36.26 91.24,36.23 91.24,35.98 90.73,35.98 90.71,35.97 90.7,35.95 90.7,34.53 90.52,34.35 89.57,34.35 89.23,34.38 89.01,34.12 89.01,34.11 88.62,33.72 88.62,30.93 88.24,30.54 85.19,30.54 84.94,30.8 84.94,35.37 85.06,35.5 87.1,35.5 87.22,35.62 88.37,35.62 88.62,35.88 88.62,38.8 88.87,39.05 90.52,39.05
+5V_HDD on BOTTOM (solid shape): 203.68,60.39 204.06,60.39 204.19,60.26 204.19,58.29 203.91,58.01 201.65,58.01 201.42,58.24 201.42,60.93 201.87,61.38 202.69,61.38
+5V_HDD on IN2 (solid shape): outline of 1605 points within 93.83,41.21 204.32,60.35
+5V_MOD on TOP (solid shape): 27.53,32.7 28.29,32.7 28.42,32.58 28.42,27.75 28.04,27.37 28.04,24.54 27.89,24.38 26.33,24.38 25.37,25.34 23.34,25.34 23.09,25.59 23.09,26.99 23.34,27.24 25.75,27.24 26.01,27.5 26.01,32.7 26.26,32.96 27.28,32.96
+5V_MXM on TOP (solid shape): 43.41,137.35 43.41,135.57 43.92,135.07 43.92,132.65 43.66,132.4 40.99,132.4 40.87,132.53 40.87,133.8 40.99,133.92 40.99,137.35 41.12,137.48 43.28,137.48
+5V_MXM_PWR on TOP (solid shape): 41.22,132.19 41.22,131.74 41.23,131.73 41.23,131.69 41.27,131.69 41.27,131.69 41.71,131.69 41.74,131.69 41.74,131.72 41.76,131.74 41.76,132.19 41.78,132.22 41.98,132.22 42.01,132.19 42.01,131.71 42.04,131.69 42.52,131.69 42.54,131.69 42.54,131.7 42.54,131.71 42.54,132.19 42.57,132.22 43.08,132.22 43.28,132.02 43.28,128.84 43.15,128.72 42.39,128.72 41.88,129.22 40.61,129.22 40.49,129.35 40.49,130.37 40.61,130.49 40.61,132.02 40.82,132.22 41.2,132.22
+5V_RUN on TOP (solid shape): 167.61,26.73 166.34,25.46 164.31,25.46 164.06,25.72 164.06,26.61 166.34,28.89 167.61,28.89
+5V_RUN on TOP (solid shape): 194.41,35.88 194.41,34.86 193.52,33.97 190.73,33.97 190.73,35.37 191.49,36.13 194.16,36.13
+5V_RUN on TOP (solid shape): 8.48,119.32 8.48,119.06 6.07,116.65 5.82,116.65 4.93,117.54 4.93,117.79 7.34,120.21 7.59,120.21
+5V_RUN on TOP (solid shape): 229.84,87.38 229.84,85.28 229.59,85.03 226.16,85.03 225.78,85.41 225.78,88.24 226.03,88.49 228.73,88.49
+5V_RUN on TOP (solid shape): 14.96,64.71 15.09,64.58 15.09,63.18 14.96,63.06 10.55,63.06 10.49,63.11 10.42,63.15 10.41,63.16 10.39,63.18 10.39,64.58 10.51,64.71 14.93,64.71
+5V_RUN on TOP (solid shape): outline of 873 points within 56.87,18.23 102.34,39.56
+5V_RUN on BOTTOM (solid shape): 93.7,168.21 93.7,166.56 93.32,166.18 92.3,166.18 92.05,166.43 92.05,168.21 92.3,168.47 93.45,168.47
+5V_RUN on BOTTOM (solid shape): 253.59,49.21 253.59,48.2 253.34,47.94 252.32,47.94 252.2,48.07 252.2,49.72 252.32,49.85 252.96,49.85
+5V_RUN on BOTTOM (solid shape): 226.54,86.42 226.54,85.03 223.62,82.11 223.11,82.11 222.73,82.49 222.73,82.74 225.53,85.54 225.53,86.42 225.78,86.68 226.29,86.68
+5V_RUN on BOTTOM (solid shape): 60.43,23.05 60.43,21.78 60.15,21.5 59.51,21.5 59.49,21.48 59.49,20.97 59.46,20.94 59.05,20.94 59.03,20.97 59.03,21.48 59,21.5 58.29,21.5 58.27,21.48 58.27,20.97 58.24,20.94 57.86,20.94 57.83,20.97 57.83,21.48 57.81,21.5 56.92,21.5 56.74,21.68 56.74,22.67 57.38,23.31 60.17,23.31
+5V_RUN on BOTTOM (solid shape): outline of 618 points within 1.5,82.49 14.2,118.3
+5V_RUN on IN1 (solid shape): 29.72,37.61 29.72,35.74 29.35,35.37 27.21,35.37 26.82,35.76 26.82,37.5 27.1,37.78 29.54,37.78
+5V_RUN on IN1 (solid shape): 60.68,23.94 60.68,22.04 60.3,21.65 57.38,21.65 55.73,23.31 55.73,24.19 55.85,24.32 60.3,24.32
+5V_RUN on IN1 (solid shape): 10.13,65.09 10.72,65.09 11.4,65.09 11.72,64.77 11.72,63.69 11.6,63.56 10.13,63.56 9.05,64.65 8.99,64.73 8.91,64.79 8.1,65.6 8.1,66.1 9.12,66.1
+5V_RUN on IN1 (solid shape): 10.26,88.46 10.26,87.82 10.01,87.57 6.4,87.57 6.32,87.61 6.3,87.7 5.94,88.2 5.58,87.7 5.57,87.61 5.48,87.57 3.15,87.57 2.77,87.19 2.77,86.3 2.01,86.3 1.62,86.68 1.62,89.09 2.01,89.47 9.24,89.47
+5V_RUN on IN1 (solid shape): outline of 1805 points within 1.04,116.4 12.04,155.5
+5V_RUN on IN2 (solid shape): 23.47,59.75 23.47,58.48 22.45,58.48 20.29,60.64 20.29,61.28 20.42,61.41 21.82,61.41
+5V_RUN on IN2 (solid shape): 194.16,36.89 194.16,36.01 193.65,35.5 191.87,35.5 191.49,35.88 191.49,37.02 191.74,37.28 193.78,37.28
+5V_RUN on IN2 (solid shape): 229.97,86.81 229.97,85.03 229.84,84.9 228.95,84.9 228.83,85.03 228.83,86.81 229.08,87.06 229.72,87.06
+5V_RUN on IN2 (solid shape): 28.04,39.18 28.04,38 28.31,37.73 29.41,37.73 29.53,37.62 29.53,37.01 29.31,36.79 26.94,36.79 26.44,37.29 26.44,39.13 26.57,39.26 27.96,39.26
+5V_RUN on IN2 (solid shape): outline of 540 points within 94.84,18.1 166.85,33.21
+5V_RUN on IN2 (solid shape): outline of 854 points within 3.15,108.01 71.73,118.81
+5V_RUN on IN3 (solid shape): 93.83,168.21 93.83,167.7 93.45,167.32 90.91,167.32 90.78,167.45 90.78,167.7 91.54,168.47 93.57,168.47
+5V_RUN on IN3 (solid shape): 20.42,61.66 21.56,61.66 21.82,61.41 21.82,59.25 21.56,58.99 19.15,58.99 15.21,62.93 10.39,62.93 10.01,63.31 10.01,64.33 10.39,64.71 17.37,64.71
+5V_RUN on IN4 (solid shape): 11.23,156.32 11.23,154.48 10.88,154.13 9.98,154.13 9.63,154.48 9.63,156.27 10.07,156.72 10.83,156.72
+5V_RUN on IN4 (solid shape): 45.19,166.31 45.19,164.78 44.17,163.77 43.53,163.77 43.28,164.02 43.28,166.43 43.66,166.82 44.68,166.82
+5V_RUN on IN4 (solid shape): 76.81,108.14 76.81,102.3 80.11,99 80.11,92.52 79.09,91.5 79.09,89.09 78.84,88.84 77.61,88.84 77.06,89.38 77.06,90.74 77.2,90.88 77.24,90.86 77.72,90.95 77.66,91.43 77.62,91.51 77.65,91.58 79.09,93.03 79.09,97.35 75.03,101.41 75.03,107.25 73.89,108.4 71.57,108.4 71.48,108.46 71.5,108.57 71.22,109.21 70.94,108.57 70.96,108.46 70.87,108.4 70.49,108.4 70.39,108.46 70.41,108.57 70.14,109.22 69.87,108.57 69.89,108.46 69.8,108.4 66.9,108.4 66.52,108.78 66.52,110.17 66.9,110.55 68.93,110.55 69.06,110.68 74.27,110.68
+5V_RUN on VCC: 116.41,28.51 106.89,38.04 94.48,38.04 93.09,36.64 91.39,36.64 90.78,37.25 90.78,76.88 86.57,81.09 65.38,81.09 65.38,86.7 68.4,89.73 97.78,89.73 105.38,82.13 105.38,54.57 121.39,38.57 121.39,31.67 120.06,30.34 118.23,28.51
+5V_RUN_PWR on BOTTOM (solid shape): 57.68,21.32 57.68,20.82 57.71,20.79 58.39,20.79 58.42,20.82 58.42,21.32 58.44,21.35 58.85,21.35 58.88,21.32 58.88,20.79 59.59,20.79 59.61,20.82 59.61,21.32 59.64,21.35 60.1,21.35 60.3,21.15 60.3,20 59.41,19.11 59.41,17.72 59.28,17.59 58.01,17.59 57.63,17.21 57,17.21 56.87,17.34 56.87,21.15 57.07,21.35 57.66,21.35
+5V_USB_PWR1 on BOTTOM (solid shape): 294.99,116.78 294.99,114.62 294.74,114.36 293.98,114.36 292.71,113.09 291.06,113.09 290.8,113.35 290.8,114.49 291.31,115 292.2,115 292.58,115.38 292.58,116.65 292.96,117.03 294.74,117.03
+5V_USB_PWR1 on BOTTOM (solid shape): 296.67,66.97 296.67,64.68 296.59,64.61 296.42,64.61 296.37,64.66 296.37,65.44 295.96,65.85 295.63,65.85 295.38,66.1 295.38,66.76 295.38,66.87 295.6,67.09 296.54,67.09
+5V_USB_PWR1 on BOTTOM (solid shape): 290.17,106.87 290.17,101.44 289.42,100.69 289.4,100.69 288.84,100.13 286.65,100.13 286.26,100.51 286.26,103.34 286.74,103.81 286.74,105.03 286.89,105.18 286.89,105.78 287.33,106.21 287.39,106.21 287.4,106.22 288.64,106.22 288.67,106.26 288.77,106.26 289.39,106.88 290.16,106.88
+5V_USB_PWR1 on IN2 (solid shape): outline of 529 points within 285.09,65.72 296.65,117.16
+5V_USB_PWR2 on BOTTOM (solid shape): 299.69,66.87 299.69,65.85 299.44,65.6 297.33,65.6 297.15,65.42 297.15,64.66 297.1,64.61 296.92,64.61 296.87,64.66 296.87,66.87 297.13,67.12 299.44,67.12
+5V_USB_PWR2 on BOTTOM (solid shape): outline of 250 points within 284.92,85.28 298.3,94.04
+5V_USB_PWR2 on IN4 (solid shape): 302.74,88.84 302.74,66.23 302.36,65.85 297.03,65.85 296.9,65.98 296.9,73.22 299.69,76.01 299.69,76.16 299.7,76.18 299.88,79.09 297.54,80.84 297.53,80.84 292.71,85.66 292.71,88.96 292.96,89.22 302.36,89.22
+5VALWP on TOP (solid shape): 49.8,21.29 49.8,14.69 49.01,13.89 40.03,13.89 33.9,20.03 33.9,24.23 34.32,24.64 46.44,24.64
+5VALWP on BOTTOM (solid shape): outline of 85 points within 28.6,12.96 50.46,25.68
+AVCC33 on TOP (solid shape): 129.51,147.77 129.51,144.46 129.26,144.21 127.23,144.21 126.97,144.46 126.97,146.24 127.1,146.37 127.1,147.64 127.35,147.89 129.39,147.89
+DVCC33 on BOTTOM (solid shape): 122.27,140.91 122.43,140.91 122.67,140.78 122.93,140.86 123,140.88 123.29,140.78 123.58,140.88 123.65,140.86 123.91,140.78 124.15,140.91 124.31,140.91 124.43,140.78 124.43,140.02 123.93,139.51 118.92,139.51 118.72,139.51 118.46,139.26 117.45,139.26 117.19,139.51 117.19,140.65 117.58,141.03 122.15,141.03
+VCC_CORE on TOP (solid shape): outline of 4002 points within 166.33,120.21 198.37,153.22
+VCC_CORE on BOTTOM (solid shape): outline of 2768 points within 168.5,120.33 196.44,153.1
+VCC_CORE on IN1 (solid shape): outline of 7972 points within 166.41,119.57 196.44,153.1
+VCC_CORE on IN3 (solid shape): outline of 8549 points within 168.4,123.32 202.16,153.1
+VCC_CORE on IN4 (solid shape): outline of 8216 points within 166.22,120.27 198.22,153.25
GND on TOP (solid shape): 92.13,174.7 78.52,174.7 78.52,175.2 92.13,175.2
GND on TOP (solid shape): 203.39,21.03 193.39,21.03 193.39,31.03 203.39,31.03
GND on TOP (solid shape): 46.33,78.17 46.33,76.01 46.07,75.76 42.65,75.76 42.52,75.88 42.52,78.17 43.03,78.68 45.82,78.68
GND on TOP (solid shape): 115.7,38.75 115.7,36.67 115.49,36.46 113.5,36.46 113.2,36.77 113.2,38.88 113.45,39.14 115.31,39.14
GND on TOP (solid shape): 148.68,99.14 148.68,85.74 148.23,85.29 144.26,85.29 143.97,85.59 143.97,99.23 144.25,99.51 148.31,99.51
GND on TOP (solid shape): 240.64,35.88 240.64,34.1 240.51,33.97 237.21,33.97 237.08,34.1 237.08,35.88 237.21,36.01 240.51,36.01
GND on TOP (solid shape): 44.93,131.64 44.93,128.72 44.8,128.59 43.92,128.59 43.79,128.72 43.79,131.64 44.04,131.89 44.68,131.89
GND on TOP (solid shape): 118.72,66.74 118.72,61.38 118.54,61.21 117.01,61.21 116.81,61.41 116.81,65.97 116.92,66.07 116.92,66.84 117.07,66.99 118.46,66.99
GND on TOP (solid shape): 140.52,159.82 140.52,155.82 138.67,153.96 135.05,153.96 134.28,154.74 132.92,154.74 132.35,155.31 132.35,160.8 133.72,162.17 138.17,162.17
GND on TOP (solid shape): 21.94,164.15 21.94,163.13 21.31,162.5 19.02,162.5 18.95,162.42 18.95,161.58 18.82,161.46 17.91,161.46 17.63,161.74 17.63,164.02 17.88,164.28 21.82,164.28
GND on TOP (solid shape): 163.3,169.99 163.3,168.09 162.91,167.7 162.71,167.7 162.71,167.7 161.72,167.7 161.39,167.7 161.26,167.83 161.26,170.12 161.39,170.24 163.04,170.24
GND on TOP (solid shape): 204.44,141.8 204.44,140.27 204.82,139.89 204.82,138.24 203.94,137.35 202.92,137.35 202.54,137.73 202.54,138.49 203.05,139 203.05,141.8 203.17,141.92 204.32,141.92
GND on TOP (solid shape): 28.16,51.5 28.23,51.4 28.33,51.33 28.42,51.25 28.42,48.71 28.17,48.45 27.53,48.45 27.28,48.71 27.28,51.25 27.53,51.5
GND on TOP (solid shape): 41.63,66.36 41.63,64.83 41.38,64.58 38.07,64.58 37.82,64.83 37.82,66.1 38.07,66.36 40.74,66.36 40.99,66.61 41.38,66.61
GND on TOP (solid shape): 75.92,175.17 75.92,174.44 75.92,173.67 76.81,172.78 76.81,171.51 72.87,167.58 72.87,165.8 71.6,164.53 66.96,164.53 63.15,168.34 63.15,175.2 75.88,175.2
GND on TOP (solid shape): 35.69,33.01 35.69,29.01 35.58,28.89 35.11,28.89 33.84,28.89 33.28,29.46 32.7,29.46 32.56,29.6 32.56,30.65 32.9,31 32.9,33.02 32.99,33.11 35.6,33.11
GND on TOP (solid shape): 79.86,85.66 79.86,82.11 79.48,81.73 76.94,81.73 76.81,81.85 76.81,82.74 77.44,83.38 77.44,84.27 77.06,84.65 74.14,84.65 73.89,84.9 73.89,86.04 74.01,86.17 79.35,86.17
GND on TOP (solid shape): 89.89,62.68 89.89,61.66 89.76,61.53 87.35,61.53 87.22,61.41 86.59,61.41 86.46,61.53 85.83,61.53 85.7,61.66 85.7,62.29 85.83,62.42 87.35,62.42 87.73,62.8 89.76,62.8
GND on TOP (solid shape): 126.79,157.55 126.79,157.06 126.63,156.9 126.63,155.66 126.56,155.59 125.44,155.59 125.32,155.71 125.32,156.84 124.69,157.48 124.69,157.67 124.69,157.68 124.69,157.94 124.79,158.04 126.31,158.04
GND on TOP (solid shape): 188.76,91.72 188.76,87.33 187.8,86.37 187.8,83.5 187.79,83.49 187.79,81.14 188.24,80.7 188.24,78 187.53,77.29 183.16,77.29 182.55,77.9 182.55,91.78 182.84,92.08 188.4,92.08
GND on TOP (solid shape): 119.34,37.98 119.34,35.68 118.66,35 117.08,35 116.95,35.14 116.95,35.53 117.04,35.63 118.38,35.63 118.67,35.92 118.67,36.46 118.31,36.83 117.13,36.83 116.9,37.06 116.9,38.88 117.06,39.05 118.27,39.05
GND on TOP (solid shape): 29.95,27.37 29.95,25.85 29.87,25.77 29.74,25.69 29.66,25.56 29.44,25.34 29.44,24.58 29.27,24.41 28.24,24.41 28.17,24.49 28.17,27.24 28.55,27.62 29.69,27.62
GND on TOP (solid shape): 70.46,40.96 70.46,39.82 70.79,39.48 73.56,39.48 74.27,40.2 74.9,40.2 75.16,40.45 75.16,40.83 75.41,41.09 76.3,41.09 76.43,40.96 76.43,40.45 74.52,38.55 70.84,38.55 69.82,39.56 69.37,39.56 68.93,39.99 68.93,41.09 69.06,41.21 70.2,41.21
GND on TOP (solid shape): 5.85,131.51 5.85,126.98 6.77,126.06 7.52,126.06 8.96,127.51 9.28,127.51 9.45,127.34 9.45,127.01 7.92,125.49 7.92,124.93 8.96,123.89 9.6,123.89 11.1,125.39 11.42,125.39 11.57,125.24 11.57,124.94 10.06,123.43 6.96,123.43 5.4,124.99 3.57,124.99 2.65,125.91 2.65,125.98 3.29,126.62 3.29,131.53 3.49,131.74 5.62,131.74
GND on TOP (solid shape): 20.62,102.17 22.35,102.17 22.45,102.07 22.45,101.39 21.96,100.91 17.52,100.91 17.25,101.03 16.97,100.91 16.79,100.91 16.72,100.84 14.94,100.84 14.87,100.91 13.33,100.91 13.22,101.03 13.22,101.22 13.29,101.29 15.04,101.29 15.62,101.87 17.1,101.87 17.71,102.48 20.31,102.48
GND on TOP (solid shape): 41.93,54.47 41.93,52.31 41.25,51.63 38.2,51.63 37.57,50.99 37.57,50.1 36.68,49.21 36.68,48.71 36.42,48.45 34.77,48.45 34.64,48.58 34.64,49.34 35.03,49.72 35.03,50.74 34.39,51.37 33.76,51.37 33.5,51.12 33.5,49.72 33.25,49.47 32.49,49.47 32.23,49.21 31.6,49.21 31.34,49.47 31.34,50.99 33.76,53.4 33.76,53.91 34.01,54.17 39.34,54.17 39.85,54.67 41.73,54.67
GND on TOP (solid shape): 78.08,160.29 78.08,158.18 78.04,158.14 78.02,158.15 77.6,157.82 77.98,157.44 78.01,157.44 78.05,157.42 78.98,157.42 79.25,157.69 79.35,157.69 79.41,157.68 79.47,157.69 79.52,157.69 79.66,157.55 79.66,157.27 79.39,156.99 79.39,154.39 78.77,153.77 71.87,153.77 69.35,156.29 69.35,160.57 70.24,161.47 76.91,161.47
GND on TOP (solid shape): 37.65,145.73 37.84,145.68 38.04,145.73 40.99,145.73 41.12,145.61 41.12,143.45 40.74,143.07 40.74,137.61 40.87,137.48 40.87,137.4 40.87,135.95 40.61,135.7 40.61,134.18 40.36,133.92 40.36,131.38 39.85,130.87 39.5,130.87 39.49,130.9 39.24,131.05 38.99,130.9 38.98,130.87 36.8,130.87 36.3,130.37 36.3,129.86 36.17,129.73 35.41,129.73 35.15,129.99 35.15,134.68 36.42,135.95 36.42,145.35 36.8,145.73
