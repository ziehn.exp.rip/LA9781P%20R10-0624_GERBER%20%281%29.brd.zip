# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_PS8513: length 10.9
  TOP w0.203: U44.10 7.93,150.42 v3(8.53,151.02) ; U44.6 8.03,148.42 8.28,148.17 8.28,147.38 8.81,146.85 9.55,146.85 10.06,147.36 C25.1 ; C661.1 3,150.66 3.24,150.42 U44.16
  TOP w0.508: v3(1.36,150.79) 1.49,150.66 C661.1 ; C25.1 10.08,146.67 9.6,146.19 8.18,146.19 v3(7.82,146.55)
  vias: v1(2.28,147) v3(1.71,147.17)
+3.3V_RUN_PWR:
  vias: v1(75.23,35.37)
+3.3V_RUN_TPM: length 13.3
  BOTTOM w0.102: v1(258.1,54.84) 258.01,54.93 258.01,56.11
  BOTTOM w0.254: C550.1 248.36,62.65 U39.24 ; U39.19 252.37,59.4 252.7,59.07 v2(252.73,59.07)
  BOTTOM w0.381: U39.5 258.19,62.65 C48.1 ; C552.1 258.19,59.4 U39.10
  BOTTOM w0.508: v2(258.22,57.8) C551.1 258.21,58.48 C552.1 ; v2(249.05,61.91) 248.92,61.79 C553.1 C550.1
  vias: v2(257.33,62.07) v2(257.91,62.04)
+3.3V_SPI: length 16.7
  BOTTOM w0.102: v3(102.49,70.27) v4(102.49,71.06)
  BOTTOM w0.254: JSPI1.15 104.53,51.37 102.35,53.56 102.03,53.56 101.4,54.19 RH185.2
  BOTTOM w0.508: v3(115.44,61.05) 115.44,61 114.96,60.52 R3665.1 ; v3(100.1,61.68) 100.1,61.48 100.43,61.15 R3666.1 ; v3(102.34,61.68) 102.21,61.81 101.88,61.81 C1216.1 101.65,62.18 101.98,62.51 102.68,62.51 102.89,62.29 U53.8 ; v3(102.49,70.27) 102.49,70.14 101.65,69.3 C746.1 101.88,69.05 102.67,69.05 103.02,69.41 U52.8 ; RH185.2 v3(101.4,54.95) ; R3668.1 v3(100.05,68.39) ; R3664.1 v3(115.47,66.87)
+3.3V_SUS: length 138
  TOP w0.508: v3(111.25,34.86) 111.38,34.99 R589.1 R585.1
  IN2 w0.254: 78.46,46.11 77.52,47.05 73.96,47.05 73.18,46.27 72.08,46.27 71.3,47.05 68.55,47.05 67.77,46.27 67.77,44.56 67.49,44.29 65.48,44.29 65.3,44.11 ; 38.2,69.28 38.2,69.48 37.13,70.55 36.55,70.55 36.17,70.17 35.79,70.17
  IN2 w0.508: 35.79,70.17 36.93,69.03 37.95,69.03 38.2,69.28 ; 79.81,44.77 78.46,43.42 65.99,43.42 65.3,44.11
  IN2 w0.762: 38.2,69.28 38.63,69.28 39.22,68.69 45.64,68.69 49.12,65.22 49.12,49.47 49.56,49.03 49.56,47.17 54.94,41.79 56.8,41.79 57.31,41.28 61.01,41.28 63.83,44.11 65.3,44.11 ; 23.85,79.64 32.05,71.44 34.52,71.44 35.79,70.17 ; 78.46,46.11 79.81,44.77 81.89,44.77 82.52,44.13 92.33,44.13 93.95,42.51 98.07,42.51 98.68,41.9 101.88,41.9 102.18,41.59 105.46,41.59 107.95,39.1
  vias: v3(22.33,79.57) v3(22.83,79.06) v3(108.66,39.1) v3(109.32,39.1) v3(113.87,33.31) v3(116.18,33.32) v4(115.37,35.37)
+3.3V_SUS_PWR: length 1.2
  TOP w0.102: U40.8 102.78,36.93 v1(102.84,36.87)
+3.3V_VCCPRTCSUS: length 26.2
  TOP w0.305: v2(71.09,62.04) 71.09,62.27 70.79,62.57 69.42,62.57 CH53.1
  TOP w0.508: v2(72.08,48.88) 72.08,48.91 71.54,48.37 71.16,48.37 70.51,47.71 69.29,47.71 69.13,47.88 v1(68.19,47.88) RH240.2 RH246.2
  IN1 w0.508: 68.93,62.8 68.53,62.4 68.53,61.35 67.87,60.69 67.87,59.24 69.72,57.38 69.72,56.4 71.04,55.08 71.04,52.95 72.08,51.91 v2(72.08,48.88)
  BOTTOM w0.305: v2(71.09,62.04) 71.09,62.41 UH1.K8
+3.3V_VTR: length 7.8
  IN3 w0.508: v3(239.27,53.07) 239.86,52.48 240.47,52.48 v3(241.04,53.05)
  BOTTOM w0.254: U51.A22 241.8,52.29 v1(241.43,52.66) v3(241.04,53.05)
  BOTTOM w0.381: C739.1 239.27,53.94 v3(239.27,53.07) ; C739.1 R837.2 R834.2 ; C739.1 C1349.1
+3.3V_WLAN: length 40.6
  TOP w0.381: Q124.5 126.03,166.05 v2(125.88,166.21) ; R718.2 129.56,166.05 Q124.2
  TOP w0.508: R726.2 v2(134.42,164.81) ; R718.2 129.97,166.26 130.73,165.49 v2(130.73,165.14) ; v2(137.13,165.16) 137.32,165.35 Q89.2 ; R727.2 131.55,171.64 v2(130.66,172.53) ; v2(129.09,169.46) 128.85,169.46 127.81,168.41 R705.2
  IN3 w0.508: v2(112.85,157.47) 112.93,157.39 114.01,157.39 114.72,156.68 117.37,156.68 v2(118.01,157.32)
  BOTTOM w0.102: C604.1 v4(133.91,155.97)
  BOTTOM w0.508: C603.1 124.23,157.24 124.71,156.76 124.71,155.36 125.53,154.55 R725.2 ; C603.1 124.05,157.62 v2(124.31,157.87) ; C603.1 123.16,157.24 123.09,157.31 JMINI2.24 ; v2(112.85,157.47) 113.28,157.47 C605.1 ; v2(133.53,162.7) 134.29,161.94 JMINI2.52 134.29,158.61 133.91,158.23 C604.1 ; JMINI2.2 111.09,157.49 C608.1 112,157.48 v2(112.01,157.47) ; v2(129.12,170.42) 129.34,170.42 129.72,170.04 C607.2 129.89,170.04 JMINI2.41 ; JMINI2.39 v2(129.09,169.46) ; R728.2 118.55,156.32 118.01,156.87 v2(118.01,157.32)
  vias: v3(100.38,169.41) v3(100.94,169) v3(101.42,169.46) v3(102.08,169.48)
+3VALWP: length 19.8
  IN1 w0.254: v3(45.95,40.96) 44.68,39.69 42.14,39.69 41.38,40.45 39.7,40.45 39.17,39.92 39.17,38.9 38.4,38.14 37.59,38.14 37.41,37.96 33.51,37.96 31.09,40.38 v3(31.09,41.21)
  BOTTOM w0.508: v3(31.09,41.21) 31.09,40.89 31.12,40.86 PR100.1
  vias: v1(50.53,40.42) v3(39.6,47.82) v3(39.6,47.18) v3(39.6,46.55) v3(39.6,45.91) v3(39.6,45.28) v3(39.6,44.64) v3(40.23,46.29) v3(40.23,45.66) v3(45.07,43.63) v3(45.07,42.24) v3(45.19,42.87) v3(45.55,44.15) v3(45.71,43.51) v3(45.7,42.24) v3(45.83,42.87) v3(46.34,42.24)
+5V_ALW: length 495.3
  TOP w0.203: U36.4 72.17,40.39 72.08,40.48 v3(72.08,40.91) ; U63.4 102.45,73.53 102.91,73.08 ; U40.4 100.01,39.24 v3(99.9,39.13) ; U57.4 30.96,33.58 v3(31,33.54)
  TOP w0.381: PR11.1 9.94,99.76
  TOP w0.508: Q75.3 29.31,85.92 v3(29.89,86.5) ; v3(199.98,173.57) 200.09,173.47 PR501.2 ; v3(104.09,71.62) 104.09,71.9 102.91,73.08 ; v3(30.79,83.75) 31.15,83.39 Q86.3 ; v3(271.96,37.5) 271.8,37.35 271.8,36.84 272.24,36.41 272.87,36.41 275.64,33.64 278.97,33.64 v3(281.23,31.38) ; v3(294.31,60.59) 294.31,56.15 v3(293.34,55.18) ; Q79.3 130.05,170 130.05,170.63 129.36,171.31 128.88,171.31 128.27,171.92 128.27,172.43 v3(127.33,173.37) 127.33,172.2 126.64,171.51 122.15,171.51 120.29,173.37 118.13,173.37 117.32,174.18 113,174.18 v3(112.37,174.82) ; PC21.1 11.64,137.85 12.11,138.32 v3(12.5,138.32) ; PC21.1 PC18.1 ; PC21.1 9.99,136.78 PU2.8 ; v3(157.63,162.8) 157.68,162.85 158.81,162.85 PR520.2 ; v3(15.42,103.67) 13.11,103.67 10.81,101.37 10.81,100.69 11.02,100.47 PR11.1 ; JPB1.2 277.49,88.91 278.97,87.43 280.1,87.43 281.35,86.17 v3(281.35,82.66) ; v3(40.82,62.4) 40.82,62.85 40.11,63.56 PC308.1 ; v3(55.57,59.45) 55.57,59.22 54.58,58.23 54.58,57.04 53.44,55.89 53.44,48 60.89,40.55 63.8,40.55 64.29,41.03 v3(64.29,41.34) ; v3(1.34,137) 1.42,137.07 1.58,137.07 1.86,137.35 PR31.2 ; PR531.2 v3(151.81,163.31)
  IN1 w0.508: v3(264.79,37.91) 271.55,37.91 v3(271.96,37.5) ; v3(157.63,162.8) 156.95,162.8 155.52,161.38 153.74,161.38 v3(151.81,163.31) 149.02,163.31 147.8,164.53 147.8,170.98 150.72,173.9 159.76,173.9 160.78,172.89 161.67,172.89 162.08,173.29 163.24,173.29 164.21,174.26 199.3,174.26 v3(199.98,173.57)
  IN1 w1.016: 106.27,166.43 106.53,166.69 109.32,166.69
  IN2 w0.508: v3(72.08,40.91) 72.08,41.14 71.45,41.77 64.72,41.77 v3(64.29,41.34) ; v3(281.35,82.66) 280.92,82.23 280.92,77.53 282.4,76.06 282.4,70.5 279.63,67.73 279.63,62.52 286.97,55.18 v3(292.71,55.18) ; v3(190.85,29.78) 189.96,28.89
  IN2 w1.524: 189.96,28.89 188.44,28.89 187.17,27.62 187.17,21.45 180.69,14.97 180.69,13.02 180.06,12.38 121.64,12.38 117.65,16.37 113.31,16.37 107.92,10.99 86.71,10.99 82.78,14.92 82.78,26.52 83.86,27.6 83.86,32.01 83.03,32.83
  IN3 w0.508: v3(107.24,58.43) 106.3,59.37 106.3,69.41 v3(104.09,71.62)
  IN4 w0.508: v3(151.81,163.31) 146.12,163.31 137.17,172.26 132.04,172.26 130.86,173.44 127.41,173.44 v3(127.33,173.37)
  BOTTOM w0.203: U37.4 54.58,16.57 v3(54.46,16.7) ; PU200.12 150.37,20.28
  BOTTOM w0.254: v3(271.96,37.5) 271.96,37.53 272.4,37.97 U43.4 ; 150.37,20.28 150.37,19.52 PC213.1 150.91,19.07 v3(150.91,19.75) ; U2.5 279.74,83.51 279.91,83.35 C715.1 ; PU300.7 39.6,63.44 40.64,62.4 v3(40.82,62.4)
  BOTTOM w0.508: v3(229.08,20.74) 228.85,20.51 PC727.1 PC728.1 229.13,21.4 229.42,21.68 PU703.8 ; v3(294.31,60.59) 294.03,60.31 R816.2 ; v3(226.69,18.45) 227.33,18.45 PR735.2 ; v3(281.35,82.66) 280.97,82.66 280.66,82.97 C715.1 280.63,83.38 R1614.2 ; v3(62.84,29.66) 62.84,31.69 64.29,33.13 v3(64.29,41.34) ; v3(264.79,37.91) 265.15,37.55 PR1012.2 ; R1630.1 55.9,59.12 v3(55.57,59.45) ; v3(147.24,17.06) 147.84,17.65 PR203.1 ; v3(107.24,58.43) 109.9,55.77 113.89,55.77 114.76,54.9 114.76,52.08 109.17,46.5 109.17,43.02 106.93,40.78 101.5,40.78 99.9,39.18 v3(99.9,39.13) 104.37,34.66 v3(104.37,33.24)
  vias: v3(11.02,71.18) v3(11.02,70.55) v3(11.02,69.91) v3(11.02,69.28) v3(11.02,68.64) v3(11.1,141.58) v3(11.17,140.81) v3(11.58,142.1) v3(11.68,141.28) v3(11.91,71.18) v3(11.91,70.55) v3(11.91,69.91) v3(11.91,69.28) v3(11.91,68.64) v3(12.21,141.68) v3(18.77,154.88) v3(19.02,155.51) v3(19.4,154.88) v3(19.79,155.51) v3(20.04,154.88) v3(20.42,155.39) v3(30.4,31.41) v3(30.94,32.63) v3(30.96,31.97) v3(31.04,31.33) v3(32.05,66.89) v3(32.69,67.07) v3(33.12,65.22) v3(33.32,67.12) v3(33.88,65.22) v3(34.14,67.25) v3(34.11,66.43) v3(34.19,65.77) v3(34.66,66.75) v3(34.77,66.1) v3(36.83,129.45) v3(36.98,128.82) v3(37.36,129.86) v3(37.49,129.22) v3(38.02,129.58) v3(37.95,128.16) v3(40.61,151.83) v3(40.99,151.32) v3(41.35,151.85) v3(41.76,151.32) v3(50.53,17.74) v3(51.28,23.56) v3(51.28,22.8) v3(51.28,22.04) v3(51.28,21.4) v3(51.28,20.77) v3(51.28,20) v3(51.28,19.24) v3(51.28,18.48) v3(51.28,17.72) v3(51.28,16.96) v3(51.28,16.32) v3(51.28,15.69) v3(51.28,15.05) v3(51.28,14.42) v3(51.92,23.31) v3(51.92,22.54) v3(51.92,21.91) v3(51.92,21.15) v3(51.92,20.51) v3(51.92,19.75) v3(51.92,18.86) v3(51.92,18.1) v3(51.92,17.34) v3(51.92,16.7) v3(51.92,15.94) v3(51.92,15.3) v3(51.92,14.54) v3(52.55,23.69) v3(52.55,22.92) v3(52.55,22.04) v3(52.55,21.02) v3(52.55,20.26) v3(52.55,19.37) v3(52.55,18.48) v3(52.55,17.72) v3(52.55,17.08) v3(52.55,16.32) v3(52.55,15.56) v3(52.55,14.8) v3(53.9,18.89) v3(54.15,18.28) v3(54.43,17.67) v3(54.71,18.91) v3(55.07,18.3) v3(55.47,18.86) v3(66.52,152.97) v3(66.55,152.21) v3(67.16,152.46) v3(67.41,153.1) v3(82.47,36.36) v3(83.11,36.36) v3(83.74,36.36) v3(104.32,166.61) v3(104.98,166.61) v3(106.45,173.39) v3(107.01,172.96) v3(107.44,173.52) v3(107.67,172.91) v3(110.62,166.33) v3(111.33,166.15) v3(191.49,29.78) v3(192.12,29.78) v3(292.71,54.55) v3(292.71,53.91) v3(292.71,53.28) v3(293.34,54.55) v3(293.34,53.91) v3(293.34,53.28) v4(293.1,56.17) v4(294.56,53.45) v4(297.24,53.45)
+5V_ALW2: length 3.6
  BOTTOM w0.102: PC118.1 39.25,36.13 v1(39.47,35.92)
  BOTTOM w0.203: PC118.1 38.66,37.96 PU101.13
+5V_ALW_ESATA:
  vias: v1(20.66,159.28)
+5V_ALW_FUSE:
  vias: v1(295.69,59.61)
+5V_ESATA_PWR:
  vias: v3(18.13,166.56) v3(18.39,167.45) v3(18.9,166.82) v3(19.15,167.45) v3(19.84,167.37) v4(17.22,167.21)
+5V_HDD: length 13
  TOP w2.032: 89.71,38.55 89.71,41.65 93.47,45.41 93.47,46.65 94.84,48.02 94.84,49.47
  vias: v3(94.59,50.94) v3(95.27,50.91) v3(95.91,50.91) v3(96.62,50.91) v3(202.39,60.06) v3(202.36,59.42) v3(203.02,59.42) v3(203.05,60.08) v4(201.67,59.89)
+5V_MOD: length 0.8
  BOTTOM w0.102: v4(25.51,31.45) 25.8,31.15 v2(26.24,31.15)
+5V_MXM: length 0.6
  BOTTOM w0.102: v2(43.2,133.21) v4(42.59,133.21)
+5V_MXM_PWR: length 2.1
  TOP w0.102: v1(39.24,130.77) 39.47,130.54 39.94,130.54 40.64,129.85 U35.8
+5V_RUN: length 603.4
  TOP w0.508: v3(125.14,95.24) 125.11,95.28 125.11,97.36 126.31,98.57 C758.1 127.48,100.51 JKB1.10 127.5,101.65 v3(126.77,102.38) 126.93,102.38 127.5,102.94 JKB1.9 ; v3(119.78,31.05) C54.1 119.61,30.11 118.62,30.11 118.41,30.32 JUSH1.14 ; Q80.3 25.56,78.72 24.87,79.41 v3(24.87,80.96) ; R2153.1 v3(20.42,153.81)
  TOP w1.524: 191.24,34.86 191.13,34.86 189.15,32.88 175.12,32.88 173.8,31.56 172.21,31.56 168.15,27.5 166.85,27.5
  IN1 w0.508: v3(20.42,153.81) 20.42,153.58 19.95,153.11 12,153.11 v3(10.68,154.43) ; v3(288.26,58.48) 286.94,58.48 282.57,54.12 273.73,54.12 273.2,54.65 264.19,54.65 263.61,54.07 258.77,54.07 253.8,49.11 v2(253.36,49.11) ; v3(69.24,154.75) 69.24,152.62 68.13,151.51 66.79,151.51 66.37,151.09 66.37,148.76 65.81,148.19 65.53,148.19 64.85,147.51 55.68,147.51 54.92,146.74 43.9,146.74 43.66,146.98 40.79,146.98 v3(40.26,147.51)
  IN1 w1.016: v3(2.13,86.93) 4.48,84.58 4.48,83.5 6.45,81.53 6.45,68.01 9.37,65.09
  IN1 w1.524: 56.87,23.81 54.58,26.1 43.41,26.1 40.35,29.16 28.95,29.16 27.82,30.29 27.82,36.25
  IN2 w0.508: v3(288.26,58.48) 288.26,60.67 290.2,62.6 v3(290.2,64.45)
  IN2 w1.016: 193.52,36.89 194.38,36.89 196.57,39.08 204.3,39.08 205.04,39.83 206.96,39.83 210.51,43.38 210.51,54.85 223.45,67.79 223.45,69.5 222.73,70.22 222.73,74.46 225.12,76.85 225.12,80.68 229.46,85.03
  IN2 w1.524: 27.28,38.37 27.28,44.77 25.63,46.42 25.63,56.45 22.2,59.88
  IN3 w0.508: v3(69.24,154.75) 70.15,155.66 80.37,155.66 81.81,157.1 81.81,158.84 82.75,159.78 84.64,159.78 86.97,162.1 86.97,165.29 89.25,167.58 92.35,167.58 v3(92.78,168.01) ; v3(85.57,106.16) 85.57,106 80.85,101.28 v3(76.48,101.28)
  IN4 w0.508: v2(253.36,49.11) 253.97,48.5 253.97,43.09 254.97,42.1 254.97,39.77 253.52,38.32 253.52,36.34 250.92,33.74 248.93,33.74 247.53,32.35 245.65,32.35 245.08,31.77 234.37,31.77 234.23,31.92 232.51,31.92 231.65,32.78 224.94,32.78 217.96,39.76 210.08,39.76 208.77,38.45 205.81,38.45 204.58,37.22 200.96,37.22 199.95,36.21 193.88,36.21 v3(193.39,35.73)
  IN4 w1.016: 78.08,99.12 79.6,97.6 79.6,92.77 78.59,91.76 78.59,91.12 ; 10.09,156.25 10.09,159.41 14.32,163.64 22.58,163.64 24.1,165.16 32.99,165.16 37.95,160.21 40.87,160.21 43.79,163.13 43.79,164.28
  BOTTOM w0.102: v3(69.24,154.75) v4(69.24,155.46)
  BOTTOM w0.203: U19.21 93.91,108.39 93.75,108.55 93.75,109.68 C1182.1 ; 97.34,110.11 97.31,110.07 97.31,108.7 97.11,108.5 U19.29
  BOTTOM w0.508: v3(24.87,80.96) 24.48,80.58 19.02,80.58 18.34,79.9 17.63,79.9 17.4,79.67 17.4,79.16 16.95,78.72 14.46,78.72 11.53,81.65 11.53,82.87 ; v3(76.48,101.28) 77.76,100 83.53,100 87.31,96.23 101.93,96.23 102.84,97.14 105.35,97.14 106.75,98.54 116.26,98.54 116.66,98.13 122.17,98.13 125.07,95.24 v3(125.14,95.24) ; v3(43.79,166.31) 44.35,166.31 U5.1 44.48,165.67 v3(43.79,165.67) ; v3(40.26,147.51) 39.75,147 36.84,147 33.23,143.4 19.33,143.4 17.8,144.92 17.8,151.07 18.27,151.54 20.42,153.68 v3(20.42,153.81) ; R2193.1 v3(288.26,58.48) ; R1532.1 69.04,107.94 68.55,108.42 v3(68.55,108.83) ; v3(290.2,64.45) 290.2,64.87 289.52,65.55 R2192.1 ; R1537.1 v3(71.02,114.31) ; 97.34,110.11 96.37,111.09 94.13,111.09 93.65,110.6 93.65,109.8 C1182.1 92.62,110.81 91.11,110.81 87.45,107.15 86.56,107.15 v3(85.57,106.16) ; R721.1 45.31,110.12 v3(44.68,110.12)
  vias: v3(2.13,87.82) v3(5.18,117.67) v3(5.69,117.16) v3(9.83,87.77) v3(9.96,88.43) v3(10.04,155.07) v3(10.04,154.43) v3(10.68,155.07) v3(10.64,64.45) v3(10.69,63.82) v3(11.36,63.84) v3(20.67,61.15) v3(21.06,60.64) v3(21.41,61.18) v3(27.94,37.43) v3(28.57,37.43) v3(29.21,37.43) v3(57.5,22.8) v3(57.5,22.16) v3(58.14,22.8) v3(58.14,22.16) v3(58.77,22.8) v3(58.77,22.16) v3(59.41,22.8) v3(59.41,22.16) v3(60.04,22.8) v3(60.04,22.16) v3(67.64,108.83) v3(77.7,89.47) v3(78.46,89.47) v3(91.16,38.55) v3(91.79,38.55) v3(92.43,38.55) v3(92.68,37.02) v3(93.06,38.55) v3(93.45,168.09) v3(95.35,18.86) v3(95.99,18.86) v3(96.62,18.86) v3(97.26,18.86) v3(97.89,18.86) v3(98.53,18.86) v3(164.82,26.1) v3(165.45,26.1) v3(166.09,26.1) v3(192.76,35.75) v3(226.03,86.17) v3(226.03,85.54) v3(229.46,86.42) v3(229.46,85.66)
+5V_RUN_PWR: length 3.6
  BOTTOM w0.102: PJP82.2 57.01,20.6 56.3,21.31 v1(55.36,21.31)
+5V_USB_PWR1:
  vias: v3(289.94,106.64) v3(289.94,105.98) v3(289.94,105.35) v3(289.94,104.69) v3(291.44,114.36) v3(292.07,114.36) v3(292.33,113.73) v3(292.71,114.36) v3(295.78,66.79) v3(295.78,66.15) v3(296.42,66.79) v3(296.42,66.15) v4(288.4,105.6)
+5V_USB_PWR2:
  vias: v3(293.34,86.42) v3(293.34,85.79) v3(293.98,86.42) v3(293.98,85.79) v3(294.61,86.42) v3(294.61,85.79) v3(295.25,86.42) v3(295.25,85.79) v3(297.15,66.79) v3(297.15,66.15) v3(297.79,66.79) v3(297.79,66.15) v3(298.45,66.79) v3(298.45,66.15) v3(299.11,66.79) v3(299.11,66.15) v4(291.67,86.26)
+5VALWP: length 47.4
  IN2 w0.254: v3(35.03,18.91) 33.67,20.27 27.87,20.27 26.4,21.74 26.4,30.62 26.73,30.95 26.73,33.16 28.79,35.22 29.35,35.22 v3(29.82,34.75)
  IN3 w0.508: v3(38.38,37.48) 38.71,37.15 38.71,35.62 38.33,35.24 38.33,32.45 39.34,31.43 39.34,29.27 37.9,27.83 v3(37.9,23.61)
  IN4 w0.254: v3(35.03,18.91) 37.74,18.91 v3(37.82,18.99)
  BOTTOM w0.203: v3(38.38,37.48) 38.3,37.56 PU101.14
  BOTTOM w0.254: v3(29.82,34.75) 29.82,34.19 30.17,33.83 30.53,33.83 31.06,34.36 PR101.1
  vias: v1(40.56,14.3) v3(34.22,23.47) v3(34.22,22.84) v3(34.22,22.2) v3(34.89,23.5) v3(34.89,22.86) v3(34.89,22.23) v3(49.21,15.98) v3(49.21,15.34) v3(49.21,14.71) v3(49.29,20.69) v3(49.29,20.05) v3(49.29,19.42)
+AVCC33: length 1.5
  BOTTOM w0.203: v3(128.29,145.4) 128,145.7 U23.5
  vias: v1(128.89,144.83)
+DVCC33: length 2.9
  BOTTOM w0.203: U23.22 122.53,141.62 122.27,141.36 122.05,141.36 121.89,141.21 121.89,141.03 ; U23.18 124.13,141.6 124.33,141.39 124.33,140.81
  vias: v1(120.61,140.88)
+VCC_4021: length 7.7
  BOTTOM w0.102: v1(35.47,88.53) C277.1
  BOTTOM w0.254: U29.1 36.65,89.88
  BOTTOM w0.508: R393.2 40.44,89.62 39.88,89.07 38.89,89.07 38.45,88.63 R388.2 C1179.1 C277.1 36.68,89.85 36.65,89.88
+VCC_CORE: length 117.7
  TOP w0.254: v3(193.27,152.21) 193.18,152.12 193.18,149.33 PL500.1 ; v3(184,152.08) 184,149.62 PL501.1 ; PR512.2 158.49,156.91 v3(157.78,156.2) ; PL502.1 v3(173.71,152.21)
  TOP w0.508: RC66.1 v3(199.74,148.86)
  IN2 w0.254: v3(154.91,159.07) 154.58,159.41 154.58,159.57 154.76,159.75 158.78,159.75 160.25,158.28 162.05,158.28 167.93,152.4 173.52,152.4 v3(173.71,152.21) ; v3(184,152.08) 183.74,152.34 182.35,152.34 181.46,151.45 181.46,149.8 179.04,147.38 173.71,147.38 170.03,151.07 167.11,151.07 161.69,156.48 160.04,156.48 158.82,157.7 157.94,157.7 v3(157.81,157.57) ; v3(193.27,152.21) 193.08,152.4 191.79,152.4 185.53,146.14 182.73,146.14 182.55,145.96 173.49,145.96 169.78,149.67 165.07,149.67 158.37,156.38 157.96,156.38 v3(157.78,156.2)
  BOTTOM w0.254: v3(157.81,157.57) 157.99,157.57 158.88,158.46 PR544.1 ; v3(154.91,159.07) 154.66,159.32 154.66,160.13 PR555.1
  BOTTOM w0.508: v3(178.12,145.4) PC936.1
  vias: v2(167.06,129.31) v2(168.71,127.51) v2(169.06,128.31) v2(169.16,129.32) v2(169.84,125.73) v2(169.84,124.02) v2(170.06,129.31) v2(170.06,128.31) v2(170.87,127.51) v2(171.06,130.31) v2(171.06,129.31) v2(171.06,128.31) v2(171.55,125.73) v2(171.61,124.02) v2(172.06,129.31) v2(172.06,128.31) v2(172.9,127.51) v2(173.06,129.31) v2(173.06,128.31) v2(173.33,125.73) v2(173.33,124.08) v2(174.06,129.3) v2(174.06,128.31) v2(174.93,127.51) v2(175.06,129.31) v2(175.06,128.31) v2(175.11,125.73) v2(175.17,124.08) v2(176.06,129.31) v2(176.06,128.31) v2(176.88,125.73) v2(176.97,127.51) v2(177.01,124.08) v2(177.06,129.31) v2(177.06,128.31) v2(178.06,132.31) v2(178.06,130.31) v2(178.06,129.31) v2(178.06,128.31) v2(178.6,125.73) v2(178.73,124.08) v2(179.06,130.31) v2(179.06,129.31) v2(179.06,128.31) v2(179.06,127.55) v2(180.01,130.32) v2(180.06,131.31) v2(180.06,128.31) v2(180.44,125.73) v2(180.38,124.08) v2(180.38,122.24) v2(180.38,120.59) v2(180.9,127.51) v2(181.06,139.31) v2(181.06,138.31) v2(181.06,137.31) v2(181.06,136.31) v2(181.06,135.31) v2(181.08,134.28) v2(181.08,133.28) v2(181.08,132.28) v2(181.06,129.31) v2(181.06,128.31) v2(181.15,131.33) v2(181.23,130.32) v2(181.2,124.14) v2(181.46,123.56) v2(181.84,124.14) v2(182.06,138.31) v2(182.06,136.31) v2(182.06,134.31) v2(182.06,132.31) v2(182.06,130.31) v2(182.06,128.31) v2(182.09,123.56) v2(182.6,124.14) v2(182.85,123.56) v2(183.06,139.31) v2(183.06,138.31) v2(183.06,137.31) v2(183.06,136.31) v2(183.06,135.31) v2(183.06,134.31) v2(183.06,133.31) v2(183.06,132.31) v2(183.06,131.31) v2(183.06,130.31) v2(183.06,129.31) v2(183.06,128.31) v2(183.06,127.55) v2(183.74,122.37) v2(183.74,120.78) v2(184,125.79) v2(184.06,138.31) v2(184.06,136.31) v2(184.06,132.31) v2(184.06,130.31) v2(184.06,128.31) v2(184.06,124.14) v2(185.06,139.31) v2(185.06,138.31) v2(185.06,137.31) v2(185.06,136.31) v2(185.06,135.31) v2(185.06,134.31) v2(185.06,133.31) v2(185.06,132.31) v2(185.06,131.31) v2(185.06,130.31) v2(185.06,129.31) v2(185.06,128.31) v2(185.09,127.51) v2(185.9,125.79) v2(185.96,124.14) v2(186.06,138.31) v2(186.06,136.31) v2(186.06,134.31) v2(186.06,132.31) v2(186.06,130.31) v2(186.06,128.31) v2(187.06,139.31) v2(187.06,138.31) v2(187.06,137.31) v2(187.06,136.31) v2(187.06,135.31) v2(187.06,134.31) v2(187.06,133.31) v2(187.06,132.31) v2(187.06,131.31) v2(187.06,130.31) v2(187.06,129.31) v2(187.06,128.31) v2(187.25,127.51) v2(187.68,125.79) v2(187.74,124.14) v2(188.06,138.31) v2(188.06,136.31) v2(188.06,134.31) v2(188.06,132.31) v2(188.06,130.31) v2(188.06,128.31) v2(188.9,127.51) v2(189.06,139.31) v2(189.06,138.31) v2(189.06,137.31) v2(189.06,136.31) v2(189.06,135.31) v2(189.06,134.31) v2(189.06,133.31) v2(189.06,132.31) v2(189.06,131.31) v2(189.06,130.31) v2(189.06,129.31) v2(189.06,128.31) v2(189.46,125.79) v2(189.46,124.21) v2(189.99,130.29) v2(190.06,139.31) v2(190.06,138.31) v2(190.06,137.31) v2(190.06,136.31) v2(190.06,135.31) v2(190.06,134.31) v2(190.06,133.31) v2(190.06,132.31) v2(190.06,131.31) v2(190.06,129.31) v2(190.06,128.31) v2(191.06,128.31) v2(191.09,126.49) v3(171.22,151.24) v3(171.8,150.56) v3(172.06,151.58) v3(172.9,151.24) v3(174.34,151.24) v3(174.98,152.08) v3(175.64,151.24) v3(175.59,149.72) v3(175.89,152.85) v3(176.1,148.96) v3(176.3,150.58) v3(176.4,152.13) v3(176.66,149.72) v3(177.06,151.24) v3(177.85,152.16) v3(178.69,152.85) v3(178.66,151.24) v3(179.3,141.8) v3(179.48,152.21) v3(180.21,151.24) v3(180.49,150.15) v3(180.57,152.06) v3(181.02,145.4) v3(181.03,140.63) v3(181.33,152.59) v3(181.79,141.77) v3(182.42,151.27) v3(183.11,140.62) v3(183.87,141.77) v3(185.11,140.62) v3(185.19,151.27) v3(185.47,152.18) v3(185.49,149.44) v3(185.83,148.6) v3(185.93,152.79) v3(185.88,150.43) v3(185.87,141.77) v3(186.26,149.44) v3(186.66,152.26) v3(186.79,151.32) v3(187.02,146.27) v3(187.11,140.62) v3(187.87,141.77) v3(187.98,151.32) v3(188.09,152.26) v3(188.8,152.82) v3(189.11,140.62) v3(189.15,151.3) v3(189.48,152.26) v3(189.94,146.32) v3(189.87,141.77) v3(190.07,149.26) v3(190.73,148.45) v3(190.8,150.36) v3(191.06,149.34) v3(192,151.32) v3(194.08,152.36) v3(194.31,151.35) v3(195.1,151.98) v3(195.17,152.85) v3(195.15,149.14) v3(195.79,150.86) v3(195.77,150.1) v3(195.91,151.73) v4(173.44,149.71)
+VCCADAC: length 8.3
  TOP w0.102: LH1.2 91.08,63.67 92.18,63.67 v1(92.52,63.34)
  TOP w0.508: CH19.1 86.33,62.93 87.2,62.93 v2(87.54,63.26) 87.71,63.44 CH18.1 89.33,63.44 CH20.1 89.4,63.37 LH1.2
  BOTTOM w0.254: UH1.P45 87.28,63.26 v2(87.54,63.26)
+VCCIO2PCH: length 175.3
  TOP w0.254: v2(72.47,70.5) 72.47,70.5 72.5,70.53 72.5,70.66 72.18,70.98 69.87,70.98 69.52,71.34 68.6,71.34 CH81.1
  TOP w0.508: CC137.1 155.92,128 RC106.2 155.99,126.73 RC105.1 155.42,124.97 155.35,124.97 154.61,124.23 154.61,117.18 v1(150.8,113.37) 140.13,102.71 140.13,92.57 129.42,81.85 v3(127.46,81.85) ; v3(65.91,94.91) 65.91,94.5 58.65,87.24 58.65,84.52 59.23,83.93 59.23,76.47 60.5,75.2 62.03,75.2 65.71,71.51 CH83.1 67.51,71.51 CH82.1 68.41,71.53 CH81.1
  BOTTOM w0.254: UH1.AJ14 73.22,70.02 UH1.AJ12 72.5,70.25 72.5,70.46 72.46,70.5 v2(72.47,70.5)
  BOTTOM w0.508: v3(65.91,94.91) 66.52,95.52 79.58,95.52 81.91,93.18 86.74,93.18 88.04,94.48 107.2,94.48 109.72,96.99 121.36,96.99 122.4,95.95 122.4,85.54 124.69,83.25 126.85,83.25 127.46,82.64 v3(127.46,81.85)
+VCCIO2PCH_R: length 4.3
  TOP w0.508: JCPU1.A23 161.56,126.81 v1(158.33,126.81) RC106.1
+VCCIO_OUT: length 259.5
  TOP w0.305: v2(194.06,139.31) JCPU1.AN35
  TOP w0.508: v3(205.74,125.13) 206.17,124.7 CC66.1 CC65.1 206.24,123.44 JXDP1.11 ; v3(226.25,91.21) 220.43,97.03 v3(218.9,97.03) ; RC63.1 v3(202.28,135.45) 202.61,135.45 203.1,135.93 203.1,136.54 202.41,137.22 RC60.1 201.6,138.06 201.57,138.09 v3(201.52,138.09) ; v3(204.93,145.58) 204.82,145.68 204.19,145.68 202.47,143.97 RC4.1 ; v3(158.98,146.16) 166.3,146.16 v3(168.2,148.06)
  IN1 w0.508: v2(198.91,138.49) 199.13,138.72 200.89,138.72 v3(201.52,138.09)
  IN2 w0.508: v3(203.94,149.92) 203.94,146.57 v3(204.93,145.58) ; v2(194.06,139.31) 191.16,139.31 190.5,139.97 177.67,139.97 177.14,140.5 164.64,140.5 v3(158.98,146.16)
  IN3 w0.508: v3(161.31,173.55) 161.26,173.6 151.69,173.6 146.48,168.38 146.48,166.01 152.4,160.08 157.68,160.08 159.08,158.69 159.08,156.15 167.16,148.06 v3(168.2,148.06) ; v3(205.74,125.13) 205.79,125.08 206.96,125.08 207.62,125.74 207.62,127.52 207.16,127.98 207.16,131.89 v3(206.4,132.65) ; v3(245.82,80.3) 246.1,80.58 247.3,80.58 252.78,75.1 252.78,64.32 250.09,61.64 250.09,59.89 248.24,58.03 v3(248,58.03)
  IN4 w0.508: v2(198.91,138.49) 197.3,140.1 194.42,140.1 194.06,139.74 v2(194.06,139.31)
  BOTTOM w0.508: PR500.2 PR503.2 PR504.2 161.59,173.27 v3(161.31,173.55) ; v3(204.93,145.58) 204.85,145.5 204.04,145.5 203.55,145.02 203.55,143.59 198.91,138.94 v2(198.91,138.49) ; v3(245.82,80.3) 242.9,83.22 235.53,83.22 228.7,90.06 227.89,90.06 226.73,91.21 v3(226.25,91.21) ; RC128.1 200.63,151.24 201.47,152.08 202.89,152.08 203.94,151.04 v3(203.94,149.92) RC44.1 ; v3(206.4,132.65) 203.61,135.45 v3(202.28,135.45) ; v3(218.9,97.03) 217.15,98.77 217.15,100.72 211.96,105.91 v4(211.96,116.22) 208.76,119.42 208.76,121.6 205.74,124.63 v3(205.74,125.13) ; v3(248,58.03) 248,58.08 248.46,58.53 R399.1 ; v3(168.2,148.06) RC65.2
+VCCST: length 18.1
  TOP w0.254: JCPU1.AK31 190.59,134.86 v2(191.06,135.33)
  TOP w0.508: v2(198.43,135.85) 198.43,136.52 199.77,137.86 199.77,138.39 200.76,139.38 CC79.1 CC78.1 201.94,141.63 202.47,142.16 RC99.1
  IN4 w0.254: v2(198.43,135.85) 198.38,135.8 191.66,135.8 191.19,135.33 v2(191.06,135.33)
  BOTTOM w0.102: v2(191.06,135.33) 191.06,135.76 v4(191.2,135.89)
GND: length 6576.7
  TOP w0.102: v3(284.69,93.62) v4(283.91,93.62) ; v3(285.99,95.45) v4(285.99,94.76)
  TOP w0.203: U63.5 102.45,75.62 101.83,74.99 v3(101.7,74.99) ; U44.3 v3(5.69,146.2) ; U9.26 27,158.84 v3(26.77,159.07) ; U57.5 27.96,34.07 C544.2 ; v3(2.75,150.08) 2.91,149.92 U44.17 ; v3(103.53,39.1) 103.39,39.24 U40.11 ; U9.38 v3(24.43,153.24) ; C539.2 107.72,169.71 108.32,170.31 U34.5 ; U9.35 v3(24.43,154.44) ; U36.11 U36.15 ; v3(25.3,150.99) 25.42,151.12 26.01,151.12 26.2,150.92 U9.43
  TOP w0.254: v3(74.24,143.1) 74.24,143.83 74.44,144.03 JMXM1.162 ; UH2.3 62.32,51.08 62.86,50.53 v3(62.99,50.53) ; JCPU1.AA25 v2(182.06,129.31) ; JMXM1.130 v3(64.44,143.75) ; CH45.2 77.2,67.18 77.01,66.99 ; JMXM1.168 75.91,144.87 75.91,143.71 76.12,143.5 76.12,143.09 76.1,143.07 v3(76.1,143.1) ; v3(77.41,143.1) 77.41,144.87 JMXM1.174 ; v3(21.1,86.73) 21.1,86.73 21.07,86.7 JIO1.56 ; v3(78.9,143.1) 78.9,143.06 78.91,143.08 78.91,144.87 JMXM1.180 ; JIO1.74 18.19,81.3 v3(18.03,81.14) ; v3(89.56,59.55) 89.1,59.55 CH15.2 ; v3(70.41,143.1) 70.41,143.06 70.44,143.09 JMXM1.154 ; v3(153.77,172.86) 153.77,173.62 PR525.1 ; JMXM1.136 v3(65.94,143.75) ; v3(178.59,40.63) 178.48,40.52 177.78,40.52 U88.5 ; JMXM1.293 106.69,137.8 v3(106.35,138.14) ; RPH3.6 77.95,83.12 v3(78,83.17) 78.45,82.73 RPH3.5 ; JLVDS1.30 84.24,157.4 v3(84.3,157.47) ; JMXM1.73 v3(50.19,135.55) ; JMXM1.244 94.94,143.93 v3(94.77,143.75) ; JLVDS1.17 90.74,155.44 v3(89.85,154.55) 89.69,154.72 89.69,155.12 89.24,155.56 JLVDS1.20 ; JIO1.39 14.14,91.5 16.51,91.5 v3(16.76,91.76) ; JMXM1.194 82.44,143.21 v3(82.33,143.1) ; JMXM1.232 91.94,143.9 v3(91.79,143.75) ; JMXM1.118 v3(61.44,143.75) ; JMXM1.220 88.94,143.76 v3(88.95,143.75) 88.92,143.73 87.83,143.73 87.44,144.12 JMXM1.214 ; JMXM1.82 52.44,144.22 53.11,143.55 v3(53.11,143.29) ; JCPU1.AH2 188.59,105.78 v2(189.06,105.31) ; U44.13 5.69,150.64 v3(6.3,150.03) ; v3(16.1,102.93) 16.08,102.93 16.05,102.9 JIO1.1 ; v3(87.01,138.31) 87.19,138.12 JMXM1.215 ; v3(85.77,143.1) 85.77,143.07 ; 85.77,143.07 85.77,143.06 85.91,143.21 85.91,144.87 JMXM1.208 ; 85.77,143.07 85.75,143.09 85.49,143.09 84.44,144.15 JMXM1.202 ; v2(85.22,138.29) 85.69,137.82 JMXM1.209 85.69,135.72 85.44,135.47 84.4,135.47 84.19,135.68 JMXM1.203 ; v3(21.08,83.05) 21,83.12 20.98,83.1 JIO1.68 ; JMXM1.245 94.69,138.3 v3(94.68,138.31) ; PR521.2 157.99,174.87 v3(157.99,175.15) ; CH39.2 73.47,66.27 v2(73.73,66.27) ; v2(195.06,139.33) 194.59,138.86 JCPU1.AP35 ; JMXM1.251 v3(96.19,138.3) ; JLVDS1.11 93.74,155.71 92.86,154.83 92.86,153.95 92.18,153.26 v3(92.18,152.08) ; JIO1.112 23.17,69.9 24.92,71.64 v3(24.92,72.48) ; v3(81,157.39) 80.74,157.13 JLVDS1.37 ; D16.3 286.61,99.3 v3(285.99,98.68) ; PU501.4 201.84,168.21 201.92,168.13 v2(202.33,168.13) ; JMXM1.226 90.44,144.22 90.75,143.9 v3(90.75,143.75) ; JLVDS1.40 79.24,157.26 v3(79.4,157.42) ; JMXM1.72 49.94,144.18 50.56,143.56 v3(50.56,143.28) ; JLVDS1.27 85.74,157 86.02,157.28 v3(86.5,157.28) ; JMXM1.88 53.94,143.82 54.22,143.55 v3(54.3,143.55) ; v2(71.22,63.08) 71.22,63.18 70.86,63.54 69.75,63.54 69.54,63.34 CH53.2 ; v3(90.16,138.31) 90.16,138.35 90.19,138.31 90.19,136.7 JMXM1.227 ; JCPU1.AK32 190.59,135.99 v2(191.06,136.46) ; JCPU1.P11 174.57,114.84 v2(174.08,114.35) ; JLVDS1.10 94.24,157.73 94.51,158 v3(94.93,158) 94.93,157.02 94.74,156.83 JLVDS1.9 ; JCPU1.AL32 v2(192.06,136.31) ; v3(16.86,97.5) JIO1.19 ; v3(93.47,143.75) 93.44,143.78 JMXM1.238 ; v3(93.19,138.31) 93.19,136.7 JMXM1.239 ; JMXM1.233 91.69,136.7 v3(91.69,138.31) ; JMXM1.112 59.94,144.11 59.69,143.85 58.54,143.85 v3(58.44,143.75) JMXM1.106 ; JEDP1.37 v3(112.49,155) ; CH30.2 73.78,64.91 v2(73.73,64.96) ; JMXM1.124 v3(62.94,143.75) ; v3(103.69,138.16) JMXM1.281 ; JIO1.7 16.55,101.1 v3(16.56,101.11) 17.75,102.3 JIO1.4 ; JMXM1.100 56.94,144.18 56.44,143.68 55.57,143.68 v3(55.44,143.55) JMXM1.94 ; JMXM1.187 80.19,135.24 v3(80.36,135.07) ; JMXM1.256 97.94,144.03 v3(97.69,143.78) ; JCPU1.AL31 191.59,134.85 v2(192.05,135.31) ; JIO1.62 20.5,84.9 v3(20.62,85.03) ; JMXM1.287 105.19,138.05 105.18,138.06 v3(105.18,138.16) ; JIO1.40 v3(20.67,91.5) ; JMXM1.305 109.69,137.81 109.33,138.16 107.73,138.16 107.72,138.15 ; JMXM1.221 88.69,138.31 88.67,138.33 88.67,138.3 88.68,138.3 v3(88.68,138.3) ; JMXM1.148 v3(68.94,143.1) ; JCPU1.R11 175.59,114.83 175.15,114.39 v2(175.14,114.39) ; U42.5 103.73,169.33 v3(104.06,169.66) ; JMXM1.299 108.19,137.68 107.72,138.15 ; JMXM1.142 v3(67.44,143.75) ; JCPU1.W25 v2(180.06,129.31) ; 107.72,138.15 v3(107.11,138.15) ; JMXM1.250 96.44,143.78 v3(96.47,143.75) ; JCPU1.AT13 JCPU1.AR13 ; U35.5 41.26,128.35 41.55,128.05 v3(41.55,127.8) ; JMXM1.160 v3(71.94,143.1)
  TOP w0.279: JCPU1.AG25 v2(188.06,129.31) ; JCPU1.AC31 v2(184.06,135.31) ; v2(191.06,132.31) JCPU1.AK28 ; JCPU1.AC35 v2(184.06,139.31) ; JCPU1.B22 162.53,125.84 v2(162.06,126.31) ; v2(191.06,133.31) JCPU1.AK29 ; JCPU1.AE27 v2(186.06,131.31) ; JCPU1.AG31 v2(188.06,135.31) ; JCPU1.AC33 v2(184.06,137.31) ; JCPU1.AC27 v2(184.06,131.31) ; JCPU1.D22 164.53,125.84 v2(164.06,126.31) ; v2(193.06,136.31) JCPU1.AM32 ; v2(163.06,126.31) 163.53,125.84 JCPU1.C22 ; v2(197.06,134.31) JCPU1.AT30 ; JCPU1.AC29 v2(184.06,133.31) ; v2(191.06,129.31) JCPU1.AK25 ; v2(196.06,135.31) JCPU1.AR31 ; JCPU1.AE29 v2(186.06,133.31) ; v2(191.06,134.31) JCPU1.AK30 ; JCPU1.AE35 v2(186.06,139.31) ; v2(167.06,126.31) 166.59,126.78 JCPU1.F23 ; JCPU1.AA31 v2(182.06,135.31) ; JCPU1.E22 165.55,125.84 165.05,126.35 v2(165.05,126.35) ; v2(191.06,138.31) JCPU1.AK34 ; JCPU1.AA27 v2(182.06,131.31) ; JCPU1.AA33 v2(182.06,137.31) ; JCPU1.AG27 v2(188.06,131.31) ; v2(186.06,129.31) JCPU1.AE25 ; JCPU1.AG33 v2(188.06,137.31) ; JCPU1.AE31 v2(186.06,135.31) ; v2(194.06,134.31) JCPU1.AN30 ; JCPU1.AC25 v2(184.06,129.31) ; JCPU1.AA29 v2(182.06,133.31) ; v2(197.06,128.31) JCPU1.AT24 ; JCPU1.AG29 v2(188.06,133.31) ; v2(191.06,130.31) JCPU1.AK26 ; JCPU1.AE33 v2(186.06,137.31) ; JCPU1.AG35 v2(188.06,139.31)
  TOP w0.305: v2(170.05,136.34) 170.56,136.84 JCPU1.K33 ; v2(173.06,104.31) JCPU1.N1 ; v2(168.02,115.34) 168.08,115.34 168.58,114.84 JCPU1.H11 ; v2(189.06,109.31) JCPU1.AH5 ; v2(194.06,110.31) 193.59,110.78 JCPU1.AN7 ; v3(174.85,43.63) 174.85,43.55 175.21,43.9 175.61,43.9 175.76,43.76 U88.13 175.76,43.08 175.89,42.94 176.12,42.94 176.26,43.07 U88.12 ; JCPU1.F8 166.53,111.84 v2(166.06,112.31) ; v3(107.87,143.75) 107.94,143.68 JMXM1.296 ; JCPU1.J6 169.59,109.78 v2(170.06,109.31) ; v2(167.06,133.31) 167.53,132.84 JCPU1.G29 ; v2(164.06,111.31) 164.53,110.84 JCPU1.D7 ; v2(187.06,114.31) 186.59,114.78 JCPU1.AF11 ; JMXM1.113 60.19,135.53 v3(60.2,135.52) ; JCPU1.AH8 v2(189.06,112.31) 188.59,112.78 JCPU1.AH9 ; v2(187.06,111.31) 186.59,111.78 JCPU1.AF8 ; v2(192.06,114.31) JCPU1.AL10 ; v2(165.06,117.31) 165.53,116.84 JCPU1.E13 ; v2(172.06,109.31) JCPU1.M6 ; JCPU1.B2 162.53,105.84 v2(162.06,106.31) ; JCPU1.G1 167.54,104.89 167.54,105.79 JCPU1.G2 167.53,105.84 v2(167.06,106.31) ; v2(194.06,107.28) 193.59,107.75 JCPU1.AN4 ; JCPU1.K8 170.53,111.84 v2(170.06,112.31) ; JCPU1.AG6 187.59,109.78 v2(188.06,109.31) ; v2(161.06,123.31) 161.53,122.84 JCPU1.A19 ; JCPU1.AG11 187.59,114.78 v2(188.06,114.31) ; v2(196.16,105.27) 195.6,105.84 JCPU1.AR2 ; JCPU1.AL2 191.59,105.78 v2(192.06,105.31) ; v2(182.06,139.31) JCPU1.AA35 ; v2(179.06,114.31) 179.53,113.84 JCPU1.W10 ; v2(197.06,119.31) 196.59,119.78 JCPU1.AT16 ; JCPU1.F12 166.53,115.84 v2(166.06,116.31) ; v3(172.97,39.64) 173.61,40.27 173.76,40.27 174.96,41.47 U88.16 ; v2(167.07,127.4) 167.05,127.4 166.6,127.84 JCPU1.F24 ; v3(66.19,135.52) 66.19,135.53 JMXM1.137 ; v3(67.69,135.52) 67.69,135.53 JMXM1.143 ; v2(166.06,108.31) 166.53,107.84 JCPU1.F4 ; JCPU1.AM10 192.59,113.78 v2(193.06,113.31) JCPU1.AN10 ; v2(195.06,116.31) 194.59,116.78 JCPU1.AP13 ; JCPU1.AR7 195.59,110.78 v2(196.06,110.31) ; v2(191.06,108.31) 191.06,108.37 JCPU1.AK5 ; v2(170.06,104.31) JCPU1.K1 ; v2(163.06,106.31) 163.53,105.84 JCPU1.C2 ; v2(163.06,120.31) 163.53,119.84 JCPU1.C16 ; v2(197.06,136.31) JCPU1.AT32 ; v2(174.06,108.31) JCPU1.P5 ; v2(192.05,116.32) 191.59,115.86 JCPU1.AL12 ; JCPU1.E19 165.53,122.84 v2(165.06,123.31) JCPU1.D19 ; JCPU1.AN13 193.59,116.78 v2(194.06,116.31) ; JCPU1.B10 162.53,113.84 v2(162.06,114.31) ; JMXM1.161 72.19,138.07 v2(72.44,138.32) ; v2(170.06,114.31) 170.53,113.84 JCPU1.K10 ; JCPU1.D31 164.53,134.84 v2(164.06,135.31) ; JCPU1.AL1 191.59,104.78 v2(192.06,104.31) ; v2(192.06,113.31) JCPU1.AL9 ; v2(164.06,129.3) 164.06,129.32 164.54,128.84 JCPU1.D25 ; v2(196.06,138.31) JCPU1.AR34 ; JCPU1.J11 169.53,114.84 169.05,115.32 v2(169.05,115.28) ; v2(193.06,107.31) 193.06,107.37 JCPU1.AM4 ; v2(170.05,137.35) 170.08,137.33 170.08,137.29 169.59,137.78 JCPU1.J34 ; v2(168.06,114.31) 168.53,113.84 JCPU1.H10 ; v2(192.06,112.31) JCPU1.AL8 ; JCPU1.AP34 194.53,137.84 v2(194.06,138.31) JCPU1.AN34 ; JCPU1.E25 165.59,128.77 v2(165.12,128.31) ; JCPU1.W33 179.59,136.91 179.99,137.31 v2(180.06,137.31) ; v2(189.06,114.31) JCPU1.AH10 ; v2(184.06,111.31) 184.53,110.84 JCPU1.AD7 ; v2(167.06,123.31) JCPU1.F19 ; JCPU1.K35 170.53,138.84 v2(170.06,139.31) ; JMXM1.119 61.69,135.53 v3(61.7,135.52) ; JMXM1.272 101.94,143.79 v3(101.9,143.75) ; v2(161.06,135.31) 161.53,134.84 JCPU1.A31 ; v2(167,120.41) 167,120.43 166.6,120.84 JCPU1.F17 ; JCPU1.C1 163.53,104.84 v2(163.06,105.31) ; v2(164.06,120.31) 164.53,119.84 JCPU1.D16 ; v2(165.06,108.31) 165.53,107.84 JCPU1.E4 ; JCPU1.A13 v2(162.06,117.31) 162.53,116.84 JCPU1.B13 ; JCPU1.A3 161.46,106.84 v2(161.06,107.25) ; v2(161.03,108.25) 161.44,107.84 JCPU1.A4 ; v2(178.06,113.31) JCPU1.V10 ; JCPU1.C28 163.53,131.84 v2(163.06,132.31) ; JCPU1.AR10 v2(195.06,113.31) 194.59,113.78 JCPU1.AP10 ; v2(170.06,108.31) JCPU1.K5 ; JCPU1.W1 179.53,104.84 v2(179.06,105.31) ; JCPU1.AH7 188.59,110.78 v2(189.06,110.31) JCPU1.AH6 ; v2(175.06,108.31) JCPU1.R5 ; JMXM1.175 77.19,135.53 v3(77.19,135.52) ; v2(167.06,139.3) 167.12,139.3 167.58,138.84 JCPU1.G35 ; JCPU1.F11 v2(167.06,115.31) 167.53,114.84 JCPU1.G11 ; v2(193.06,119.31) 192.59,119.78 JCPU1.AM16 ; v2(171.06,114.31) JCPU1.L11 ; U16.3 110.86,126.57 111.45,125.97 v3(111.45,125.26) ; v2(197.16,106.28) 196.6,106.84 JCPU1.AT3 ; v2(195.06,107.31) 194.59,107.78 JCPU1.AP4 ; v2(162.06,123.31) 162.53,122.84 JCPU1.B19 ; v3(64.7,135.52) 64.69,135.52 JMXM1.131 ; v2(175.1,131.31) 175.59,131.8 JCPU1.R28 ; JCPU1.AN16 193.59,119.78 v2(194.06,119.31) ; v2(186.06,105.31) JCPU1.AE1 ; U88.10 177.26,44.1 v3(177.52,44.36) ; JCPU1.AN2 193.59,105.75 v2(194.06,105.28) 194.5,104.84 JCPU1.AP1 ; v2(177.06,114.31) JCPU1.U11 ; v2(179.06,138.31) JCPU1.V34 ; JMXM1.47 43.69,137.58 v3(43.97,137.86) ; JCPU1.R30 175.62,133.84 v2(176.08,134.31) ; v2(168.06,109.31) JCPU1.G5 ; v2(173.06,113.31) JCPU1.N10 ; v2(166.06,123.38) 166.04,123.36 166.04,123.34 166.54,123.84 JCPU1.F20 ; JMXM1.278 103.44,143.94 v3(103.63,143.75) ; JCPU1.C19 163.53,122.84 v2(163.06,123.31) ; JMXM1.107 58.69,135.55 58.67,135.53 v3(58.67,135.52) ; v2(165.06,105.31) 165.53,104.84 JCPU1.E1 ; v2(181.06,114.31) 180.59,114.78 JCPU1.Y11 ; v2(164.06,131.31) 164.53,130.84 JCPU1.D27 ; JCPU1.A7 161.53,110.84 v2(161.06,111.31) ; v2(179.06,136.31) JCPU1.V32 ; JMXM1.95 55.69,135.53 v3(55.67,135.51) ; v3(78.69,135.52) JMXM1.181 ; v2(183.06,113.31) JCPU1.AB9 ; JCPU1.W3 179.53,106.84 v2(179.06,107.31) ; v2(178.06,131.31) JCPU1.U27 ; JCPU1.AE3 v2(186.06,107.31) 185.59,107.78 JCPU1.AE4 ; JCPU1.J28 169.53,131.84 v2(169.06,132.31) ; v2(179.06,132.31) JCPU1.V28 ; v2(196.06,119.31) 195.59,119.78 JCPU1.AR16 ; v2(196.06,107.32) 195.59,107.79 JCPU1.AR4 ; JCPU1.T3 176.53,106.84 v2(176.06,107.31) JCPU1.T4 ; v2(197.06,137.31) JCPU1.AT33 ; JCPU1.C7 163.53,110.84 v2(163.06,111.31) ; JMXM1.83 52.69,135.61 v3(52.6,135.52) ; v2(161.06,114.31) 161.53,113.84 JCPU1.A10 ; JCPU1.AB3 v2(183.06,107.31) 182.59,107.78 JCPU1.AB4 ; v2(183.1,110.49) 183.1,110.31 182.63,109.84 JCPU1.AB6 ; JCPU1.C4 v2(164.06,108.31) 164.53,107.84 JCPU1.D4 ; v2(183.06,104.31) 182.59,104.78 JCPU1.AB1 ; v2(169.06,110.31) JCPU1.H6 ; JMXM1.51 44.69,137.74 v3(44.6,137.83) ; v2(164.06,137.31) 164.53,136.84 JCPU1.D33 ; JCPU1.K31 170.53,134.84 v2(170.06,135.31) 169.59,135.78 JCPU1.J32 ; v2(173.06,110.31) JCPU1.N7 ; v2(170.06,111.31) 170.53,110.84 JCPU1.K7 ; JCPU1.A16 161.53,119.84 v2(161.06,120.31) ; v2(164.06,117.31) 164.53,116.84 JCPU1.D13 ; v2(197.06,138.31) JCPU1.AT34 ; JCPU1.F15 v2(166.06,118.31) 166.53,117.84 JCPU1.F14 ; JCPU1.AT10 196.59,113.78 v2(197.06,113.31) ; v2(173.06,109.31) JCPU1.N6 ; JMXM1.49 44.19,135.57 44.17,135.55 v3(44.17,135.55) ; JMXM1.155 70.69,135.53 v3(70.69,135.52) ; v2(192.06,115.31) JCPU1.AL11 ; v2(77.8,70.85) 77.93,70.73 CH37.2 ; v2(176.06,109.31) JCPU1.T6 ; JCPU1.AE7 185.59,110.78 v2(186.06,110.31) JCPU1.AE6 ; JCPU1.A27 161.53,130.84 v2(161.06,131.31) ; JMXM1.101 57.19,135.54 57.21,135.52 57.22,135.52 57.22,135.52 v3(57.21,135.52) ; v2(163.06,128.31) 163.53,127.84 JCPU1.C24 ; v2(163.06,114.31) 163.53,113.84 JCPU1.C10 ; v3(18.08,89.35) 18.21,89.35 18.57,89.7 JIO1.46 ; v2(167.06,122.31) JCPU1.F18 ; JCPU1.J26 169.53,129.84 v2(169.06,130.31) JCPU1.H26 ; v3(11.96,77.42) 12.99,77.42 13.31,77.1 JIO1.87 ; v2(166.06,113.31) 166.53,112.84 JCPU1.F9 ; v2(169.06,134.31) 169.53,133.84 JCPU1.J30 ; JCPU1.T26 176.66,129.84 v2(177.08,130.26) ; v2(164.06,114.31) 164.53,113.84 JCPU1.D10 ; v2(170.06,107.31) JCPU1.K4 ; JCPU1.F26 166.53,129.84 v2(166.06,130.31) ; JCPU1.AC11 183.59,114.78 v2(184.06,114.31) ; JMXM1.89 54.19,135.54 v3(54.18,135.52) ; JCPU1.G27 167.53,130.84 v2(167.06,131.31) 166.59,131.78 JCPU1.F28 ; JMXM1.125 63.19,135.53 v3(63.19,135.52) ; JCPU1.L26 171.67,129.84 v2(172.11,130.28) ; v3(75.69,135.52) 75.69,135.53 JMXM1.169 ; v2(197.06,110.31) 196.59,110.78 JCPU1.AT7 ; JCPU1.K9 170.53,112.84 v2(170.06,113.31) ; v2(167.06,107.31) 167.53,106.84 JCPU1.G3 ; v2(162.06,120.31) 162.53,119.84 JCPU1.B16 ; JMXM1.290 106.44,143.89 106.55,143.78 106.5,143.73 106.5,143.78 v3(106.5,143.77) ; v2(173.06,133.36) 173.04,133.36 173.1,133.3 173.12,133.3 173.31,133.1 173.31,133.07 173.54,132.84 JCPU1.N29 ; v2(192.06,118.31) JCPU1.AL14 ; JCPU1.AK11 190.59,114.78 v2(191.06,114.31) ; JCPU1.F10 166.53,113.84 v2(166.06,114.31) ; JCPU1.A25 161.53,128.84 v2(161.06,129.31) ; v2(162.06,111.31) 162.53,110.84 JCPU1.B7 ; JCPU1.AP16 194.59,119.78 v2(195.06,119.31) ; v3(15.59,87.85) 15.59,87.85 15.54,87.9 JIO1.51 ; v2(192.06,119.31) JCPU1.AL15 ; JCPU1.E7 165.53,110.84 v2(165.06,111.31) ; JCPU1.F6 166.53,109.84 v2(166.06,110.31) ; v2(173.06,112.31) JCPU1.N9 ; JCPU1.H7 168.53,110.84 v2(168.06,111.31) ; JCPU1.C26 v3(164.06,130.31) ; v2(186.06,114.31) JCPU1.AE10 ; v2(195.06,110.31) 194.59,110.78 JCPU1.AP7 ; v2(182.03,110.3) 182.57,110.84 JCPU1.AB7 ; JCPU1.AB10 182.51,113.84 182.36,113.99 182.35,114 182.34,114 182.29,114.04 182.25,114.09 182.24,114.11 182.06,114.29 v2(182.06,114.31) 181.59,114.78 JCPU1.AA11 ; v2(175.06,113.31) JCPU1.R10 ; v2(165.06,114.31) 165.53,113.84 JCPU1.E10 ; JCPU1.AJ5 189.59,108.78 v2(190.06,108.31) ; JCPU1.C13 163.53,116.84 v2(163.06,117.31) ; JCPU1.D35 164.53,138.84 v2(164.06,139.31) ; v2(190.06,114.31) 189.59,114.78 JCPU1.AJ11 ; JCPU1.W9 179.53,112.84 v2(179.06,113.31) ; JCPU1.AL3 191.59,106.78 v2(192.06,106.31) ; v2(179.06,110.31) 179.53,109.84 JCPU1.W6 ; JCPU1.G4 167.53,107.84 v2(167.06,108.31) ; JCPU1.R34 175.53,137.84 v2(175.06,138.32) ; v2(189.06,107.31) JCPU1.AH3 ; v2(177.06,135.31) JCPU1.T31 ; v2(173.06,107.31) JCPU1.N4 ; v2(177.06,133.31) JCPU1.T29 ; JCPU1.G31 167.53,134.84 v2(167.06,135.31) ; v2(163.06,108.31) JCPU1.B4 ; v2(162.06,126.31) JCPU1.A22 ; JCPU1.B34 v2(163.06,138.31) 163.53,137.84 JCPU1.C34 ; v2(165.06,120.31) 165.53,119.84 JCPU1.E16 ; v2(192.06,111.31) JCPU1.AL7 ; v2(172.06,114.31) JCPU1.M11 ; v2(171.06,109.31) JCPU1.L6 ; v2(176.06,112.31) JCPU1.T9 ; JCPU1.C32 v2(164.06,136.31) ; v3(105,143.77) 104.94,143.83 JMXM1.284 ; v3(16.86,89.57) 16.74,89.7 JIO1.45 ; JCPU1.AD11 184.59,114.78 v2(185.06,114.31) ; v2(186.06,113.31) JCPU1.AE9 ; JCPU1.AL4 191.59,107.78 v2(192.06,107.31) ; v2(179.06,134.31) JCPU1.V30 ; v3(44.47,134.99) 45.19,135.7 JMXM1.53 ; v2(170.06,105.31) JCPU1.K2 ; v2(194.06,128.31) JCPU1.AN24 ; v2(179.06,108.31) 179.53,107.84 JCPU1.W4 ; JMXM1.163 74.19,137.63 74.88,138.32 v2(75.56,138.32) ; v2(178.06,114.31) JCPU1.V11 ; v2(173.06,106.31) JCPU1.N3 ; JCPU1.F34 166.59,137.78 v2(167.06,137.31) 167.53,136.84 JCPU1.G33 ; v3(69.19,135.52) 69.19,135.53 JMXM1.149 ; v2(161.06,133.31) 161.53,132.84 JCPU1.A29 ; C392.2 172.81,41.8 174.17,41.8 174.34,41.97 U88.15 ; JCPU1.F7 166.53,110.84 v2(166.06,111.31) ; JCPU1.T1 176.59,104.87 v2(176.11,105.35) ; v2(176.06,113.31) JCPU1.T10 ; v2(187.05,110.34) 186.59,109.88 JCPU1.AF6 ; v2(176.06,110.31) JCPU1.T7 ; v2(180.06,139.31) JCPU1.W35 ; v2(170.06,106.31) JCPU1.K3 ; v2(189.06,108.31) JCPU1.AH4 ; v2(166.06,124.31) JCPU1.F21 ; v2(189.06,105.31) JCPU1.AH1
  TOP w0.33: v2(187.2,52.85) 187.2,52.78 187.14,52.73 JDIMM3.8 ; v2(167.06,111.31) JCPU1.F7 ; v2(189.06,111.31) JCPU1.AH7 ; JCPU1.AR10 195.59,113.78 v2(196.06,113.31) ; JCPU1.H6 168.59,109.78 v2(169.06,109.31) ; JCPU1.AN10 193.59,113.78 v2(194.06,113.31)
  TOP w0.356: v2(179.47,69.49) 179.61,69.49 180.24,70.12 JDIMM1.31 ; JDIMM3.20 183.54,48.63 183.26,48.35 v3(183.26,48.11) ; v2(146.79,74.35) 146.79,74.32 147.24,73.87 JDIMM1.133 ; v2(171.47,48.14) 171.54,48.2 JDIMM3.60 ; JDIMM3.150 v3(142.14,48.11) ; v2(146.85,67.64) 146.86,67.64 147.03,67.64 148.74,65.94 JDIMM1.128 ; JDIMM3.196 128.34,48.52 v2(128.73,48.14) ; JDIMM1.168 136.74,62.68 ; 181.97,59.55 182.02,59.6 183.82,59.6 v2(183.87,59.55) 183.84,59.52 JDIMM3.19 ; 181.97,59.55 182.04,59.48 JDIMM3.25 ; 181.97,59.55 180.47,59.55 180.24,59.32 JDIMM3.31 ; v2(145.69,48.14) 145.74,48.19 JDIMM3.138 ; JDIMM3.38 178.14,48.28 v2(178.28,48.14) ; JDIMM3.144 143.94,48.24 v2(143.84,48.14) ; JCPU1.B4 162.53,107.84 v2(162.06,108.31) ; JDIMM1.63 170.64,68.62 v2(171.01,68.25) ; JDIMM1.46 175.74,66.49 v2(175.81,66.56) 176.34,66.02 JDIMM1.44 ; JDIMM3.167 137.04,59.34 ; v2(133.7,67) 133.15,66.45 133.15,65.96 133.74,65.37 JDIMM1.178 133.74,62.64 ; JDIMM1.187 131.04,71.07 130.5,70.54 130.5,69.13 v2(131.67,67.96) ; v2(148.54,48.14) 148.74,48.34 JDIMM3.128 ; JDIMM3.155 140.64,59.45 ; JDIMM3.54 173.34,48.35 v2(173.13,48.14) ; v2(174.44,66.77) 174.53,66.77 175.14,66.16 JDIMM1.48 ; JDIMM1.61 171.24,69.96 171.63,69.57 v2(172.28,69.57) ; JDIMM3.156 140.34,48.18 v3(140.41,48.11) ; JDIMM1.127 149.04,70.4 147.98,69.34 v2(146.86,69.34) ; JDIMM3.3 188.64,59.43 v2(188.94,59.73) 188.79,59.88 187.21,59.88 186.84,59.51 JDIMM3.9 ; JDIMM3.2 188.94,48.31 v2(188.77,48.14) ; v3(133.5,48.11) 133.74,48.35 JDIMM3.178 ; JDIMM3.195 128.64,59.43 v2(128.6,59.47) ; JDIMM3.48 175.14,48.35 v2(174.93,48.14) ; JDIMM1.161 138.84,73.36 139.04,73.56 139.04,74.04 139.06,74.07 v2(139.05,74.07) 139.04,74.07 138.99,74.12 137.6,74.12 137.04,73.55 JDIMM1.167 ; JDIMM1.153 141.24,71.19 140.42,70.37 140.42,68.89 v2(140.26,68.73) ; v2(148.87,59.78) 149.04,59.61 JDIMM3.127 ; v2(140.41,62.62) 140.34,62.69 JDIMM1.156 ; 146.34,62.61 JDIMM1.136 146.34,65.29 146.29,65.34 146.29,65.78 146.63,66.13 v2(146.91,66.13) ; 182.97,69.47 182.04,70.4 JDIMM1.25 ; 182.97,69.47 v2(183.15,69.47) ; 182.97,69.47 182.94,69.47 181.74,68.27 181.74,65.97 181.14,65.37 JDIMM1.28 ; v3(130.3,48.11) 130.14,48.27 JDIMM3.190 ; JDIMM3.145 143.64,59.47 ; v2(174.39,68.46) 173.51,69.34 173.51,70.8 173.04,71.27 JDIMM1.55 ; JDIMM3.151 141.84,59.5 ; v2(169.4,66.76) 167.94,65.3 JDIMM1.72 ; v2(138.74,66.82) 138.49,66.82 138.2,66.54 138.2,65.77 138.54,65.44 JDIMM1.162 138.54,62.68 ; v2(169.43,69.68) 170.04,70.29 JDIMM1.65 ; JDIMM1.2 188.94,63 v2(188.63,62.69) ; JDIMM3.44 176.34,48.2 v2(176.4,48.14) ; JDIMM3.161 138.84,59.44 ; v2(145.29,67.44) 145.74,66.99 JDIMM1.138 145.74,62.48 v2(145.74,62.47) ; v3(175.74,48.11) JDIMM3.46 ; v2(135.24,48.14) 135.54,48.44 JDIMM3.172 ; JDIMM1.14 185.34,65.14 185.71,65.51 185.71,65.91 v2(185.15,66.47) ; v2(128.93,62.68) 128.95,62.68 128.92,62.64 128.66,62.64 128.34,62.96 JDIMM1.196 ; v2(174.39,69.99) 174.61,69.99 174.94,70.31 174.94,70.98 174.84,71.08 JDIMM1.49 ; v2(180.11,48.14) 179.94,48.31 JDIMM3.32 ; JDIMM3.153 141.24,59.58 ; JDIMM1.151 141.84,71.1 141.14,70.4 141.14,68.92 141.84,68.22 v2(141.96,68.22) ; JDIMM3.168 136.74,48.44 v2(137.04,48.14) ; JDIMM1.38 178.14,65.54 179.35,66.74 v2(179.48,66.74) ; 136.14,62.7 JDIMM1.170 136.14,66.44 v2(136.7,67) ; v2(135.43,68.91) 135.24,69.1 JDIMM1.173 ; JDIMM1.195 128.64,71.09 128.43,70.88 128.03,70.88 127.77,70.63 127.77,70.05 v2(128.34,69.48) ; v2(129.87,69.86) 129.87,70.61 130.44,71.18 JDIMM1.189 ; 135.54,62.54 135.54,62.59 v2(135.51,62.62) 135.54,62.66 JDIMM1.172 135.54,66.52 v2(135.43,66.62) ; v2(176.63,60.25) 176.64,60.26 JDIMM3.43 ; JDIMM1.11 186.24,69.13 v2(187,68.37) ; JDIMM1.19 183.84,71.3 184.03,71.1 184.03,69.11 v2(185.15,67.99) ; JDIMM3.71 168.24,59.45 v2(168.37,59.58) ; JDIMM3.72 167.94,48.35 v2(168.15,48.14) ; JDIMM3.184 131.94,48.23 v2(131.85,48.14) ; JDIMM3.139 145.44,59.42 ; v2(185.15,69.52) 185.7,70.06 185.7,70.94 185.64,71 JDIMM1.13 ; v2(138.74,68.35) 139.91,69.52 139.91,70.56 140.64,71.29 JDIMM1.155 ; JDIMM1.8 187.14,65.94 v2(187,66.09) ; JDIMM3.134 v3(146.94,48.11) 146.34,48.71 JDIMM3.136 ; v2(183.15,68.17) 182.72,68.17 182.35,67.81 182.35,65.57 181.74,64.96 JDIMM1.26 ; JDIMM3.189 130.44,59.34 ; JDIMM1.134 146.94,62.65 ; JDIMM1.71 168.24,69.34 v2(169.43,68.16) ; JDIMM3.179 133.44,59.62 v2(133.64,59.82) ; v2(183.17,66.7) 183.34,66.7 183.79,66.25 183.79,65.39 183.54,65.14 JDIMM1.20 ; JDIMM3.61 171.24,56.63 171.4,56.47 v2(171.4,55.39) ; JDIMM3.187 131.04,59.37 ; JDIMM1.37 178.44,69.06 179.24,68.25 v2(179.51,68.25) ; v2(144.02,67.94) 143.58,67.94 143.18,67.55 143.18,65.78 143.94,65.02 JDIMM1.144 143.94,62.62 ; JDIMM1.60 171.54,62.96 172.26,62.24 v2(172.69,62.24) 172.59,62.14 170.18,62.14 169.74,62.58 JDIMM1.66 ; JDIMM3.11 186.24,59.14 v2(185.78,59.6) 185.64,59.46 JDIMM3.13 ; v2(181.14,48.14) JDIMM3.28 ; JDIMM3.55 173.04,59.22 173.29,59.47 v2(173.61,59.47) ; JDIMM3.37 178.44,60.23 178.4,60.27 v2(178.4,60.24) ; JDIMM3.170 136.14,48.19 v2(136.19,48.14) ; JDIMM1.145 143.64,70.69 142.44,69.49 v2(141.96,69.49) ; JDIMM3.66 169.74,48.65 v2(170.25,48.14) ; v2(172.28,68.05) 173.34,66.99 JDIMM1.54 ; JDIMM3.63 170.64,59.46 170.41,59.69 169.86,59.69 v2(169.82,59.65) ; JDIMM1.43 176.64,70.46 177.12,69.99 v2(177.38,69.99) ; JDIMM3.173 135.24,59.36 ; v2(145.29,69.72) 145.29,71 145.44,71.15 JDIMM1.139 ; v3(191.77,70.65) 188.87,70.65 188.64,70.88 JDIMM1.3 188.64,76.6 187.4,77.84 ; v2(188.63,68.58) 188.63,68.58 188.63,68.51 186.84,70.3 JDIMM1.9 ; v2(142,66.66) 141.8,66.66 141.43,66.28 141.43,65.82 142.14,65.11 JDIMM1.150 142.14,62.6 ; JDIMM1.185 131.64,70.97 131.11,70.45 131.11,70.04 v2(131.67,69.48) ; JDIMM1.32 179.94,65.16 180.85,66.07 v2(180.85,66.42) ; JDIMM3.49 174.84,59.23 174.62,59.45 v2(174.27,59.45) ; v2(181.79,48.14) 181.74,48.19 JDIMM3.26 ; v2(133.7,70.05) 133.16,70.6 133.16,71.04 133.44,71.33 JDIMM1.179 ; JDIMM1.190 v2(130.14,62.68) ; JDIMM1.184 131.94,62.69 ; JDIMM3.162 v3(138.54,48.11) ; JDIMM3.185 131.64,59.34 ; JDIMM3.14 v2(185.34,48.14) ; 147.24,59.54 JDIMM3.133
  TOP w0.381: JCPU1.AM21 v2(193.06,125.31) ; JCPU1.M26 172.55,129.84 v2(172.11,130.28) ; v2(84.35,68.54) 84.94,67.96 CH58.2 ; v2(196.06,122.31) 195.59,122.78 JCPU1.AR19 ; v3(123.86,132.09) 123.86,132.31 123.69,132.49 U27.3 ; JCPU1.M28 v2(173.06,132.31) ; v2(176.04,130.31) 176.05,130.31 175.59,129.86 JCPU1.R26 ; JCPU1.M32 v2(173.06,136.31) ; JCPU1.N2 173.53,105.84 v2(173.06,106.31) ; JCPU1.AL20 v2(192.06,124.31) ; JCPU1.W7 179.59,110.8 v2(180.03,110.36) ; U60.3 10.44,143.88 v3(10.04,143.49) ; v2(197.06,122.31) 196.59,122.78 JCPU1.AT19 ; JCPU1.AT4 196.58,107.84 v2(196.06,107.32) ; v2(161.09,137.3) 161.55,136.84 JCPU1.A33 ; v2(197.16,106.28) 197.42,106.54 200.62,106.54 ; v3(40.42,74.3) 40.12,73.99 Q304.4 ; JCPU1.AM20 v2(193.06,124.31) ; JCPU1.AL21 v2(192.06,125.31) ; v2(192.06,109.31) 191.59,109.78 JCPU1.AL6 ; v2(81.79,70.52) 81.23,71.08 CH65.2 ; Q336.1 17.23,149.37 v3(16.69,149.91) ; v2(195.06,122.31) 194.59,122.78 JCPU1.AP19 ; Q336.4 18.78,151.13 v3(19.12,150.79) ; JCPU1.AM22 v2(193.06,126.31) ; JCPU1.P26 174.59,129.84 v2(175.06,130.31) ; v2(174.06,137.3) 173.6,136.84 JCPU1.N33 ; v2(192.06,122.31) 191.59,122.78 JCPU1.AL19 ; JCPU1.AN27 v2(194.06,131.31) ; JCPU1.AR26 v2(196.06,130.31) ; JCPU1.N31 173.53,134.84 v2(173.06,135.31) ; JCPU1.R32 175.59,135.8 v2(176.08,135.31) ; JDIMM3.65 170.04,59.43 v2(169.82,59.65) ; v3(149.35,168.03) 149.36,168.05 150.23,168.05 PR558.1 ; JCPU1.M30 172.53,133.84 v2(172.06,134.31) ; JCPU1.M34 172.59,137.78 v2(173.07,137.3) ; v2(166.06,136.31) 166.53,135.84 JCPU1.F32 ; v3(114.98,125.48) 114.83,125.63 114.88,125.63 113.78,126.73 U17.3 ; JCPU1.T33 176.59,136.78 177.07,136.3 v2(177.07,136.28) ; JCPU1.AL5 191.59,108.78 v2(192.06,108.31) ; v2(80.82,54.72) 80.78,54.72 80.24,55.27 80.24,56.36 79.87,56.73 CH51.2 ; JCPU1.AM25 192.59,128.78 v2(193.06,128.31) JCPU1.AM24 ; JCPU1.D29 164.63,132.84 v2(165.1,133.31) ; v2(192.06,117.31) 192.53,116.84 JCPU1.AM13 ; v3(206.53,106.49) 206.53,106.16 206.24,105.87 UC2.3 ; U15.3 106.15,95.71 105.94,95.91 v3(105.94,96.25) ; JCPU1.AN21 v2(194.06,125.31) ; JCPU1.AT21 v2(197.06,125.31) ; CH66.2 77.11,56.43 v2(76.71,56.43) ; v2(194.06,122.31) 193.59,122.78 JCPU1.AN19 ; JCPU1.AM7 v2(192.06,110.31) ; JCPU1.AM19 192.59,122.78 v2(193.06,122.31) ; CH40.2 68.54,66.64 v2(69.05,66.13) ; v2(174.06,108.31) 173.59,108.78 JCPU1.N5 ; U25.3 118.35,133.08 118.47,132.97 118.91,132.97 v3(119,132.88) ; UH3.3 55.64,77.72 v3(55.63,77.74) ; v3(121.12,132.4) 121.02,132.5 U14.3 ; UC1.3 v3(207.98,151.61) ; JCPU1.T35 176.59,139.44 v2(176.68,139.54) ; v2(174.04,139.41) 173.59,138.96 JCPU1.N35 ; CH43.2 76.56,66.55 77.01,66.99 v2(77.01,66.97) ; v3(16.76,93.1) 16.57,93.3 JIO1.33 ; JCPU1.AR13 v2(195.06,116.31) ; 7.74,99.76 v3(6.53,99.76) ; U20.7 v3(58.82,103.8) ; JCPU1.AL23 v2(192.06,127.31) ; JCPU1.AR28 v2(196.06,132.31) ; CH36.2 82.67,72.11 83.06,71.72 v2(83.06,71.49) ; JCPU1.AL24 v2(192.06,128.31) ; JCPU1.AT27 v2(197.06,131.31) ; JCPU1.C30 163.59,133.78 v2(164.06,133.31) ; JCPU1.AL18 191.59,121.78 v2(192.06,121.31) JCPU1.AL17 ; v2(73.28,71.74) 73.28,71.11 CH49.2 ; v3(40.84,69.47) 40.84,72.52 41.02,72.69 Q304.1 ; JCPU1.F30 166.59,133.78 v2(167.06,133.31) ; v3(89.61,58.31) 89.56,58.36 CH76.2 CH80.2 ; JCPU1.AL22 v2(192.06,126.31) ; JCPU1.AP27 v2(195.06,131.31) ; U58.3 30.82,87.17 31.19,87.55 v3(31.19,87.77) ; JCPU1.AR22 v2(196.06,126.31) ; JCPU1.AM23 v2(193.06,127.31) ; JCPU1.AR25 v2(196.06,129.31) ; JCPU1.K29 v2(171.06,133.31)
  TOP w0.406: PU701.1 48.84,39.52 v3(49.16,39.84) 49.49,39.51 PU701.2
  TOP w0.457: v2(82.96,66.96) 82.96,67.75 CH71.2 ; RH150.2 81.51,57.71 81.51,56.1 81.84,55.77 v2(82.24,55.77)
  TOP w0.508: JKB1.16 v3(124.5,102.08) JKB1.15 ; v3(112.62,30.21) 112.42,30.21 111.91,30.72 C51.2 ; R45.1 10.97,150.58 v3(11.38,150.99) ; v2(65.22,56.5) 65,56.28 CH4.1 ; v3(193.27,7.56) 193.84,6.99 PC4.2 ; v3(206.48,58.18) 204.53,56.23 JSATA1.13 ; PC309.2 43.85,53.06 v3(43.28,52.49) 43.24,52.45 v4(41.5,52.45) ; C56.2 v3(112.39,28.59) ; PC20.2 v3(1.42,135.45) ; C498.2 87.81,37.06 v3(87.81,37.83) ; CD4.2 v2(155.27,81.42) ; v3(33.37,59.09) 33.69,59.09 34.38,58.41 PC303.2 ; v3(50.51,39.81) 50.55,39.85 PC701.2 ; JODD1.4 v3(25.91,37.82) ; R783.2 v3(22.53,167.37) ; JMXM1.311 25.52,140.8 v3(24.97,140.25) ; C1332.2 R491.1 v3(22.5,150.99) ; v3(11.56,91.63) 11.56,91.66 11.28,91.94 PR12.1 ; v3(110.21,132.09) 109.45,131.33 C90.2 ; v3(158.57,79.39) 159.1,78.86 CD9.2 ; RD13.1 v3(127.02,78.5) ; CH35.2 79.09,66.48 78.61,66 v2(78.61,65.62) ; CC137.2 157.39,128.79 157.54,128.94 v3(157.55,128.94) ; v3(125.32,76.77) CD18.2 CD17.2 ; RD43.2 175.08,45.05 v3(175.08,45.68) 175.08,45.76 174.55,46.29 173.91,46.29 173.33,45.71 RC109.2 ; C332.2 117.07,145.33 v3(117.65,144.74) 117.25,144.34 C8.2 ; CH21.2 75.03,77.61 74.12,76.7 74.12,76.09 74.23,75.97 v2(74.23,75.6) ; v3(118.59,91.86) 118.24,91.5 C466.2 117.91,92.52 C470.2 ; v3(34.9,159.35) 35.28,159.73 R69.1 ; PC18.2 v3(12.56,135.14) ; v3(34.39,148.07) 33.87,148.07 C766.2 32.88,148.07 C402.2 ; 123.67,137.55 v3(123.67,138.24) ; C662.2 1.81,149.31 v3(1.41,149.71) ; v3(176.41,145.38) 176.41,146.75 PC936.2 ; v2(69.26,70.7) 69.16,70.6 CH81.2 68.41,70.62 CH82.2 67.51,70.6 CH83.2 ; U33.2 114.72,169.36 C396.2 115.16,170.24 114.07,171.34 v2(114.07,171.71) ; R61.1 24.61,147.82 v3(25.14,147.28) ; v3(111.4,33.47) 111.96,32.91 ; 111.96,32.91 C55.2 ; 111.96,32.91 111.96,33.06 v3(112.37,33.47) ; v3(187.81,42.99) 189.35,42.99 JDIMM3.206 ; C536.2 102.7,171.58 v3(101.67,172.61) ; v3(60.63,69.25) 60.58,69.3 59.46,69.3 59.08,68.92 RH223.2 ; C243.2 90.14,152.59 v3(90.65,152.08) ; JBT1.10 293.56,106.98 v3(292.9,107.65) ; R222.1 120.12,149.94 v3(119.73,149.56) ; CD5.2 155.88,78.37 v2(155.56,78.69) 155.47,78.61 CD8.2 ; R63.1 29.31,147.79 29.18,147.66 v3(29.18,147.21) ; v3(12.62,134.4) 12.62,133.52 12.98,133.16 C774.2 ; CH67.2 80.24,67.6 v2(80.24,67.6) ; C1338.2 27.43,166.08 v3(27.43,166.94) ; CH25.2 75.55,67.41 v2(75.36,67.6) ; C1334.2 v3(37.51,165.14) ; R1989.2 125.02,142.89 v3(125.58,143.45) 126.01,143.45 C111.2 ; v3(5.94,87.19) 5.94,86.77 PR19.2 6.7,86.77 6.7,87.44 6.32,87.82 v3(5.94,87.82) ; Y3.2 v3(121.09,94.04) ; 200.62,106.54 201.18,105.98 RC14.2 CC156.2 ; JPB1.7 275.19,89.58 v3(275.56,89.95) ; CH32.2 CH33.2 74.7,85.25 v3(74.29,85.66) ; JODD1.7 v3(25.86,34.01) ; v3(104.8,44.39) 104.88,44.31 C513.2 ; v3(226.6,90.02) 226.93,89.69 C329.2 228.13,89.69 v3(228.84,88.98) ; v3(87.45,159.55) 88.07,160.17 JLVDS1.43 ; CH68.2 CH70.2 85.94,70.33 v2(84.89,71.39) ; v2(73.75,68.92) 73.57,69.1 CH59.2 ; v3(39.27,76.75) 39.57,77.05 PC8.2 ; QC5.3 86.24,49.45 85.92,49.13 v3(85.92,47.61) ; v3(16.23,157.8) 16.23,158.31 16.99,159.07 C676.2 17.45,158.26 v3(16.99,157.8) ; v3(288.87,141.69) 288.7,141.51 C313.2 ; C1340.2 v3(24.15,166.48) ; v3(22.88,146.16) 23.33,145.72 Q326.3 ; QC1.3 207.03,108.14 v3(206.49,108.14) ; PC21.2 v3(12.56,137.47) ; v2(162.83,79.78) 162.56,80.06 162.56,80.89 162.15,81.29 CD2.2 ; v3(183.92,16.54) 183.16,17.3 PR1026.1 ; v3(176.58,36.87) 175.74,37.71 C391.2 ; v3(105.43,167.55) 103.05,167.55 U42.9 ; JXDP1.8 v3(209.79,124.94) ; v3(23.06,162.04) 23.06,161.82 22.91,161.66 22.91,161.66 22.63,161.38 R67.1 ; v3(283.5,89.92) 282.79,89.2 JPB1.8 ; v3(153.34,157.47) R1993.1 ; v3(150.72,42.99) 151.99,42.99 152.25,43.24 CD53.2 ; C539.2 107.44,169.76 v3(107.44,170.42) ; v3(82.98,84) 82.98,82.52 CH28.2 ; PC926.2 190.49,147.08 v3(189.94,147.08) ; CH31.2 77.06,75.31 77.06,73.41 CH22.2 76.81,73.65 v2(76.34,73.65) ; CH5.1 64.99,58.06 RH53.1 64.96,58.98 64.22,58.98 63.96,58.71 v3(63.55,58.71) ; CH73.2 78.15,64.37 78.54,64.37 v2(78.61,64.3) 78.88,64.03 79.1,64.03 CH27.2 ; C1336.2 v3(31.27,166.48) ; v3(34.62,166.48) 34.62,166 C1333.2 ; CMOS1.1 68.55,57.06 v2(68.17,57.44) 67.89,57.16 67.26,57.16 66.9,56.81 CH7.1 ; C1167.2 67.08,160.47 v4(67.77,161.15) v3(68.35,161.74) ; C92.2 112.5,131.79 112.8,132.09 113.47,132.09 v3(113.49,132.08) ; v3(159.33,82.72) 159.33,82.74 159.1,82.51 CD13.2 ; C619.2 v3(16.16,155.64) ; C477.1 105.82,39.69 v3(106.42,39.08) 106.02,38.67 C476.1 ; v2(80.06,75.58) 80.39,75.91 80.39,76.49 81.24,77.34 CH41.2 ; v3(85.11,36.77) 85.11,36.72 85.32,36.51 C415.2 ; v3(164.06,42.99) 163.55,42.99 162.79,43.75 CD51.2 ; JMXM1.312 115.14,140.29 v3(117.19,138.24) 117.19,137.72 117.07,137.59 C95.2 ; RH76.2 60.78,75.88 v3(60.7,75.96) ; v3(197.75,60.11) 197.75,59.63 194.97,56.85 JDIMM1.206 ; v3(202.36,65.55) 202.36,64.17 202.04,63.85 JSATA1.19 ; CD10.2 164.57,78.98 v2(163.3,80.25) ; R514.2 32.51,33.82 v3(32,34.33) ; C362.2 v3(106.22,174.56) ; CD21.2 CD22.2 127.48,76.52 v3(127.1,76.9) ; JSATA1.23 202.08,33.25 202.08,35.4 201.57,35.91 JSATA1.1 ; v3(148.56,169.53) 148.79,169.3 PC542.1 ; v3(45.74,79.97) 46.31,79.4 Q70.3 ; CH79.2 88.04,54.7 87.4,54.06 v3(87.4,54.09) ; v3(65.64,82.02) 65.85,81.81 65.85,81.32 RH218.2 ; CD16.2 CD15.2 v2(147.42,78.83) ; C770.2 101.19,79.01 101.67,79.49 v3(101.8,79.49) 101.93,79.49 102.34,79.08 C547.2 ; RH118.1 88.87,64.53 v2(89.48,64.53) ; v2(75.36,70.22) 75.42,70.16 CH24.2 76.17,70.09 CH50.2 ; C364.2 226.06,89.1 v3(225.66,89.5) ; v3(202.97,125.9) 203.96,125.9 v4(204.32,125.54) 205.26,124.6 CC66.2 CC65.2 ; v3(19.73,109.91) 19.73,110.6 19.87,110.74 PC1.2 ; v2(162.09,78.79) 162.09,78.31 CD3.2 ; v3(10.9,147.97) 10.62,148.25 R49.1 ; C668.2 v3(20.75,168.29) ; v3(94.61,166.01) 94.99,166.4 U28.2 ; JCAM1.14 v3(3.78,120.44) ; v3(68.55,53.43) 68.55,54.12 CH6.1 ; v3(281.13,88.08) 281.49,88.44 JPB1.6 ; C675.2 17.35,161 v3(16.99,161.35) ; C772.2 45.82,77.2 v3(46.1,77.48) ; CH72.2 80.96,66.29 81.41,66.29 81.68,66.02 81.68,65.99 81.72,65.95 81.74,65.95 81.74,65.98 v2(81.76,65.98) ; R2186.1 12.85,146.22 v3(12.39,145.76) ; C1335.2 v3(33.96,166.48) ; v3(206.89,112.17) 206.5,112.56 CC138.2 ; PC1.2 19.26,111.44 19.02,111.2 v3(19.02,109.91) ; PC1.2 20.25,111.44 20.56,111.14 20.56,110.06 v3(20.41,109.91) ; R1991.1 149.91,157.42 v3(149.27,157.42) ; R1971.1 R1970.1 45.29,133.41 v3(44.58,132.7) ; JEDP1.44 129.64,160.64 v3(130.33,161.33) ; PR514.1 v3(162.23,169.86) ; JSATA1.17 198.72,61.31 198.55,61.14 ; CD1.2 CD6.2 197.88,72.19 v3(198.04,72.35) ; v3(206.81,118.58) 206.95,118.44 JXDP1.21 ; v3(31.42,111.24) 31.32,111.14 30.44,111.14 C301.2 ; R758.2 v3(121,138.24) ; RC76.2 v3(202.87,124.19) RC77.2 ; v2(146.47,81.15) 146.53,81.09 RD46.2 ; PC302.2 35.58,58.57 v3(36.1,58.57) ; RC70.2 v3(197.2,148.22) ; v3(34.11,87.64) 33.96,87.49 C778.2 ; CD47.2 160.63,43.5 161.14,42.99 v3(161.52,42.99) ; JODD1.13 v3(25.84,22.8) 25.84,23.37 25.41,23.8 JODD1.12 ; RH150.2 RH151.2 ; v3(116.47,135.83) 115.92,135.28 R135.2 ; C483.2 43.71,162.36 C481.2 42.39,162.12 v4(41.38,161.1) v3(39.98,161.1) ; C94.2 121.87,138.09 v3(121.74,138.09) ; JEDP1.43 v3(120.74,161.2) ; JXDP1.27 v3(206.37,129.44) ; v3(29.03,34.66) 28.85,34.48 C544.2 ; v3(68.35,35.07) 67.79,34.51 67.79,32.2 ; R127.1 142.39,152.51 v3(142.19,152.31) ; JDIMM3.205 124.79,43.27 126.72,45.2 CD62.2 ; CD92.2 209.98,90.89 RD30.2 v3(209.98,92.47) ; R301.2 v3(110.67,175.25) ; v3(125.58,146.75) 125.83,147 C106.2 ; CD52.2 158.09,43.88 158.98,42.99 v3(159.49,42.99) ; JSATA1.4 202.21,39.72 203.15,40.65 v3(203.15,42.33) 203.15,42.61 202.23,43.53 JSATA1.7 ; CH16.2 88.95,61.56 CH20.2 ; 198.55,61.14 198.55,62 198.07,62.48 CD49.2 CD45.2 ; 198.55,61.14 v3(198.55,61.13) ; C725.2 v3(23.34,78.3) 23.6,78.55 23.6,80.48 C724.2 ; C7.2 44.37,133.62 v3(44.42,133.57) ; PC925.2 187.74,146.9 v3(187.02,146.9) ; C538.1 103.86,171.97 v3(103.99,172.1) ; CD62.2 CD61.2 ; CD62.2 128.18,44.73 v3(128.01,44.56) ; PC15.2 v3(4.8,87.19) ; v3(287.25,138.49) 287.82,138.49 C482.2 288.02,139.26 v3(287.25,139.26) ; JSATA2.17 v3(89.38,34.02) ; R2187.1 v3(16.36,144.59) ; RH18.2 69.87,49.09 v3(69.92,49.04) ; C305.2 122.86,150.74 121.79,151.8 v3(121.79,152.08) ; v3(209.95,146.8) CC140.2 RC11.2 ; v3(205.69,51.12) 203.12,53.69 JSATA1.11 ; PD3.1 v3(199.68,8.32) ; JSATA2.7 71.6,30.44 v2(72.08,29.96) ; v3(80.47,158.94) 80.09,159.32 JLVDS1.42 ; v3(3.66,133.52) 4.27,132.91 PU2.4 ; R557.2 120.75,88.71 v3(120.88,88.58) ; R561.2 v3(105.15,92.27) ; C474.2 v3(104.44,104.53) ; JXDP1.29 v3(209.73,114.94) ; CH74.2 81.38,63.64 v2(81.76,64.02) ; v3(75.77,34.51) 76.63,34.51 C408.2 C407.2 ; JPB1.5 v3(280.49,88.1) ; v3(22.05,155.69) 22.05,156.35 22.12,156.43 R73.1 ; PC525.1 150.5,174.94 v3(150.04,175.4) ; C18.2 89.46,169.36 v3(89.38,169.43) ; C400.2 v3(109.7,165.77) ; CH34.2 74.52,68.26 v2(73.75,68.26) ; JBT1.13 v3(302.59,108.96) ; JSATA2.1 v3(63.98,30.37) ; CD54.2 v3(164.06,43.75) ; v3(20.17,115.63) 19.75,115.63 PC30.2 19.75,116.4 v3(20.17,116.4) ; CH29.2 76.29,64.77 76.76,64.3 v2(76.99,64.3) 76.99,64.29 CH48.2 ; C759.2 279.25,94.04 v3(279.88,93.41) 279.25,92.77 PWRSW1.2 ; C756.2 C758.2 126.31,97.65 v3(125.77,97.1) ; v3(97.56,161.53) 97.89,161.2 JLVDS1.44 ; v3(205.64,115.25) 205.95,114.94 JXDP1.30 ; R57.1 21.82,159.45 v3(21,160.26) ; CH12.2 55.3,78.07 v3(55.63,77.74) ; R74.1 C405.2 24.79,161.25 v3(24.26,161.25) ; v3(20.17,117.16) 19.79,117.54 PC31.2 ; R336.1 111.25,150.05 v3(110.77,149.57) ; JUSH1.19 115.42,27.82 v3(116.05,27.19) ; C721.2 v3(10.69,67.04) ; v3(172.31,39.64) 171.99,39.95 C392.2 ; C540.2 93.42,166.62 R1140.2 93.42,164.73 v3(92.89,164.2) ; JKB1.19 v3(122.5,102.1) JKB1.20 ; v3(147.81,174.86) 148.51,174.15 PC526.1 ; v3(55.32,71.11) 55.63,70.8 QH3.3 ; C661.2 v3(2.16,152.25) ; R935.2 v3(26.54,129.53) ; v3(201.19,10.15) 201.33,10.01 201.33,9.34 ; v3(156.06,42.99) 155.55,42.99 155.17,43.37 CD48.2 ; v3(86.08,168.26) 86.38,167.96 C19.2 ; CH23.2 73.84,70.14 v2(73.75,70.23) ; JXDP1.18 v3(209.79,119.94) ; R562.2 115.87,96.15 v3(115.42,95.7) ; v3(204.23,171.77) 203.82,172.18 PC500.2 ; CD46.2 v3(156.95,43.75) ; JCAM1.21 v3(12.8,119.09) ; RC58.2 v3(203.12,134.53) ; 144.58,85.56 RC110.2 ; v2(84.94,65.95) 85.04,65.95 85.6,66.51 CH47.2 86.69,66.51 RH97.1 ; CD50.2 v3(161.52,43.75) ; JDIMM1.205 121.03,56.06 v3(123.23,56.06) ; R493.1 C437.2 33.58,161 v3(33.58,161.81) ; v3(86.54,36.74) 86.33,36.54 C409.2 ; PC935.2 179.32,146.74 v3(179.32,145.38) ; v3(8.61,74.11) 9.08,74.11 PC14.2 9.21,74.74 v3(8.61,74.74) ; CH75.2 79.35,59.5 v2(78.89,59.96) ; U30.2 292.01,135.21 v3(292.23,134.99) ; v3(27.35,58.66) 26.89,59.12 PR22.2 26.26,59.27 26.01,59.01 PQ8.6 ; JUSH1.18 116.74,28.32 116.46,28.03 v3(116.46,27.93) ; JUSH1.24 v3(116.47,26.32) ; v3(102.59,162.52) 103.59,162.52 104.42,163.35 R717.2 ; JXDP1.28 v3(209.69,129.44) ; PQ7.3 41.69,87 v3(42.11,86.58) 42.21,86.58 42.75,87.11 PC16.2 ; Q87.3 v3(17.44,131.19) ; R1128.2 v3(42.7,164.22) ; C473.2 v3(117.75,104.53) ; PQ3.3 v3(12.18,95.11) ; RH187.2 76.84,60.93 76.6,60.69 v2(76.33,60.69) ; v3(108.61,124.12) 109.04,124.12 109.32,124.4 R51.2 ; CD55.2 v3(159.49,43.75) ; PR1001.2 v3(131.62,115.72) 131.29,115.39 PR1003.2 ; C417.1 C435.1 v3(72.62,34.48) ; v3(157.33,175.15) 157.07,175.4 PC510.2 156.65,175.37 PC509.1 ; v3(62.79,47.08) 62.63,47.23 CH11.2 ; Q81.4 v3(31.95,24.76) ; C776.2 26.45,128.27 v3(26.44,128.26) ; C436.2 v3(43.74,127.34) ; R558.2 120.85,90.74 v3(120.9,90.69) ; RD49.2 166.98,43.19 v3(166.42,43.75) RC111.2 ; v2(150.35,82.74) 150.34,82.74 CD11.2 ; PD2.1 v3(197.93,9.02) ; v3(171.14,26.05) 171.92,26.82 PQ1010.3 ; R801.1 289.47,134.06 v3(289.01,134.52) ; CH46.2 71.22,67.73 v2(69.05,67.73) ; v3(89.58,52.82) 89.64,52.77 RH132.2 ; CH69.2 79.4,68.39 78.87,68.92 v2(78.61,68.92) 79.19,69.5 CH42.2 ; v3(118.17,96.05) 118.08,95.97 C471.2 ; v2(74.34,62.5) 74.45,62.6 CH54.2 ; JODD1.1 v3(25.88,41.63) ; C1337.2 v3(30.4,166.46) ; RC130.2 v4(200.89,150.05) v3(199.74,151.19) ; PC212.2 138.78,19.69 v3(138.78,20.38) ; CD64.2 v3(146.53,43.75) ; v2(154.37,82.01) 153.54,82.01 CD12.2 ; CH26.2 87.59,76.58 v2(86.59,77.58) ; D73.1 v3(14.3,166.97) ; JBT1.14 291.71,108.96 v3(292.25,108.42) ; C15.2 90.79,165.52 91.12,165.19 v3(91.39,165.19) ; JXDP1.2 v3(209.71,127.94) ; v3(69.11,53.12) 69.19,53.2 69.19,53.45 69.59,53.86 ME1.1 ; JXDP1.24 v3(209.69,116.94) ; JBT1.1 v3(302.56,107.61) ; 201.83,159.75 201.76,159.75 ; C478.2 v3(103.48,95.95) ; v3(105.95,36.32) C475.2 ; R519.1 v3(118.34,138.24) ; R66.1 v3(37.59,149.92) ; JSATA2.13 v3(84.3,34.05) ; C244.2 v3(118.85,169.86) ; C472.2 105.69,100.06 v3(105.79,100.17) ; JSATA2.19 v3(91.92,33.54) ; JCAM1.5 11.78,122.76 12.95,123.94 v3(12.95,124.02) ; v3(80.54,29.93) 80.8,29.93 81.76,30.9 JSATA2.11 ; v3(119.2,138.1) 119.73,137.57 C96.2 ; C310.2 v3(8,114.62) ; JUSH1.23 114.91,25.52 v3(115.09,25.34) ; v2(150.34,79.32) 150.72,78.94 CD7.2 ; v3(121.44,30.26) 120.72,30.26 C54.2 ; PR18.2 v3(10.26,73.09) ; CD63.2 v3(145.52,43.75) ; v3(90.65,149.04) C1145.2 C1146.2 ; CD56.2 v3(153.9,43.75) ; CD57.2 v3(150.72,43.75) ; PQ323.3 2.88,138.43 1.78,139.54 v3(1.4,139.54) ; C410.2 v3(22,153.18) ; Y3.4 v3(119.39,91.86) ; C108.2 125.7,144.97 v3(125.58,145.1) 125.58,145.48 125.96,145.86 C107.2 ; JCAM1.12 v3(4.46,119.7) ; PR26.2 v3(1.42,134.56) ; C86.2 v3(37.59,149.04)
  GND1 w0.203: 22.84,20 JODD1.15 ; JODD1.15 26.39,22.1 ; JODD1.15 24.61,20 ; JODD1.15 26.39,21.05 ; JODD1.15 22.84,21.05 ; JODD1.15 26.39,20 ; JODD1.15 22.84,22.1 ; JODD1.15 24.61,22.1 ; 300.94,152.8 JDP1.24 ; JDP1.24 300.94,153.57 ; JDP1.24 303.5,153.57 ; JDP1.24 302.22,152.02 ; JDP1.24 302.22,153.57 ; JDP1.24 303.5,152.8 ; JDP1.24 300.94,152.02 ; JDP1.24 303.5,152.02 ; H20.1 272.31,88.55 ; H20.1 272.82,87.13 ; H20.1 269.47,88.55 ; H20.1 272.31,85.71 ; H20.1 268.96,87.13 ; H20.1 270.89,89.06 ; H20.1 270.89,85.2 ; H20.1 269.47,85.71 ; 122.99,125.65 JDOCK1.156 ; JDOCK1.156 125.05,126.63 ; JDOCK1.156 120.93,127.6 ; JDOCK1.156 125.05,125.65 ; JDOCK1.156 122.99,127.6 ; JDOCK1.156 125.05,127.6 ; JDOCK1.156 120.93,125.65 ; JDOCK1.156 120.93,126.63 ; JCRT1.6 80.03,174.65 ; JCRT1.6 79.49,174.5 ; JCRT1.6 79.34,173.96 ; JCRT1.6 79.49,173.42 ; JCRT1.6 80.56,174.5 ; JCRT1.6 80.71,173.96 ; JCRT1.6 80.03,173.27 ; JDP1.21 296.7,137.32 ; JDP1.21 296.7,136.55 ; JDP1.21 293.86,136.55 ; JDP1.21 293.86,135.77 ; JDP1.21 293.86,137.32 ; JDP1.21 296.7,135.77 ; JDP1.21 295.28,137.32 ; JDP1.21 295.28,135.77 ; JUSB2.10 297.14,89.47 ; JUSB2.10 295.36,91.23 ; JUSB2.10 297.14,91.23 ; JUSB2.10 293.58,89.47 ; JUSB2.10 293.58,90.35 ; JUSB2.10 297.14,90.35 ; JUSB2.10 293.58,91.23 ; JUSB2.10 295.36,89.47 ; 210.8,97.04 H15.1 ; H15.1 212.64,97.73 ; H15.1 208.96,101.41 ; H15.1 208.27,99.57 ; H15.1 212.64,101.41 ; H15.1 210.8,102.1 ; H15.1 208.96,97.73 ; H15.1 213.33,99.57 ; 291.05,159.2 H22.1 ; H22.1 295.53,161.13 ; H22.1 293.29,157.27 ; H22.1 295.53,157.27 ; H22.1 295.53,159.2 ; H22.1 293.29,161.13 ; H22.1 291.05,161.13 ; H22.1 291.05,157.27 ; 218.86,79.43 H17.1 ; H17.1 218.86,76.17 ; H17.1 220.49,75.56 ; H17.1 222.12,79.43 ; H17.1 218.25,77.8 ; H17.1 222.73,77.8 ; H17.1 220.49,80.04 ; H17.1 222.12,76.17 ; H19.1 222.73,16.1 ; H19.1 222.12,14.47 ; H19.1 222.12,17.73 ; H19.1 218.86,14.47 ; H19.1 218.86,17.73 ; H19.1 218.25,16.1 ; H19.1 220.49,13.86 ; H19.1 220.49,18.34 ; 89.18,173.27 JCRT1.10 ; JCRT1.10 88.5,173.96 ; JCRT1.10 89.18,174.65 ; JCRT1.10 89.87,173.96 ; JCRT1.10 89.72,174.5 ; JCRT1.10 88.65,174.5 ; 90.17,174.5 JCRT1.5 ; JCRT1.5 91.4,173.96 ; JCRT1.5 91.25,174.5 ; JCRT1.5 91.25,173.42 ; JCRT1.5 90.02,173.96 ; JCRT1.5 90.71,173.27 ; JCRT1.5 90.71,174.65 ; JSATA2.23 62.12,32.39 ; JSATA2.23 60.17,29.04 ; JSATA2.23 62.12,30.71 ; JSATA2.23 61.15,32.39 ; JSATA2.23 60.17,32.39 ; JSATA2.23 61.15,29.04 ; JSATA2.23 62.12,29.04 ; JSATA2.23 60.17,30.71 ; JSATA1.24 201.91,71.47 ; JSATA1.24 200.23,70.49 ; JSATA1.24 201.91,69.52 ; JSATA1.24 203.58,71.47 ; JSATA1.24 200.23,71.47 ; JSATA1.24 203.58,69.52 ; JSATA1.24 200.23,69.52 ; JSATA1.24 203.58,70.49 ; 140.27,147.42 H6.1 ; H6.1 139.76,146 ; H6.1 141.69,147.93 ; H6.1 140.27,144.58 ; H6.1 143.62,146 ; H6.1 141.69,144.07 ; H6.1 143.11,147.42 ; H6.1 143.11,144.58 ; JCRT1.17 75.08,171.19 ; JCRT1.17 74.02,171.19 ; JCRT1.17 75.08,174.41 JCRT1.16 ; JCRT1.17 72.97,174.41 ; JCRT1.17 75.08,172.8 ; JCRT1.17 72.97,171.19 ; JCRT1.17 74.02,174.41 ; 68.07,166.28 H5.1 ; H5.1 69.49,169.63 ; H5.1 70.91,166.28 ; H5.1 70.91,169.12 ; H5.1 71.42,167.7 ; H5.1 68.07,169.12 ; H5.1 67.56,167.7 ; H5.1 69.49,165.77 ; JUSB2.11 297.14,104.03 ; JUSB2.11 297.14,102.27 ; JUSB2.11 295.36,104.03 ; JUSB2.11 295.36,102.27 ; JUSB2.11 293.58,103.15 ; JUSB2.11 297.14,103.15 ; JUSB2.11 293.58,102.27 ; JUSB2.11 293.58,104.03 ; PBATT1.11 209.44,0.74 ; PBATT1.11 209.44,4.56 ; PBATT1.11 208.46,0.74 ; PBATT1.11 207.49,2.65 ; PBATT1.11 207.49,0.74 ; PBATT1.11 207.49,4.56 ; PBATT1.11 209.44,2.65 ; PBATT1.11 208.46,4.56 ; 19.33,177.2 JESA1.13 ; JESA1.13 20.19,178.71 ; JESA1.13 19.33,175.69 ; JESA1.13 20.19,175.69 ; JESA1.13 21.05,175.69 ; JESA1.13 21.05,177.2 ; JESA1.13 19.33,178.71 ; JESA1.13 21.05,178.71 ; 135.81,158.68 H28.1 ; H28.1 136.59,156.87 ; H28.1 137.62,157.9 ; H28.1 136.59,158.93 ; H28.1 137.37,157.12 ; H28.1 137.37,158.68 ; H28.1 135.81,157.12 ; H28.1 135.56,157.9 ; 205.34,1.67 PBATT1.9 ; PBATT1.9 206.32,2.65 ; PBATT1.9 205.34,3.63 ; PBATT1.9 206.08,3.39 ; PBATT1.9 204.6,1.91 ; PBATT1.9 204.6,3.39 ; PBATT1.9 206.08,1.91 ; 293.78,140.66 JDP1.19 ; JDP1.19 293.2,141.25 ; JDP1.19 293.32,141.71 ; JDP1.19 293.32,140.78 ; 105.44,119.75 JDOCK1.163 ; JDOCK1.163 107.54,118.77 ; JDOCK1.163 107.54,119.75 ; JDOCK1.163 107.54,117.8 ; JDOCK1.163 106.49,119.75 ; JDOCK1.163 106.49,117.8 ; JDOCK1.163 105.44,118.77 ; JDOCK1.163 105.44,117.8 ; JHDMI1.20 40.62,168.22 ; JHDMI1.20 40.62,170.05 ; JHDMI1.20 39.69,171.88 ; JHDMI1.20 38.76,171.88 ; JHDMI1.20 38.76,170.05 ; JHDMI1.20 39.69,168.22 ; JHDMI1.20 40.62,171.88 ; JHDMI1.20 38.76,168.22 ; JUSB2.12 300.41,91.23 ; JUSB2.12 301.72,90.35 ; JUSB2.12 301.72,89.47 ; JUSB2.12 300.41,89.47 ; JUSB2.12 299.1,89.47 ; JUSB2.12 299.1,90.35 ; JUSB2.12 301.72,91.23 ; JUSB2.12 299.1,91.23 ; JESA1.11 15.34,170.26 ; JESA1.11 15.49,169.72 ; JESA1.11 14.8,169.03 ; JESA1.11 14.26,169.18 ; JESA1.11 15.34,169.18 ; JDOCK1.155 106.49,127.6 ; JDOCK1.155 105.44,127.6 ; JDOCK1.155 105.44,125.65 ; JDOCK1.155 107.54,127.6 ; JDOCK1.155 106.49,125.65 ; JDOCK1.155 107.54,126.63 ; JDOCK1.155 105.44,126.63 ; JDOCK1.155 107.54,125.65 ; 72.31,158.68 H26.1 ; H26.1 72.31,157.12 ; H26.1 73.09,156.87 ; H26.1 74.12,157.9 ; H26.1 73.87,158.68 ; H26.1 73.09,158.93 ; H26.1 73.87,157.12 ; H26.1 72.06,157.9 ; H18.1 200.32,26.03 ; H18.1 196.46,26.03 ; H18.1 198.39,27.96 ; H18.1 198.39,24.1 ; H18.1 196.97,27.45 ; H18.1 199.81,24.61 ; H18.1 196.97,24.61 ; H18.1 199.81,27.45 ; H24.1 299.33,16.1 ; H24.1 297.09,13.86 ; H24.1 297.09,18.34 ; H24.1 294.85,16.1 ; H24.1 295.46,14.47 ; H24.1 295.46,17.73 ; H24.1 298.72,14.47 ; H24.1 298.72,17.73 ; 293.86,152.95 JDP1.22 ; JDP1.22 296.7,153.72 ; JDP1.22 295.28,153.72 ; JDP1.22 296.7,152.95 ; JDP1.22 296.7,152.17 ; JDP1.22 293.86,152.17 ; JDP1.22 295.28,152.17 ; JDP1.22 293.86,153.72 ; JDOCK1.154 95.54,127.6 ; JDOCK1.154 95.54,125.65 ; JDOCK1.154 93.44,127.6 ; JDOCK1.154 94.49,127.6 ; JDOCK1.154 93.44,126.63 ; JDOCK1.154 95.54,126.63 ; JDOCK1.154 93.44,125.65 ; JDOCK1.154 94.49,125.65 ; JCRT1.7 82.85,172.42 ; JCRT1.7 81.78,172.42 ; JCRT1.7 81.63,172.96 ; JCRT1.7 82.32,172.27 ; JCRT1.7 83,172.96 ; JCRT1.7 82.32,173.65 ; JDOCK1.153 80.05,126.63 ; JDOCK1.153 80.05,125.65 ; JDOCK1.153 77.99,127.6 ; JDOCK1.153 75.93,126.63 ; JDOCK1.153 80.05,127.6 ; JDOCK1.153 77.99,125.65 ; JDOCK1.153 75.93,127.6 ; JDOCK1.153 75.93,125.65 ; JCRT1.8 85.29,173.96 ; JCRT1.8 85.14,174.5 ; JCRT1.8 84.07,174.5 ; JCRT1.8 84.61,173.27 ; JCRT1.8 84.61,174.65 ; JCRT1.8 83.92,173.96 ; JDP1.2 295.24,149.28 ; JDP1.2 295.36,149.75 ; JDP1.2 294.78,150.33 ; JDP1.2 295.24,150.21 ; H1.1 3.49,164.13 ; H1.1 4.91,163.62 ; H1.1 5.42,162.2 ; H1.1 3.49,160.27 ; H1.1 2.07,163.62 ; H1.1 1.56,162.2 ; H1.1 2.07,160.78 ; H1.1 4.91,160.78 ; 292.63,99.61 JUSB2.4 ; JUSB2.4 293.9,99.61 ; JUSB2.4 293.26,99.42 ; JUSB2.4 294.09,100.25 ; JUSB2.4 293.9,100.88 ; JUSB2.4 293.26,101.08 ; 97.59,29.04 JSATA2.24 ; JSATA2.24 97.59,30.71 ; JSATA2.24 98.57,29.04 ; JSATA2.24 99.54,32.39 ; JSATA2.24 97.59,32.39 ; JSATA2.24 99.54,29.04 ; JSATA2.24 99.54,30.71 ; JSATA2.24 98.57,32.39 ; 30.49,14.27 H3.1 ; H3.1 29.07,17.62 ; H3.1 29.07,14.78 ; H3.1 31.91,14.78 ; H3.1 31.91,17.62 ; H3.1 30.49,18.13 ; H3.1 32.42,16.2 ; H3.1 28.56,16.2 ; H23.1 299.33,77.8 ; H23.1 294.85,77.8 ; H23.1 298.72,79.43 ; H23.1 295.46,76.17 ; H23.1 295.46,79.43 ; H23.1 297.09,80.04 ; H23.1 297.09,75.56 ; H23.1 298.72,76.17 ; H7.1 108.69,78.24 ; H7.1 106.99,77.6 ; H7.1 106.99,74.2 ; H7.1 108.69,73.56 ; H7.1 111.03,75.9 ; H7.1 110.39,77.6 ; H7.1 110.39,74.2 ; H7.1 106.35,75.9 ; 193.36,169.2 H11.1 ; H11.1 195.29,171.13 ; H11.1 193.87,167.78 ; H11.1 195.29,167.27 ; H11.1 196.71,167.78 ; H11.1 197.22,169.2 ; H11.1 196.71,170.62 ; H11.1 193.87,170.62 ; 103.81,157.9 H27.1 ; H27.1 104.84,158.93 ; H27.1 105.62,157.12 ; H27.1 105.62,158.68 ; H27.1 104.84,156.87 ; H27.1 105.87,157.9 ; H27.1 104.06,157.12 ; H27.1 104.06,158.68 ; 75.26,122.7 JDOCK1.145 ; JDOCK1.145 75.26,124.68 ; JDOCK1.145 77.37,120.72 ; JDOCK1.145 76.32,120.72 ; JDOCK1.145 77.37,122.7 ; JDOCK1.145 77.37,124.68 ; JDOCK1.145 76.32,124.68 ; JDOCK1.145 75.26,120.72 ; JDOCK1.160 119.29,121.9 ; JDOCK1.160 119.29,123.5 ; JDOCK1.160 117.69,121.9 ; JDOCK1.160 118.49,121.65 ; JDOCK1.160 117.69,123.5 ; JDOCK1.160 119.54,122.7 ; JDOCK1.160 118.49,123.75 ; 114.47,10.81 H9.1 ; H9.1 115.89,10.3 ; H9.1 113.96,12.23 ; H9.1 114.47,13.65 ; H9.1 117.82,12.23 ; H9.1 117.31,10.81 ; H9.1 117.31,13.65 ; H9.1 115.89,14.16 ; PBATT1.10 186.22,4.56 ; PBATT1.10 185.24,4.56 ; PBATT1.10 185.24,2.65 ; PBATT1.10 185.24,0.74 ; PBATT1.10 187.19,2.65 ; PBATT1.10 187.19,4.56 ; PBATT1.10 186.22,0.74 ; PBATT1.10 187.19,0.74 ; 77.99,117.8 JDOCK1.161 ; JDOCK1.161 80.05,118.77 ; JDOCK1.161 80.05,119.75 ; JDOCK1.161 75.93,117.8 ; JDOCK1.161 80.05,117.8 ; JDOCK1.161 75.93,118.77 ; JDOCK1.161 77.99,119.75 ; JDOCK1.161 75.93,119.75 ; H12.1 154.2,144.99 ; H12.1 149.14,144.99 ; H12.1 153.51,146.83 ; H12.1 153.51,143.15 ; H12.1 151.67,147.52 ; H12.1 151.67,142.46 ; H12.1 149.83,143.15 ; H12.1 149.83,146.83 ; 147.85,106.04 H14.1 ; H14.1 151.53,106.04 ; H14.1 151.53,102.36 ; H14.1 149.69,106.73 ; H14.1 147.16,104.2 ; H14.1 149.69,101.67 ; H14.1 152.22,104.2 ; H14.1 147.85,102.36 ; 24.26,177.53 JHDMI1.23 ; JHDMI1.23 25.19,174.49 ; JHDMI1.23 24.26,174.49 ; JHDMI1.23 26.12,176.01 ; JHDMI1.23 26.12,174.49 ; JHDMI1.23 24.26,176.01 ; JHDMI1.23 26.12,177.53 ; JHDMI1.23 25.19,177.53 ; JESA1.15 2.65,168.49 ; JESA1.15 0.93,168.49 ; JESA1.15 1.79,171.51 ; JESA1.15 1.79,168.49 ; JESA1.15 2.65,170 ; JESA1.15 0.93,171.51 ; JESA1.15 0.93,170 ; 97.96,171.19 JCRT1.19 ; JCRT1.19 100.07,174.41 JCRT1.18 ; JCRT1.19 99.01,171.19 ; JCRT1.19 100.07,172.8 ; JCRT1.19 97.96,174.41 ; JCRT1.19 99.01,174.41 ; JCRT1.19 100.07,171.19 ; JESA1.5 7.72,169.18 ; JESA1.5 7.18,169.03 ; JESA1.5 6.49,169.72 ; JESA1.5 6.64,169.18 ; JESA1.5 6.64,170.26 ; JESA1.14 1.79,178.71 ; JESA1.14 0.93,177.2 ; JESA1.14 2.65,175.69 ; JESA1.14 2.65,177.2 ; JESA1.14 2.65,178.71 ; JESA1.14 0.93,175.69 ; JESA1.14 1.79,175.69 ; 22.84,44.5 JODD1.14 ; JODD1.14 26.39,44.5 ; JODD1.14 26.39,42.4 ; JODD1.14 22.84,42.4 ; JODD1.14 26.39,43.45 ; JODD1.14 24.61,42.4 ; JODD1.14 24.61,44.5 ; JODD1.14 22.84,43.45 ; JHDMI1.8 31.44,170.22 ; JHDMI1.8 31.9,170.1 ; JHDMI1.8 30.98,170.1 ; JUSB1.12 301.72,112.56 ; JUSB1.12 299.1,112.56 ; JUSB1.12 300.41,112.56 ; JUSB1.12 301.72,114.32 ; JUSB1.12 300.41,114.32 ; JUSB1.12 301.72,113.44 ; JUSB1.12 299.1,114.32 ; JUSB1.12 299.1,113.44 ; JUSB2.13 301.72,102.27 ; JUSB2.13 299.1,104.03 ; JUSB2.13 300.41,104.03 ; JUSB2.13 299.1,102.27 ; JUSB2.13 299.1,103.15 ; JUSB2.13 301.72,103.15 ; JUSB2.13 300.41,102.27 ; JUSB2.13 301.72,104.03 ; 290.93,96.75 JUSB2.7 ; JUSB2.7 291.12,97.39 ; JUSB2.7 291.12,96.12 ; JUSB2.7 291.76,95.92 ; JUSB2.7 292.39,97.39 ; JUSB2.7 292.59,96.75 ; JUSB2.7 292.39,96.12 ; JUSB2.7 291.76,97.58 ; 293.32,145.71 JDP1.11 ; JDP1.11 293.2,145.25 ; JDP1.11 293.32,144.78 ; JESA1.12 21.05,170 ; JESA1.12 19.33,170 ; JESA1.12 20.19,168.49 ; JESA1.12 21.05,171.51 ; JESA1.12 19.33,168.49 ; JESA1.12 21.05,168.49 ; JESA1.12 20.19,171.51 ; 35.48,168.18 JHDMI1.17 ; JHDMI1.17 36.4,168.18 ; JHDMI1.17 35.94,168.06 ; JHDMI1.21 25.19,171.88 ; JHDMI1.21 24.26,168.22 ; JHDMI1.21 25.19,168.22 ; JHDMI1.21 24.26,170.05 ; JHDMI1.21 26.12,171.88 ; JHDMI1.21 24.26,171.88 ; JHDMI1.21 26.12,168.22 ; JHDMI1.21 26.12,170.05 ; 293.58,126.24 JUSB1.11 ; JUSB1.11 293.58,127.12 ; JUSB1.11 297.14,127.12 ; JUSB1.11 297.14,125.36 ; JUSB1.11 295.36,127.12 ; JUSB1.11 293.58,125.36 ; JUSB1.11 295.36,125.36 ; JUSB1.11 297.14,126.24 ; 299.1,126.24 JUSB1.13 ; JUSB1.13 300.41,127.12 ; JUSB1.13 301.72,127.12 ; JUSB1.13 299.1,125.36 ; JUSB1.13 301.72,126.24 ; JUSB1.13 300.41,125.36 ; JUSB1.13 301.72,125.36 ; JUSB1.13 299.1,127.12 ; 120.93,118.77 JDOCK1.164 ; JDOCK1.164 122.99,117.8 ; JDOCK1.164 122.99,119.75 ; JDOCK1.164 125.05,118.77 ; JDOCK1.164 125.05,117.8 ; JHDMI1.5 30.4,168.18 ; JHDMI1.5 29.48,168.18 ; JHDMI1.5 29.94,168.06 ; JCRT1.16 75.08,173.36 ; JCRT1.16 75.08,172.31 ; 302.22,135.92 JDP1.23 ; JDP1.23 303.5,137.47 ; JDP1.23 302.22,137.47 ; JDP1.23 300.94,135.92 ; JDP1.23 300.94,137.47 ; JDP1.23 303.5,135.92 ; JDP1.23 300.94,136.7 ; JDP1.23 303.5,136.7 ; H2.1 35.39,77.6 ; H2.1 31.99,74.2 ; H2.1 33.69,73.56 ; H2.1 31.35,75.9 ; H2.1 31.99,77.6 ; H2.1 36.03,75.9 ; H2.1 35.39,74.2 ; H2.1 33.69,78.24 ; JHDMI1.22 40.62,176.01 ; JHDMI1.22 38.76,176.01 ; JHDMI1.22 38.76,177.53 ; JHDMI1.22 40.62,177.53 ; JHDMI1.22 39.69,174.49 ; JHDMI1.22 39.69,177.53 ; JHDMI1.22 40.62,174.49 ; JHDMI1.22 38.76,174.49 ; JDOCK1.152 125.72,124.68 ; JDOCK1.152 124.66,120.72 ; JDOCK1.152 123.61,124.68 ; JDOCK1.152 125.72,122.7 ; JDOCK1.152 125.72,120.72 ; JDOCK1.152 123.61,120.72 ; JDOCK1.152 123.61,122.7 ; JDOCK1.152 124.66,124.68 ; 200.23,32.1 JSATA1.23 ; JSATA1.23 203.58,33.08 ; JSATA1.23 200.23,34.05 ; JSATA1.23 201.91,32.1 ; JSATA1.23 201.91,34.05 ; JSATA1.23 200.23,33.08 ; JSATA1.23 203.58,34.05 ; JSATA1.23 203.58,32.1 ; H8.1 118.91,78.62 ; H8.1 119.42,77.2 ; H8.1 115.56,77.2 ; H8.1 118.91,75.78 ; H8.1 116.07,75.78 ; H8.1 117.49,79.13 ; H8.1 116.07,78.62 ; H8.1 117.49,75.27 ; 10.45,169.18 JESA1.8 ; JESA1.8 10.99,169.03 ; JESA1.8 11.53,170.26 ; JESA1.8 10.45,170.26 ; JESA1.8 10.99,170.41 ; JESA1.8 11.53,169.18 ; 198.6,1.91 PBATT1.6 ; PBATT1.6 198.6,3.39 ; PBATT1.6 199.34,3.63 ; PBATT1.6 199.34,1.67 ; PBATT1.6 200.08,1.91 ; PBATT1.6 200.08,3.39 ; JCRT1.18 100.07,173.36 ; JCRT1.18 100.07,172.31 ; 293.26,122.51 JUSB1.4 ; JUSB1.4 293.9,123.98 ; JUSB1.4 293.26,124.17 ; JUSB1.4 292.63,122.71 ; JUSB1.4 293.9,122.71 ; JUSB1.4 294.09,123.34 ; 215.49,88.57 H16.1 ; H16.1 216.91,91.92 ; H16.1 217.42,90.5 ; H16.1 213.56,90.5 ; H16.1 214.07,91.92 ; H16.1 216.91,89.08 ; H16.1 215.49,92.43 ; H16.1 214.07,89.08 ; JDOCK1.158 95.43,123.64 ; JDOCK1.158 93.23,122.7 ; JDOCK1.158 95.43,121.76 ; JDOCK1.158 93.55,121.76 ; JDOCK1.158 95.75,122.7 ; JDOCK1.158 93.55,123.64 ; JDOCK1.158 94.49,123.96 ; JDOCK1.158 94.49,121.44 ; 288.47,8.45 H25.1 ; H25.1 291.82,7.03 ; H25.1 291.31,5.61 ; H25.1 288.47,5.61 ; H25.1 289.89,5.1 ; H25.1 287.96,7.03 ; H25.1 291.31,8.45 ; H25.1 289.89,8.96 ; 293.2,148.25 JDP1.5 ; JDP1.5 293.32,147.78 ; JDP1.5 293.32,148.71 ; 94.49,117.8 JDOCK1.162 ; JDOCK1.162 93.44,117.8 ; JDOCK1.162 94.49,119.75 ; JDOCK1.162 95.54,119.75 ; JDOCK1.162 95.54,118.77 ; JDOCK1.162 95.54,117.8 ; JDOCK1.162 93.44,118.77 ; JDOCK1.162 93.44,119.75 ; 106.49,121.44 JDOCK1.159 ; JDOCK1.159 105.55,121.76 ; JDOCK1.159 107.75,122.7 ; JDOCK1.159 105.55,123.64 ; JDOCK1.159 106.49,123.96 ; JDOCK1.159 105.23,122.7 ; JDOCK1.159 107.43,123.64 ; JDOCK1.159 107.43,121.76 ; H4.1 54.82,36.38 ; H4.1 48.39,36.38 ; H4.1 41.96,28.02 ; H4.1 41.96,32.2 ; H4.1 48.39,28.02 ; H4.1 41.96,36.38 ; H4.1 54.82,32.2 ; H4.1 54.82,28.02 ; 46.93,168.42 JLOM1.15 ; JLOM1.15 47.79,171.92 ; JLOM1.15 47.79,168.42 ; JLOM1.15 46.93,171.92 ; JLOM1.15 46.93,170.17 ; 203.34,1.67 PBATT1.8 ; PBATT1.8 204.08,1.91 ; PBATT1.8 204.08,3.39 ; PBATT1.8 202.6,1.91 ; PBATT1.8 202.6,3.39 ; PBATT1.8 203.34,3.63 ; 6.9,171.56 JESA1.4 ; JESA1.4 7.49,171.73 ; JESA1.4 8.25,170.97 ; JESA1.4 6.73,170.97 ; JESA1.4 8.08,171.56 ; JESA1.4 8.08,170.38 ; H13.1 208.41,144.04 ; H13.1 206.57,143.35 ; H13.1 210.25,139.67 ; H13.1 206.57,139.67 ; H13.1 208.41,138.98 ; H13.1 210.25,143.35 ; H13.1 210.94,141.51 ; H13.1 205.88,141.51 ; 295.07,168.28 H21.1 ; H21.1 294.56,169.7 ; H21.1 296.49,171.63 ; H21.1 295.07,171.12 ; H21.1 296.49,167.77 ; H21.1 297.91,171.12 ; H21.1 297.91,168.28 ; H21.1 298.42,169.7 ; 121.36,7.43 H10.1 ; H10.1 125.22,7.43 ; H10.1 121.87,6.01 ; H10.1 123.29,9.36 ; H10.1 124.71,6.01 ; H10.1 124.71,8.85 ; H10.1 121.87,8.85 ; H10.1 123.29,5.5 ; JLOM1.14 64.65,171.92 ; JLOM1.14 63.79,171.92 ; JLOM1.14 64.65,170.17 ; JUSB1.7 292.39,120.48 ; JUSB1.7 291.76,120.67 ; JUSB1.7 290.93,119.84 ; JUSB1.7 291.76,119.01 ; JUSB1.7 292.39,119.21 ; JUSB1.7 291.12,119.21 ; JUSB1.7 292.59,119.84 ; JUSB1.7 291.12,120.48 ; 27.86,169.64 JHDMI1.2 ; JHDMI1.2 28.9,170.1 ; JHDMI1.2 27.98,170.1 ; JHDMI1.2 28.44,170.22 ; JDP1.8 295.24,146.28 ; JDP1.8 295.24,147.21 ; JDP1.8 295.36,146.75 ; JDOCK1.157 83.29,123.5 ; JDOCK1.157 81.44,122.7 ; JDOCK1.157 81.69,121.9 ; JDOCK1.157 81.69,123.5 ; JDOCK1.157 82.49,121.65 ; JDOCK1.157 83.29,121.9 ; JDOCK1.157 82.49,123.75 ; JDP1.16 295.24,142.28 ; JDP1.16 295.36,142.75 ; JDP1.16 295.24,143.21 ; 293.58,113.44 JUSB1.10 ; JUSB1.10 295.36,114.32 ; JUSB1.10 297.14,114.32 ; JUSB1.10 293.58,114.32 ; JUSB1.10 297.14,113.44 ; JUSB1.10 295.36,112.56 ; JUSB1.10 293.58,112.56 ; JUSB1.10 297.14,112.56 ; JHDMI1.11 33.4,168.18 ; JHDMI1.11 32.48,168.18 ; JHDMI1.11 32.94,168.06
  IN1 w0.254: 159.83,117.67 160.7,116.8 166.48,116.8 167.36,117.69 166.48,117.69 166.35,117.82 160.79,117.82 160.6,118 160.6,118.57 v2(160.45,118.72) 160.15,118.72 159.83,118.41 159.83,117.67
  IN1 w0.508: 167.36,117.69 168.55,118.87 188.63,118.87 189.13,118.38 v2(190.22,118.38)
  VCC w0.203: H21.1 297.91,171.12 ; H21.1 297.91,168.28 ; H21.1 298.42,169.7 ; H21.1 296.49,167.77 ; H21.1 294.56,169.7 ; H21.1 295.07,168.28 ; H21.1 295.07,171.12 ; H21.1 296.49,171.63 ; 290.93,119.84 JUSB1.7 ; JUSB1.7 292.39,120.48 ; JUSB1.7 291.12,120.48 ; JUSB1.7 291.76,120.67 ; JUSB1.7 291.12,119.21 ; JUSB1.7 291.76,119.01 ; JUSB1.7 292.39,119.21 ; JUSB1.7 292.59,119.84 ; JCRT1.8 85.29,173.96 ; JCRT1.8 83.92,173.96 ; JCRT1.8 84.61,173.27 ; JCRT1.8 85.14,174.5 ; JCRT1.8 84.61,174.65 ; JCRT1.8 84.07,174.5 ; 293.58,127.12 JUSB1.11 ; JUSB1.11 295.36,125.36 ; JUSB1.11 293.58,126.24 ; JUSB1.11 297.14,125.36 ; JUSB1.11 293.58,125.36 ; JUSB1.11 295.36,127.12 ; JUSB1.11 297.14,126.24 ; JUSB1.11 297.14,127.12 ; 295.36,112.56 JUSB1.10 ; JUSB1.10 297.14,114.32 ; JUSB1.10 293.58,113.44 ; JUSB1.10 297.14,112.56 ; JUSB1.10 293.58,112.56 ; JUSB1.10 295.36,114.32 ; JUSB1.10 293.58,114.32 ; JUSB1.10 297.14,113.44 ; 47.79,168.42 JLOM1.15 ; JLOM1.15 46.93,171.92 ; JLOM1.15 47.79,171.92 ; JLOM1.15 46.93,168.42 ; JLOM1.15 46.93,170.17 ; 10.99,169.03 JESA1.8 ; JESA1.8 10.45,170.26 ; JESA1.8 10.99,170.41 ; JESA1.8 11.53,169.18 ; JESA1.8 10.45,169.18 ; JESA1.8 11.53,170.26 ; 302.22,152.02 JDP1.24 ; JDP1.24 300.94,153.57 ; JDP1.24 303.5,152.8 ; JDP1.24 303.5,153.57 ; JDP1.24 303.5,152.02 ; JDP1.24 300.94,152.8 ; JDP1.24 300.94,152.02 ; JDP1.24 302.22,153.57 ; JDP1.8 295.24,146.28 ; JDP1.8 295.24,147.21 ; JDP1.8 295.36,146.75 ; 29.48,168.18 JHDMI1.5 ; JHDMI1.5 29.94,168.06 ; JHDMI1.5 30.4,168.18 ; JDP1.2 295.24,150.21 ; JDP1.2 295.36,149.75 ; JDP1.2 294.78,150.33 ; JDP1.2 295.24,149.28 ; 2.07,163.62 H1.1 ; H1.1 5.42,162.2 ; H1.1 4.91,163.62 ; H1.1 2.07,160.78 ; H1.1 3.49,164.13 ; H1.1 3.49,160.27 ; H1.1 4.91,160.78 ; H1.1 1.56,162.2 ; JCRT1.10 89.18,174.65 ; JCRT1.10 89.72,174.5 ; JCRT1.10 89.18,173.27 ; JCRT1.10 89.87,173.96 ; JCRT1.10 88.5,173.96 ; JCRT1.10 88.65,174.5 ; H5.1 70.91,166.28 ; H5.1 69.49,165.77 ; H5.1 68.07,166.28 ; H5.1 67.56,167.7 ; H5.1 69.49,169.63 ; H5.1 70.91,169.12 ; H5.1 71.42,167.7 ; H5.1 68.07,169.12 ; 299.1,113.44 JUSB1.12 ; JUSB1.12 299.1,112.56 ; JUSB1.12 300.41,114.32 ; JUSB1.12 301.72,114.32 ; JUSB1.12 300.41,112.56 ; JUSB1.12 301.72,112.56 ; JUSB1.12 299.1,114.32 ; JUSB1.12 301.72,113.44 ; 38.76,176.01 JHDMI1.22 ; JHDMI1.22 38.76,174.49 ; JHDMI1.22 38.76,177.53 ; JHDMI1.22 40.62,174.49 ; JHDMI1.22 40.62,176.01 ; JHDMI1.22 40.62,177.53 ; JHDMI1.22 39.69,177.53 ; JHDMI1.22 39.69,174.49 ; 299.1,90.35 JUSB2.12 ; JUSB2.12 300.41,91.23 ; JUSB2.12 299.1,89.47 ; JUSB2.12 301.72,90.35 ; JUSB2.12 301.72,91.23 ; JUSB2.12 300.41,89.47 ; JUSB2.12 299.1,91.23 ; JUSB2.12 301.72,89.47 ; 293.78,140.66 JDP1.19 ; JDP1.19 293.32,141.71 ; JDP1.19 293.32,140.78 ; JDP1.19 293.2,141.25 ; JUSB1.13 301.72,125.36 ; JUSB1.13 301.72,127.12 ; JUSB1.13 301.72,126.24 ; JUSB1.13 299.1,126.24 ; JUSB1.13 299.1,125.36 ; JUSB1.13 300.41,127.12 ; JUSB1.13 299.1,127.12 ; JUSB1.13 300.41,125.36 ; 32.48,168.18 JHDMI1.11 ; JHDMI1.11 33.4,168.18 ; JHDMI1.11 32.94,168.06 ; JHDMI1.20 40.62,171.88 ; JHDMI1.20 38.76,168.22 ; JHDMI1.20 39.69,168.22 ; JHDMI1.20 39.69,171.88 ; JHDMI1.20 38.76,171.88 ; JHDMI1.20 40.62,168.22 ; JHDMI1.20 40.62,170.05 ; JHDMI1.20 38.76,170.05 ; JCRT1.6 80.03,174.65 ; JCRT1.6 79.49,173.42 ; JCRT1.6 80.03,173.27 ; JCRT1.6 79.49,174.5 ; JCRT1.6 79.34,173.96 ; JCRT1.6 80.71,173.96 ; JCRT1.6 80.56,174.5 ; H14.1 152.22,104.2 ; H14.1 151.53,102.36 ; H14.1 149.69,106.73 ; H14.1 147.85,102.36 ; H14.1 147.16,104.2 ; H14.1 151.53,106.04 ; H14.1 147.85,106.04 ; H14.1 149.69,101.67 ; 293.58,103.15 JUSB2.11 ; JUSB2.11 295.36,104.03 ; JUSB2.11 297.14,103.15 ; JUSB2.11 293.58,102.27 ; JUSB2.11 297.14,104.03 ; JUSB2.11 297.14,102.27 ; JUSB2.11 295.36,102.27 ; JUSB2.11 293.58,104.03 ; 6.64,170.26 JESA1.5 ; JESA1.5 7.72,169.18 ; JESA1.5 6.64,169.18 ; JESA1.5 6.49,169.72 ; JESA1.5 7.18,169.03 ; 74.02,171.19 JCRT1.17 ; JCRT1.17 75.08,174.41 JCRT1.16 ; JCRT1.17 75.08,172.8 ; JCRT1.17 74.02,174.41 ; JCRT1.17 72.97,171.19 ; JCRT1.17 72.97,174.41 ; JCRT1.17 75.08,171.19 ; JESA1.15 2.65,170 ; JESA1.15 1.79,168.49 ; JESA1.15 1.79,171.51 ; JESA1.15 2.65,168.49 ; JESA1.15 0.93,168.49 ; JESA1.15 0.93,171.51 ; JESA1.15 0.93,170 ; 27.98,170.1 JHDMI1.2 ; JHDMI1.2 27.86,169.64 ; JHDMI1.2 28.9,170.1 ; JHDMI1.2 28.44,170.22 ; JCRT1.16 75.08,173.36 ; JCRT1.16 75.08,172.31 ; 290.93,96.75 JUSB2.7 ; JUSB2.7 291.12,97.39 ; JUSB2.7 292.39,96.12 ; JUSB2.7 291.76,95.92 ; JUSB2.7 292.39,97.39 ; JUSB2.7 291.12,96.12 ; JUSB2.7 291.76,97.58 ; JUSB2.7 292.59,96.75 ; 293.86,137.32 JDP1.21 ; JDP1.21 296.7,136.55 ; JDP1.21 293.86,136.55 ; JDP1.21 296.7,135.77 ; JDP1.21 293.86,135.77 ; JDP1.21 295.28,137.32 ; JDP1.21 296.7,137.32 ; JDP1.21 295.28,135.77 ; JHDMI1.23 26.12,174.49 ; JHDMI1.23 25.19,174.49 ; JHDMI1.23 24.26,176.01 ; JHDMI1.23 24.26,174.49 ; JHDMI1.23 26.12,177.53 ; JHDMI1.23 25.19,177.53 ; JHDMI1.23 26.12,176.01 ; JHDMI1.23 24.26,177.53 ; 299.1,102.27 JUSB2.13 ; JUSB2.13 299.1,103.15 ; JUSB2.13 301.72,102.27 ; JUSB2.13 301.72,104.03 ; JUSB2.13 301.72,103.15 ; JUSB2.13 300.41,102.27 ; JUSB2.13 299.1,104.03 ; JUSB2.13 300.41,104.03 ; JESA1.12 21.05,171.51 ; JESA1.12 21.05,170 ; JESA1.12 20.19,171.51 ; JESA1.12 21.05,168.49 ; JESA1.12 19.33,170 ; JESA1.4 8.08,171.56 ; JESA1.4 6.73,170.97 ; JESA1.4 7.49,171.73 ; JESA1.4 8.25,170.97 ; JESA1.4 8.08,170.38 ; JESA1.4 6.9,171.56 ; JDP1.22 296.7,152.17 ; JDP1.22 296.7,152.95 ; JDP1.22 293.86,152.17 ; JDP1.22 293.86,152.95 ; JDP1.22 295.28,152.17 ; JDP1.22 296.7,153.72 ; JDP1.22 295.28,153.72 ; JDP1.22 293.86,153.72 ; JHDMI1.21 26.12,170.05 ; JHDMI1.21 24.26,170.05 ; JHDMI1.21 25.19,171.88 ; JHDMI1.21 25.19,168.22 ; JHDMI1.21 24.26,171.88 ; JHDMI1.21 26.12,168.22 ; JHDMI1.21 24.26,168.22 ; JHDMI1.21 26.12,171.88 ; JDP1.23 302.22,137.47 ; JDP1.23 302.22,135.92 ; JDP1.23 303.5,135.92 ; JDP1.23 303.5,137.47 ; JDP1.23 300.94,136.7 ; JDP1.23 300.94,137.47 ; JDP1.23 300.94,135.92 ; JDP1.23 303.5,136.7 ; JUSB2.4 293.9,99.61 ; JUSB2.4 294.09,100.25 ; JUSB2.4 293.26,99.42 ; JUSB2.4 292.63,99.61 ; JUSB2.4 293.26,101.08 ; JUSB2.4 293.9,100.88 ; 293.26,122.51 JUSB1.4 ; JUSB1.4 293.9,123.98 ; JUSB1.4 292.63,122.71 ; JUSB1.4 294.09,123.34 ; JUSB1.4 293.26,124.17 ; JUSB1.4 293.9,122.71 ; JUSB2.10 297.14,90.35 ; JUSB2.10 297.14,91.23 ; JUSB2.10 297.14,89.47 ; JUSB2.10 293.58,89.47 ; JUSB2.10 295.36,91.23 ; JUSB2.10 293.58,91.23 ; JUSB2.10 295.36,89.47 ; JUSB2.10 293.58,90.35 ; JCRT1.5 91.4,173.96 ; JCRT1.5 91.25,173.42 ; JCRT1.5 90.02,173.96 ; JCRT1.5 90.71,173.27 ; JCRT1.5 90.17,174.5 ; JCRT1.5 90.71,174.65 ; JCRT1.5 91.25,174.5 ; 14.8,169.03 JESA1.11 ; JESA1.11 14.26,169.18 ; JESA1.11 15.49,169.72 ; JESA1.11 15.34,169.18 ; JESA1.11 15.34,170.26 ; 35.48,168.18 JHDMI1.17 ; JHDMI1.17 35.94,168.06 ; JHDMI1.17 36.4,168.18 ; 293.32,148.71 JDP1.5 ; JDP1.5 293.32,147.78 ; JDP1.5 293.2,148.25 ; JCRT1.19 100.07,172.8 ; JCRT1.19 100.07,174.41 JCRT1.18 ; JCRT1.19 97.96,171.19 ; JCRT1.19 99.01,174.41 ; JCRT1.19 99.01,171.19 ; JCRT1.19 97.96,174.41 ; JCRT1.19 100.07,171.19 ; H22.1 293.29,161.13 ; H22.1 291.05,161.13 ; H22.1 293.29,157.27 ; H22.1 295.53,161.13 ; H22.1 295.53,157.27 ; H22.1 291.05,159.2 ; H22.1 295.53,159.2 ; H22.1 291.05,157.27 ; 82.32,172.27 JCRT1.7 ; JCRT1.7 82.32,173.65 ; JCRT1.7 83,172.96 ; JCRT1.7 81.63,172.96 ; JCRT1.7 82.85,172.42 ; JCRT1.7 81.78,172.42 ; 30.98,170.1 JHDMI1.8 ; JHDMI1.8 31.44,170.22 ; JHDMI1.8 31.9,170.1 ; JESA1.13 21.05,175.69 ; JESA1.13 19.33,177.2 ; JESA1.13 19.33,178.71 ; JESA1.13 21.05,177.2 ; JESA1.13 21.05,178.71 ; JESA1.13 20.19,178.71 ; JESA1.13 19.33,175.69 ; JESA1.13 20.19,175.69 ; JLOM1.14 64.65,170.17 ; JLOM1.14 64.65,171.92 ; JLOM1.14 63.79,171.92 ; JDP1.16 295.24,142.28 ; JDP1.16 295.24,143.21 ; JDP1.16 295.36,142.75 ; 0.93,175.69 JESA1.14 ; JESA1.14 2.65,177.2 ; JESA1.14 2.65,178.71 ; JESA1.14 2.65,175.69 ; JESA1.14 0.93,177.2 ; JESA1.14 1.79,175.69 ; JESA1.14 1.79,178.71 ; 293.2,145.25 JDP1.11 ; JDP1.11 293.32,145.71 ; JDP1.11 293.32,144.78 ; JCRT1.18 100.07,173.36 ; JCRT1.18 100.07,172.31
  GND2 w0.203: JUSB2.4 293.26,101.08 ; JUSB2.4 293.9,99.61 ; JUSB2.4 294.09,100.25 ; JUSB2.4 292.63,99.61 ; JUSB2.4 293.26,99.42 ; JUSB2.4 293.9,100.88 ; 60.17,30.71 JSATA2.23 ; JSATA2.23 62.12,30.71 ; JSATA2.23 62.12,32.39 ; JSATA2.23 62.12,29.04 ; JSATA2.23 61.15,29.04 ; JSATA2.23 60.17,32.39 ; JSATA2.23 60.17,29.04 ; JSATA2.23 61.15,32.39 ; JUSB1.13 301.72,125.36 ; JUSB1.13 300.41,125.36 ; JUSB1.13 299.1,126.24 ; JUSB1.13 299.1,125.36 ; JUSB1.13 301.72,126.24 ; JUSB1.13 299.1,127.12 ; JUSB1.13 300.41,127.12 ; JUSB1.13 301.72,127.12 ; JDP1.22 295.28,153.72 ; JDP1.22 293.86,152.95 ; JDP1.22 295.28,152.17 ; JDP1.22 293.86,152.17 ; JDP1.22 293.86,153.72 ; JDP1.22 296.7,152.17 ; JDP1.22 296.7,152.95 ; JDP1.22 296.7,153.72 ; JDOCK1.161 80.05,119.75 ; JDOCK1.161 77.99,117.8 ; JDOCK1.161 77.99,119.75 ; JDOCK1.161 75.93,119.75 ; JDOCK1.161 80.05,118.77 ; JDOCK1.161 75.93,117.8 ; JDOCK1.161 75.93,118.77 ; JDOCK1.161 80.05,117.8 ; H3.1 31.91,14.78 ; H3.1 28.56,16.2 ; H3.1 29.07,14.78 ; H3.1 32.42,16.2 ; H3.1 30.49,18.13 ; H3.1 30.49,14.27 ; H3.1 29.07,17.62 ; H3.1 31.91,17.62 ; JHDMI1.22 39.69,177.53 ; JHDMI1.22 38.76,177.53 ; JHDMI1.22 40.62,174.49 ; JHDMI1.22 39.69,174.49 ; JHDMI1.22 40.62,176.01 ; JHDMI1.22 40.62,177.53 ; JHDMI1.22 38.76,174.49 ; JHDMI1.22 38.76,176.01 ; 300.41,89.47 JUSB2.12 ; JUSB2.12 299.1,91.23 ; JUSB2.12 301.72,91.23 ; JUSB2.12 299.1,90.35 ; JUSB2.12 301.72,90.35 ; JUSB2.12 299.1,89.47 ; JUSB2.12 300.41,91.23 ; JUSB2.12 301.72,89.47 ; 41.96,28.02 H4.1 ; H4.1 54.82,28.02 ; H4.1 41.96,36.38 ; H4.1 48.39,28.02 ; H4.1 54.82,36.38 ; H4.1 41.96,32.2 ; H4.1 54.82,32.2 ; H4.1 48.39,36.38 ; 81.69,123.5 JDOCK1.157 ; JDOCK1.157 81.44,122.7 ; JDOCK1.157 82.49,123.75 ; JDOCK1.157 83.29,121.9 ; JDOCK1.157 83.29,123.5 ; JDOCK1.157 81.69,121.9 ; JDOCK1.157 82.49,121.65 ; 136.59,156.87 H28.1 ; H28.1 135.81,157.12 ; H28.1 135.81,158.68 ; H28.1 137.37,158.68 ; H28.1 135.56,157.9 ; H28.1 137.62,157.9 ; H28.1 137.37,157.12 ; H28.1 136.59,158.93 ; 68.07,169.12 H5.1 ; H5.1 69.49,165.77 ; H5.1 71.42,167.7 ; H5.1 68.07,166.28 ; H5.1 67.56,167.7 ; H5.1 69.49,169.63 ; H5.1 70.91,166.28 ; H5.1 70.91,169.12 ; 151.67,142.46 H12.1 ; H12.1 151.67,147.52 ; H12.1 154.2,144.99 ; H12.1 149.14,144.99 ; H12.1 149.83,146.83 ; H12.1 153.51,146.83 ; H12.1 153.51,143.15 ; H12.1 149.83,143.15 ; H22.1 293.29,161.13 ; H22.1 291.05,157.27 ; H22.1 291.05,159.2 ; H22.1 291.05,161.13 ; H22.1 295.53,161.13 ; H22.1 295.53,157.27 ; H22.1 293.29,157.27 ; H22.1 295.53,159.2 ; 300.94,136.7 JDP1.23 ; JDP1.23 303.5,136.7 ; JDP1.23 303.5,135.92 ; JDP1.23 300.94,137.47 ; JDP1.23 303.5,137.47 ; JDP1.23 302.22,137.47 ; JDP1.23 302.22,135.92 ; JDP1.23 300.94,135.92 ; 22.84,42.4 JODD1.14 ; JODD1.14 26.39,42.4 ; JODD1.14 26.39,43.45 ; JODD1.14 22.84,44.5 ; JODD1.14 26.39,44.5 ; JODD1.14 24.61,44.5 ; JODD1.14 24.61,42.4 ; JODD1.14 22.84,43.45 ; PBATT1.11 209.44,0.74 ; PBATT1.11 208.46,4.56 ; PBATT1.11 207.49,2.65 ; PBATT1.11 209.44,2.65 ; PBATT1.11 207.49,0.74 ; PBATT1.11 209.44,4.56 ; PBATT1.11 208.46,0.74 ; PBATT1.11 207.49,4.56 ; 300.94,152.8 JDP1.24 ; JDP1.24 300.94,153.57 ; JDP1.24 303.5,152.02 ; JDP1.24 300.94,152.02 ; JDP1.24 302.22,152.02 ; JDP1.24 303.5,152.8 ; JDP1.24 302.22,153.57 ; JDP1.24 303.5,153.57 ; JDP1.16 295.24,142.28 ; JDP1.16 295.24,143.21 ; JDP1.16 295.36,142.75 ; 83.92,173.96 JCRT1.8 ; JCRT1.8 84.61,173.27 ; JCRT1.8 84.61,174.65 ; JCRT1.8 84.07,174.5 ; JCRT1.8 85.14,174.5 ; JCRT1.8 85.29,173.96 ; 72.97,171.19 JCRT1.17 ; JCRT1.17 72.97,174.41 ; JCRT1.17 74.02,171.19 ; JCRT1.17 75.08,174.41 JCRT1.16 ; JCRT1.17 74.02,174.41 ; JCRT1.17 75.08,172.8 ; JCRT1.17 75.08,171.19 ; H1.1 4.91,163.62 ; H1.1 5.42,162.2 ; H1.1 2.07,163.62 ; H1.1 3.49,164.13 ; H1.1 4.91,160.78 ; H1.1 2.07,160.78 ; H1.1 1.56,162.2 ; H1.1 3.49,160.27 ; 6.49,169.72 JESA1.5 ; JESA1.5 7.72,169.18 ; JESA1.5 6.64,170.26 ; JESA1.5 6.64,169.18 ; JESA1.5 7.18,169.03 ; 0.93,177.2 JESA1.14 ; JESA1.14 0.93,175.69 ; JESA1.14 1.79,175.69 ; JESA1.14 2.65,175.69 ; JESA1.14 1.79,178.71 ; JESA1.14 2.65,177.2 ; JESA1.14 2.65,178.71 ; 117.69,121.9 JDOCK1.160 ; JDOCK1.160 119.29,123.5 ; JDOCK1.160 118.49,123.75 ; JDOCK1.160 117.69,123.5 ; JDOCK1.160 119.54,122.7 ; JDOCK1.160 118.49,121.65 ; JDOCK1.160 119.29,121.9 ; JDP1.8 295.24,146.28 ; JDP1.8 295.24,147.21 ; JDP1.8 295.36,146.75 ; 185.24,0.74 PBATT1.10 ; PBATT1.10 187.19,2.65 ; PBATT1.10 185.24,4.56 ; PBATT1.10 187.19,0.74 ; PBATT1.10 187.19,4.56 ; PBATT1.10 185.24,2.65 ; PBATT1.10 186.22,0.74 ; PBATT1.10 186.22,4.56 ; PBATT1.8 203.34,3.63 ; PBATT1.8 204.08,3.39 ; PBATT1.8 202.6,1.91 ; PBATT1.8 204.08,1.91 ; PBATT1.8 203.34,1.67 ; PBATT1.8 202.6,3.39 ; 105.44,117.8 JDOCK1.163 ; JDOCK1.163 105.44,119.75 ; JDOCK1.163 107.54,119.75 ; JDOCK1.163 106.49,117.8 ; JDOCK1.163 105.44,118.77 ; JDOCK1.163 107.54,118.77 ; JDOCK1.163 106.49,119.75 ; JDOCK1.163 107.54,117.8 ; 293.58,102.27 JUSB2.11 ; JUSB2.11 297.14,102.27 ; JUSB2.11 293.58,103.15 ; JUSB2.11 295.36,102.27 ; JUSB2.11 297.14,104.03 ; JUSB2.11 297.14,103.15 ; JUSB2.11 295.36,104.03 ; JUSB2.11 293.58,104.03 ; JODD1.15 24.61,22.1 ; JODD1.15 26.39,22.1 ; JODD1.15 26.39,21.05 ; JODD1.15 26.39,20 ; JODD1.15 22.84,21.05 ; JODD1.15 22.84,22.1 ; JODD1.15 22.84,20 ; JODD1.15 24.61,20 ; 38.76,168.22 JHDMI1.20 ; JHDMI1.20 40.62,171.88 ; JHDMI1.20 38.76,170.05 ; JHDMI1.20 38.76,171.88 ; JHDMI1.20 39.69,171.88 ; JHDMI1.20 40.62,170.05 ; JHDMI1.20 40.62,168.22 ; JHDMI1.20 39.69,168.22 ; JUSB1.10 297.14,112.56 ; JUSB1.10 297.14,114.32 ; JUSB1.10 297.14,113.44 ; JUSB1.10 293.58,113.44 ; JUSB1.10 295.36,114.32 ; JUSB1.10 293.58,114.32 ; JUSB1.10 293.58,112.56 ; JUSB1.10 295.36,112.56 ; H25.1 291.31,8.45 ; H25.1 289.89,8.96 ; H25.1 288.47,8.45 ; H25.1 289.89,5.1 ; H25.1 288.47,5.61 ; H25.1 291.31,5.61 ; H25.1 291.82,7.03 ; H25.1 287.96,7.03 ; 200.23,69.52 JSATA1.24 ; JSATA1.24 201.91,69.52 ; JSATA1.24 203.58,71.47 ; JSATA1.24 201.91,71.47 ; JSATA1.24 200.23,70.49 ; JSATA1.24 203.58,70.49 ; JSATA1.24 203.58,69.52 ; JSATA1.24 200.23,71.47 ; 299.1,102.27 JUSB2.13 ; JUSB2.13 300.41,104.03 ; JUSB2.13 301.72,103.15 ; JUSB2.13 299.1,103.15 ; JUSB2.13 301.72,104.03 ; JUSB2.13 299.1,104.03 ; JUSB2.13 300.41,102.27 ; JUSB2.13 301.72,102.27 ; 105.55,121.76 JDOCK1.159 ; JDOCK1.159 106.49,121.44 ; JDOCK1.159 105.55,123.64 ; JDOCK1.159 107.75,122.7 ; JDOCK1.159 105.23,122.7 ; JDOCK1.159 107.43,121.76 ; JDOCK1.159 107.43,123.64 ; JDOCK1.159 106.49,123.96 ; H19.1 222.12,14.47 ; H19.1 218.86,14.47 ; H19.1 220.49,18.34 ; H19.1 222.73,16.1 ; H19.1 218.25,16.1 ; H19.1 218.86,17.73 ; H19.1 222.12,17.73 ; H19.1 220.49,13.86 ; JDOCK1.153 77.99,127.6 ; JDOCK1.153 80.05,125.65 ; JDOCK1.153 75.93,127.6 ; JDOCK1.153 77.99,125.65 ; JDOCK1.153 75.93,125.65 ; JDOCK1.153 80.05,126.63 ; JDOCK1.153 80.05,127.6 ; JDOCK1.153 75.93,126.63 ; 292.63,122.71 JUSB1.4 ; JUSB1.4 294.09,123.34 ; JUSB1.4 293.26,122.51 ; JUSB1.4 293.9,122.71 ; JUSB1.4 293.9,123.98 ; JUSB1.4 293.26,124.17 ; 24.26,176.01 JHDMI1.23 ; JHDMI1.23 24.26,174.49 ; JHDMI1.23 25.19,177.53 ; JHDMI1.23 24.26,177.53 ; JHDMI1.23 26.12,174.49 ; JHDMI1.23 26.12,176.01 ; JHDMI1.23 25.19,174.49 ; JHDMI1.23 26.12,177.53 ; 123.61,120.72 JDOCK1.152 ; JDOCK1.152 124.66,124.68 ; JDOCK1.152 123.61,124.68 ; JDOCK1.152 124.66,120.72 ; JDOCK1.152 123.61,122.7 ; JDOCK1.152 125.72,120.72 ; JDOCK1.152 125.72,124.68 ; JDOCK1.152 125.72,122.7 ; 293.58,91.23 JUSB2.10 ; JUSB2.10 295.36,91.23 ; JUSB2.10 297.14,91.23 ; JUSB2.10 297.14,90.35 ; JUSB2.10 297.14,89.47 ; JUSB2.10 295.36,89.47 ; JUSB2.10 293.58,89.47 ; JUSB2.10 293.58,90.35 ; JDOCK1.155 106.49,127.6 ; JDOCK1.155 107.54,126.63 ; JDOCK1.155 105.44,125.65 ; JDOCK1.155 105.44,126.63 ; JDOCK1.155 106.49,125.65 ; JDOCK1.155 105.44,127.6 ; JDOCK1.155 107.54,125.65 ; JDOCK1.155 107.54,127.6 ; H17.1 220.49,80.04 ; H17.1 222.12,76.17 ; H17.1 222.12,79.43 ; H17.1 220.49,75.56 ; H17.1 218.25,77.8 ; H17.1 218.86,79.43 ; H17.1 222.73,77.8 ; H17.1 218.86,76.17 ; 268.96,87.13 H20.1 ; H20.1 272.82,87.13 ; H20.1 272.31,88.55 ; H20.1 270.89,89.06 ; H20.1 270.89,85.2 ; H20.1 272.31,85.71 ; H20.1 269.47,85.71 ; H20.1 269.47,88.55 ; 121.87,6.01 H10.1 ; H10.1 121.87,8.85 ; H10.1 123.29,5.5 ; H10.1 125.22,7.43 ; H10.1 123.29,9.36 ; H10.1 124.71,6.01 ; H10.1 124.71,8.85 ; H10.1 121.36,7.43 ; 27.86,169.64 JHDMI1.2 ; JHDMI1.2 28.9,170.1 ; JHDMI1.2 28.44,170.22 ; JHDMI1.2 27.98,170.1 ; H16.1 216.91,89.08 ; H16.1 214.07,91.92 ; H16.1 214.07,89.08 ; H16.1 216.91,91.92 ; H16.1 213.56,90.5 ; H16.1 215.49,92.43 ; H16.1 217.42,90.5 ; H16.1 215.49,88.57 ; JSATA1.23 203.58,34.05 ; JSATA1.23 203.58,33.08 ; JSATA1.23 200.23,34.05 ; JSATA1.23 200.23,33.08 ; JSATA1.23 200.23,32.1 ; JSATA1.23 201.91,34.05 ; JSATA1.23 201.91,32.1 ; JSATA1.23 203.58,32.1 ; H23.1 298.72,76.17 ; H23.1 295.46,76.17 ; H23.1 294.85,77.8 ; H23.1 295.46,79.43 ; H23.1 297.09,75.56 ; H23.1 299.33,77.8 ; H23.1 298.72,79.43 ; H23.1 297.09,80.04 ; 140.27,144.58 H6.1 ; H6.1 143.11,147.42 ; H6.1 143.62,146 ; H6.1 140.27,147.42 ; H6.1 139.76,146 ; H6.1 141.69,147.93 ; H6.1 143.11,144.58 ; H6.1 141.69,144.07 ; JESA1.15 2.65,168.49 ; JESA1.15 0.93,168.49 ; JESA1.15 1.79,168.49 ; JESA1.15 0.93,170 ; JESA1.15 0.93,171.51 ; JESA1.15 2.65,170 ; JESA1.15 1.79,171.51 ; JDOCK1.162 95.54,119.75 ; JDOCK1.162 93.44,117.8 ; JDOCK1.162 95.54,117.8 ; JDOCK1.162 95.54,118.77 ; JDOCK1.162 93.44,118.77 ; JDOCK1.162 93.44,119.75 ; JDOCK1.162 94.49,117.8 ; JDOCK1.162 94.49,119.75 ; 204.6,3.39 PBATT1.9 ; PBATT1.9 205.34,1.67 ; PBATT1.9 205.34,3.63 ; PBATT1.9 206.08,1.91 ; PBATT1.9 204.6,1.91 ; PBATT1.9 206.32,2.65 ; PBATT1.9 206.08,3.39 ; 116.07,75.78 H8.1 ; H8.1 117.49,79.13 ; H8.1 119.42,77.2 ; H8.1 118.91,75.78 ; H8.1 116.07,78.62 ; H8.1 118.91,78.62 ; H8.1 117.49,75.27 ; H8.1 115.56,77.2 ; JDOCK1.145 76.32,124.68 ; JDOCK1.145 75.26,122.7 ; JDOCK1.145 77.37,122.7 ; JDOCK1.145 77.37,120.72 ; JDOCK1.145 77.37,124.68 ; JDOCK1.145 76.32,120.72 ; JDOCK1.145 75.26,120.72 ; JDOCK1.145 75.26,124.68 ; 293.78,140.66 JDP1.19 ; JDP1.19 293.2,141.25 ; JDP1.19 293.32,141.71 ; JDP1.19 293.32,140.78 ; 147.16,104.2 H14.1 ; H14.1 147.85,102.36 ; H14.1 151.53,106.04 ; H14.1 149.69,106.73 ; H14.1 152.22,104.2 ; H14.1 147.85,106.04 ; H14.1 149.69,101.67 ; H14.1 151.53,102.36 ; 79.34,173.96 JCRT1.6 ; JCRT1.6 79.49,174.5 ; JCRT1.6 79.49,173.42 ; JCRT1.6 80.03,174.65 ; JCRT1.6 80.03,173.27 ; JCRT1.6 80.56,174.5 ; JCRT1.6 80.71,173.96 ; JESA1.8 11.53,169.18 ; JESA1.8 11.53,170.26 ; JESA1.8 10.45,169.18 ; JESA1.8 10.99,169.03 ; JESA1.8 10.99,170.41 ; JESA1.8 10.45,170.26 ; H21.1 297.91,171.12 ; H21.1 295.07,168.28 ; H21.1 296.49,167.77 ; H21.1 296.49,171.63 ; H21.1 297.91,168.28 ; H21.1 298.42,169.7 ; H21.1 294.56,169.7 ; H21.1 295.07,171.12 ; 205.88,141.51 H13.1 ; H13.1 210.94,141.51 ; H13.1 210.25,139.67 ; H13.1 206.57,143.35 ; H13.1 208.41,138.98 ; H13.1 206.57,139.67 ; H13.1 208.41,144.04 ; H13.1 210.25,143.35 ; 14.8,169.03 JESA1.11 ; JESA1.11 15.34,169.18 ; JESA1.11 14.26,169.18 ; JESA1.11 15.34,170.26 ; JESA1.11 15.49,169.72 ; JUSB2.7 292.39,97.39 ; JUSB2.7 292.39,96.12 ; JUSB2.7 292.59,96.75 ; JUSB2.7 291.76,97.58 ; JUSB2.7 291.76,95.92 ; JUSB2.7 291.12,97.39 ; JUSB2.7 291.12,96.12 ; JUSB2.7 290.93,96.75 ; 88.5,173.96 JCRT1.10 ; JCRT1.10 89.72,174.5 ; JCRT1.10 89.18,174.65 ; JCRT1.10 89.87,173.96 ; JCRT1.10 89.18,173.27 ; JCRT1.10 88.65,174.5 ; JCRT1.19 99.01,174.41 ; JCRT1.19 99.01,171.19 ; JCRT1.19 100.07,171.19 ; JCRT1.19 97.96,171.19 ; JCRT1.19 100.07,174.41 JCRT1.18 ; JCRT1.19 97.96,174.41 ; JCRT1.19 100.07,172.8 ; 295.28,135.77 JDP1.21 ; JDP1.21 296.7,137.32 ; JDP1.21 295.28,137.32 ; JDP1.21 296.7,136.55 ; JDP1.21 293.86,136.55 ; JDP1.21 293.86,137.32 ; JDP1.21 296.7,135.77 ; JDP1.21 293.86,135.77 ; 97.59,30.71 JSATA2.24 ; JSATA2.24 97.59,32.39 ; JSATA2.24 98.57,32.39 ; JSATA2.24 99.54,30.71 ; JSATA2.24 99.54,32.39 ; JSATA2.24 98.57,29.04 ; JSATA2.24 97.59,29.04 ; JSATA2.24 99.54,29.04 ; H11.1 197.22,169.2 ; H11.1 195.29,171.13 ; H11.1 193.87,167.78 ; H11.1 196.71,167.78 ; H11.1 193.87,170.62 ; H11.1 193.36,169.2 ; H11.1 196.71,170.62 ; H11.1 195.29,167.27 ; 32.48,168.18 JHDMI1.11 ; JHDMI1.11 33.4,168.18 ; JHDMI1.11 32.94,168.06 ; 47.79,168.42 JLOM1.15 ; JLOM1.15 46.93,170.17 ; JLOM1.15 47.79,171.92 ; JLOM1.15 46.93,171.92 ; JLOM1.15 46.93,168.42 ; 290.93,119.84 JUSB1.7 ; JUSB1.7 292.39,119.21 ; JUSB1.7 291.12,120.48 ; JUSB1.7 291.12,119.21 ; JUSB1.7 291.76,120.67 ; JUSB1.7 292.39,120.48 ; JUSB1.7 291.76,119.01 ; JUSB1.7 292.59,119.84 ; PBATT1.6 200.08,1.91 ; PBATT1.6 198.6,3.39 ; PBATT1.6 199.34,1.67 ; PBATT1.6 199.34,3.63 ; PBATT1.6 198.6,1.91 ; PBATT1.6 200.08,3.39 ; JLOM1.14 64.65,170.17 ; JLOM1.14 63.79,171.92 ; JLOM1.14 64.65,171.92 ; JESA1.12 21.05,168.49 ; JESA1.12 19.33,170 ; JESA1.12 20.19,171.51 ; JESA1.12 21.05,171.51 ; JESA1.12 19.33,168.49 ; JESA1.12 20.19,168.49 ; JESA1.12 21.05,170 ; JCRT1.5 91.25,174.5 ; JCRT1.5 90.02,173.96 ; JCRT1.5 90.71,173.27 ; JCRT1.5 91.4,173.96 ; JCRT1.5 90.71,174.65 ; JCRT1.5 91.25,173.42 ; JCRT1.5 90.17,174.5 ; 24.26,171.88 JHDMI1.21 ; JHDMI1.21 26.12,168.22 ; JHDMI1.21 25.19,171.88 ; JHDMI1.21 24.26,168.22 ; JHDMI1.21 26.12,171.88 ; JHDMI1.21 26.12,170.05 ; JHDMI1.21 25.19,168.22 ; JHDMI1.21 24.26,170.05 ; JCRT1.16 75.08,172.31 ; JCRT1.16 75.08,173.36 ; 19.33,175.69 JESA1.13 ; JESA1.13 21.05,175.69 ; JESA1.13 21.05,177.2 ; JESA1.13 20.19,175.69 ; JESA1.13 19.33,178.71 ; JESA1.13 19.33,177.2 ; JESA1.13 20.19,178.71 ; JESA1.13 21.05,178.71 ; JUSB1.12 301.72,113.44 ; JUSB1.12 301.72,112.56 ; JUSB1.12 300.41,114.32 ; JUSB1.12 301.72,114.32 ; JUSB1.12 299.1,114.32 ; JUSB1.12 300.41,112.56 ; JUSB1.12 299.1,112.56 ; JUSB1.12 299.1,113.44 ; H9.1 117.31,13.65 ; H9.1 115.89,10.3 ; H9.1 117.82,12.23 ; H9.1 114.47,13.65 ; H9.1 117.31,10.81 ; H9.1 115.89,14.16 ; H9.1 113.96,12.23 ; H9.1 114.47,10.81 ; JDOCK1.158 95.43,121.76 ; JDOCK1.158 94.49,121.44 ; JDOCK1.158 93.55,123.64 ; JDOCK1.158 93.55,121.76 ; JDOCK1.158 95.43,123.64 ; JDOCK1.158 94.49,123.96 ; JDOCK1.158 93.23,122.7 ; JDOCK1.158 95.75,122.7 ; JESA1.4 7.49,171.73 ; JESA1.4 8.08,170.38 ; JESA1.4 6.73,170.97 ; JESA1.4 8.25,170.97 ; JESA1.4 6.9,171.56 ; JESA1.4 8.08,171.56 ; 35.48,168.18 JHDMI1.17 ; JHDMI1.17 35.94,168.06 ; JHDMI1.17 36.4,168.18 ; 106.99,74.2 H7.1 ; H7.1 108.69,78.24 ; H7.1 106.35,75.9 ; H7.1 110.39,77.6 ; H7.1 110.39,74.2 ; H7.1 108.69,73.56 ; H7.1 106.99,77.6 ; H7.1 111.03,75.9 ; JDP1.2 295.24,149.28 ; JDP1.2 295.24,150.21 ; JDP1.2 295.36,149.75 ; JDP1.2 294.78,150.33 ; 198.39,24.1 H18.1 ; H18.1 199.81,24.61 ; H18.1 198.39,27.96 ; H18.1 200.32,26.03 ; H18.1 199.81,27.45 ; H18.1 196.97,27.45 ; H18.1 196.46,26.03 ; H18.1 196.97,24.61 ; H24.1 299.33,16.1 ; H24.1 295.46,17.73 ; H24.1 297.09,13.86 ; H24.1 298.72,17.73 ; H24.1 294.85,16.1 ; H24.1 295.46,14.47 ; H24.1 297.09,18.34 ; H24.1 298.72,14.47 ; JCRT1.7 83,172.96 ; JCRT1.7 82.32,173.65 ; JCRT1.7 81.78,172.42 ; JCRT1.7 82.85,172.42 ; JCRT1.7 82.32,172.27 ; JCRT1.7 81.63,172.96 ; 208.96,97.73 H15.1 ; H15.1 208.96,101.41 ; H15.1 213.33,99.57 ; H15.1 208.27,99.57 ; H15.1 212.64,101.41 ; H15.1 210.8,102.1 ; H15.1 212.64,97.73 ; H15.1 210.8,97.04 ; 293.58,126.24 JUSB1.11 ; JUSB1.11 293.58,125.36 ; JUSB1.11 293.58,127.12 ; JUSB1.11 297.14,125.36 ; JUSB1.11 297.14,127.12 ; JUSB1.11 297.14,126.24 ; JUSB1.11 295.36,125.36 ; JUSB1.11 295.36,127.12 ; 33.69,73.56 H2.1 ; H2.1 31.99,74.2 ; H2.1 36.03,75.9 ; H2.1 35.39,77.6 ; H2.1 31.35,75.9 ; H2.1 31.99,77.6 ; H2.1 35.39,74.2 ; H2.1 33.69,78.24 ; 93.44,127.6 JDOCK1.154 ; JDOCK1.154 93.44,126.63 ; JDOCK1.154 95.54,126.63 ; JDOCK1.154 95.54,125.65 ; JDOCK1.154 95.54,127.6 ; JDOCK1.154 94.49,125.65 ; JDOCK1.154 94.49,127.6 ; JDOCK1.154 93.44,125.65 ; H26.1 73.87,158.68 ; H26.1 73.87,157.12 ; H26.1 73.09,158.93 ; H26.1 72.06,157.9 ; H26.1 72.31,158.68 ; H26.1 74.12,157.9 ; H26.1 73.09,156.87 ; H26.1 72.31,157.12 ; 104.84,156.87 H27.1 ; H27.1 105.87,157.9 ; H27.1 103.81,157.9 ; H27.1 105.62,158.68 ; H27.1 104.06,157.12 ; H27.1 105.62,157.12 ; H27.1 104.84,158.93 ; H27.1 104.06,158.68 ; 293.2,145.25 JDP1.11 ; JDP1.11 293.32,144.78 ; JDP1.11 293.32,145.71 ; JCRT1.18 100.07,172.31 ; JCRT1.18 100.07,173.36 ; JDOCK1.156 122.99,127.6 ; JDOCK1.156 120.93,127.6 ; JDOCK1.156 125.05,127.6 ; JDOCK1.156 125.05,125.65 ; JDOCK1.156 120.93,125.65 ; JDOCK1.156 125.05,126.63 ; JDOCK1.156 122.99,125.65 ; JDOCK1.156 120.93,126.63 ; JDOCK1.164 125.05,117.8 ; JDOCK1.164 122.99,119.75 ; JDOCK1.164 120.93,118.77 ; JDOCK1.164 125.05,118.77 ; JDOCK1.164 122.99,117.8 ; JHDMI1.8 31.44,170.22 ; JHDMI1.8 30.98,170.1 ; JHDMI1.8 31.9,170.1 ; JHDMI1.5 30.4,168.18 ; JHDMI1.5 29.94,168.06 ; JHDMI1.5 29.48,168.18 ; 293.2,148.25 JDP1.5 ; JDP1.5 293.32,147.78 ; JDP1.5 293.32,148.71
  GND3 w0.203: H2.1 36.03,75.9 ; H2.1 31.99,77.6 ; H2.1 31.35,75.9 ; H2.1 33.69,78.24 ; H2.1 31.99,74.2 ; H2.1 35.39,77.6 ; H2.1 35.39,74.2 ; H2.1 33.69,73.56 ; 299.1,125.36 JUSB1.13 ; JUSB1.13 301.72,125.36 ; JUSB1.13 301.72,127.12 ; JUSB1.13 300.41,125.36 ; JUSB1.13 301.72,126.24 ; JUSB1.13 300.41,127.12 ; JUSB1.13 299.1,126.24 ; JUSB1.13 299.1,127.12 ; JDOCK1.156 125.05,126.63 ; JDOCK1.156 120.93,127.6 ; JDOCK1.156 120.93,125.65 ; JDOCK1.156 120.93,126.63 ; JDOCK1.156 122.99,125.65 ; JDOCK1.156 125.05,125.65 ; JDOCK1.156 125.05,127.6 ; JDOCK1.156 122.99,127.6 ; 208.27,99.57 H15.1 ; H15.1 208.96,97.73 ; H15.1 212.64,101.41 ; H15.1 212.64,97.73 ; H15.1 213.33,99.57 ; H15.1 210.8,97.04 ; H15.1 208.96,101.41 ; H15.1 210.8,102.1 ; 296.49,167.77 H21.1 ; H21.1 295.07,171.12 ; H21.1 295.07,168.28 ; H21.1 298.42,169.7 ; H21.1 294.56,169.7 ; H21.1 297.91,171.12 ; H21.1 297.91,168.28 ; H21.1 296.49,171.63 ; 81.44,122.7 JDOCK1.157 ; JDOCK1.157 82.49,123.75 ; JDOCK1.157 81.69,121.9 ; JDOCK1.157 83.29,123.5 ; JDOCK1.157 82.49,121.65 ; JDOCK1.157 83.29,121.9 ; JDOCK1.157 81.69,123.5 ; 25.19,174.49 JHDMI1.23 ; JHDMI1.23 25.19,177.53 ; JHDMI1.23 24.26,174.49 ; JHDMI1.23 24.26,177.53 ; JHDMI1.23 24.26,176.01 ; JHDMI1.23 26.12,177.53 ; JHDMI1.23 26.12,174.49 ; JHDMI1.23 26.12,176.01 ; 75.26,124.68 JDOCK1.145 ; JDOCK1.145 76.32,124.68 ; JDOCK1.145 77.37,124.68 ; JDOCK1.145 75.26,122.7 ; JDOCK1.145 76.32,120.72 ; JDOCK1.145 77.37,122.7 ; JDOCK1.145 77.37,120.72 ; JDOCK1.145 75.26,120.72 ; H10.1 123.29,9.36 ; H10.1 125.22,7.43 ; H10.1 121.87,8.85 ; H10.1 121.36,7.43 ; H10.1 124.71,8.85 ; H10.1 124.71,6.01 ; H10.1 121.87,6.01 ; H10.1 123.29,5.5 ; JDOCK1.152 125.72,120.72 ; JDOCK1.152 125.72,124.68 ; JDOCK1.152 123.61,120.72 ; JDOCK1.152 124.66,120.72 ; JDOCK1.152 125.72,122.7 ; JDOCK1.152 123.61,122.7 ; JDOCK1.152 124.66,124.68 ; JDOCK1.152 123.61,124.68 ; H14.1 151.53,102.36 ; H14.1 147.16,104.2 ; H14.1 149.69,101.67 ; H14.1 151.53,106.04 ; H14.1 149.69,106.73 ; H14.1 147.85,106.04 ; H14.1 152.22,104.2 ; H14.1 147.85,102.36 ; 291.05,161.13 H22.1 ; H22.1 295.53,157.27 ; H22.1 295.53,159.2 ; H22.1 293.29,157.27 ; H22.1 291.05,157.27 ; H22.1 295.53,161.13 ; H22.1 291.05,159.2 ; H22.1 293.29,161.13 ; H1.1 4.91,160.78 ; H1.1 4.91,163.62 ; H1.1 2.07,160.78 ; H1.1 2.07,163.62 ; H1.1 3.49,160.27 ; H1.1 3.49,164.13 ; H1.1 1.56,162.2 ; H1.1 5.42,162.2 ; 120.93,118.77 JDOCK1.164 ; JDOCK1.164 122.99,117.8 ; JDOCK1.164 125.05,118.77 ; JDOCK1.164 122.99,119.75 ; JDOCK1.164 125.05,117.8 ; H8.1 118.91,78.62 ; H8.1 115.56,77.2 ; H8.1 117.49,79.13 ; H8.1 119.42,77.2 ; H8.1 116.07,78.62 ; H8.1 118.91,75.78 ; H8.1 117.49,75.27 ; H8.1 116.07,75.78 ; JUSB2.13 300.41,104.03 ; JUSB2.13 301.72,104.03 ; JUSB2.13 300.41,102.27 ; JUSB2.13 301.72,103.15 ; JUSB2.13 299.1,104.03 ; JUSB2.13 299.1,102.27 ; JUSB2.13 301.72,102.27 ; JUSB2.13 299.1,103.15 ; 117.69,123.5 JDOCK1.160 ; JDOCK1.160 117.69,121.9 ; JDOCK1.160 118.49,123.75 ; JDOCK1.160 118.49,121.65 ; JDOCK1.160 119.29,121.9 ; JDOCK1.160 119.29,123.5 ; JDOCK1.160 119.54,122.7 ; 295.28,135.77 JDP1.21 ; JDP1.21 293.86,135.77 ; JDP1.21 296.7,137.32 ; JDP1.21 293.86,136.55 ; JDP1.21 296.7,135.77 ; JDP1.21 295.28,137.32 ; JDP1.21 293.86,137.32 ; JDP1.21 296.7,136.55 ; H25.1 291.82,7.03 ; H25.1 289.89,5.1 ; H25.1 287.96,7.03 ; H25.1 288.47,5.61 ; H25.1 291.31,8.45 ; H25.1 289.89,8.96 ; H25.1 288.47,8.45 ; H25.1 291.31,5.61 ; 41.96,36.38 H4.1 ; H4.1 48.39,36.38 ; H4.1 54.82,36.38 ; H4.1 41.96,32.2 ; H4.1 48.39,28.02 ; H4.1 54.82,28.02 ; H4.1 54.82,32.2 ; H4.1 41.96,28.02 ; 293.86,153.72 JDP1.22 ; JDP1.22 293.86,152.95 ; JDP1.22 296.7,153.72 ; JDP1.22 295.28,153.72 ; JDP1.22 296.7,152.95 ; JDP1.22 293.86,152.17 ; JDP1.22 295.28,152.17 ; JDP1.22 296.7,152.17 ; 93.23,122.7 JDOCK1.158 ; JDOCK1.158 95.43,123.64 ; JDOCK1.158 93.55,121.76 ; JDOCK1.158 95.75,122.7 ; JDOCK1.158 94.49,123.96 ; JDOCK1.158 94.49,121.44 ; JDOCK1.158 93.55,123.64 ; JDOCK1.158 95.43,121.76 ; H17.1 222.12,79.43 ; H17.1 218.86,76.17 ; H17.1 220.49,75.56 ; H17.1 218.25,77.8 ; H17.1 220.49,80.04 ; H17.1 218.86,79.43 ; H17.1 222.12,76.17 ; H17.1 222.73,77.8 ; 293.58,90.35 JUSB2.10 ; JUSB2.10 297.14,90.35 ; JUSB2.10 293.58,89.47 ; JUSB2.10 295.36,89.47 ; JUSB2.10 295.36,91.23 ; JUSB2.10 293.58,91.23 ; JUSB2.10 297.14,89.47 ; JUSB2.10 297.14,91.23 ; 293.58,126.24 JUSB1.11 ; JUSB1.11 297.14,126.24 ; JUSB1.11 295.36,127.12 ; JUSB1.11 293.58,125.36 ; JUSB1.11 297.14,127.12 ; JUSB1.11 293.58,127.12 ; JUSB1.11 297.14,125.36 ; JUSB1.11 295.36,125.36 ; H26.1 73.87,157.12 ; H26.1 73.87,158.68 ; H26.1 73.09,156.87 ; H26.1 72.31,158.68 ; H26.1 74.12,157.9 ; H26.1 73.09,158.93 ; H26.1 72.06,157.9 ; H26.1 72.31,157.12 ; JUSB1.10 295.36,114.32 ; JUSB1.10 293.58,113.44 ; JUSB1.10 295.36,112.56 ; JUSB1.10 293.58,112.56 ; JUSB1.10 293.58,114.32 ; JUSB1.10 297.14,112.56 ; JUSB1.10 297.14,113.44 ; JUSB1.10 297.14,114.32 ; JUSB1.12 301.72,114.32 ; JUSB1.12 299.1,113.44 ; JUSB1.12 301.72,113.44 ; JUSB1.12 301.72,112.56 ; JUSB1.12 299.1,114.32 ; JUSB1.12 300.41,114.32 ; JUSB1.12 299.1,112.56 ; JUSB1.12 300.41,112.56 ; 32.94,168.06 JHDMI1.11 ; JHDMI1.11 32.48,168.18 ; JHDMI1.11 33.4,168.18 ; 60.17,29.04 JSATA2.23 ; JSATA2.23 62.12,29.04 ; JSATA2.23 60.17,30.71 ; JSATA2.23 62.12,30.71 ; JSATA2.23 62.12,32.39 ; JSATA2.23 61.15,29.04 ; JSATA2.23 61.15,32.39 ; JSATA2.23 60.17,32.39 ; JESA1.14 2.65,177.2 ; JESA1.14 2.65,178.71 ; JESA1.14 2.65,175.69 ; JESA1.14 0.93,177.2 ; JESA1.14 1.79,178.71 ; JESA1.14 1.79,175.69 ; JESA1.14 0.93,175.69 ; 151.67,142.46 H12.1 ; H12.1 149.83,146.83 ; H12.1 149.83,143.15 ; H12.1 149.14,144.99 ; H12.1 154.2,144.99 ; H12.1 153.51,146.83 ; H12.1 153.51,143.15 ; H12.1 151.67,147.52 ; 6.64,169.18 JESA1.5 ; JESA1.5 6.64,170.26 ; JESA1.5 6.49,169.72 ; JESA1.5 7.18,169.03 ; JESA1.5 7.72,169.18 ; JCRT1.19 100.07,174.41 JCRT1.18 ; JCRT1.19 99.01,171.19 ; JCRT1.19 100.07,172.8 ; JCRT1.19 97.96,171.19 ; JCRT1.19 97.96,174.41 ; JCRT1.19 99.01,174.41 ; JCRT1.19 100.07,171.19 ; 203.34,1.67 PBATT1.8 ; PBATT1.8 202.6,3.39 ; PBATT1.8 203.34,3.63 ; PBATT1.8 204.08,3.39 ; PBATT1.8 204.08,1.91 ; PBATT1.8 202.6,1.91 ; JLOM1.14 63.79,171.92 ; JLOM1.14 64.65,171.92 ; JLOM1.14 64.65,170.17 ; 89.18,173.27 JCRT1.10 ; JCRT1.10 88.5,173.96 ; JCRT1.10 89.72,174.5 ; JCRT1.10 89.87,173.96 ; JCRT1.10 88.65,174.5 ; JCRT1.10 89.18,174.65 ; H19.1 222.73,16.1 ; H19.1 218.25,16.1 ; H19.1 218.86,17.73 ; H19.1 222.12,17.73 ; H19.1 222.12,14.47 ; H19.1 220.49,13.86 ; H19.1 220.49,18.34 ; H19.1 218.86,14.47 ; JDOCK1.162 95.54,117.8 ; JDOCK1.162 95.54,118.77 ; JDOCK1.162 93.44,118.77 ; JDOCK1.162 93.44,117.8 ; JDOCK1.162 94.49,119.75 ; JDOCK1.162 93.44,119.75 ; JDOCK1.162 94.49,117.8 ; JDOCK1.162 95.54,119.75 ; 204.6,1.91 PBATT1.9 ; PBATT1.9 206.08,3.39 ; PBATT1.9 205.34,3.63 ; PBATT1.9 206.32,2.65 ; PBATT1.9 205.34,1.67 ; PBATT1.9 204.6,3.39 ; PBATT1.9 206.08,1.91 ; 84.61,173.27 JCRT1.8 ; JCRT1.8 84.61,174.65 ; JCRT1.8 85.29,173.96 ; JCRT1.8 85.14,174.5 ; JCRT1.8 84.07,174.5 ; JCRT1.8 83.92,173.96 ; JHDMI1.22 40.62,177.53 ; JHDMI1.22 38.76,176.01 ; JHDMI1.22 39.69,177.53 ; JHDMI1.22 38.76,174.49 ; JHDMI1.22 40.62,174.49 ; JHDMI1.22 39.69,174.49 ; JHDMI1.22 38.76,177.53 ; JHDMI1.22 40.62,176.01 ; 135.56,157.9 H28.1 ; H28.1 137.37,157.12 ; H28.1 136.59,156.87 ; H28.1 135.81,158.68 ; H28.1 137.37,158.68 ; H28.1 135.81,157.12 ; H28.1 137.62,157.9 ; H28.1 136.59,158.93 ; 207.49,2.65 PBATT1.11 ; PBATT1.11 209.44,0.74 ; PBATT1.11 207.49,4.56 ; PBATT1.11 207.49,0.74 ; PBATT1.11 209.44,2.65 ; PBATT1.11 209.44,4.56 ; PBATT1.11 208.46,0.74 ; PBATT1.11 208.46,4.56 ; 93.44,125.65 JDOCK1.154 ; JDOCK1.154 95.54,126.63 ; JDOCK1.154 95.54,127.6 ; JDOCK1.154 93.44,127.6 ; JDOCK1.154 94.49,127.6 ; JDOCK1.154 95.54,125.65 ; JDOCK1.154 94.49,125.65 ; JDOCK1.154 93.44,126.63 ; 10.99,169.03 JESA1.8 ; JESA1.8 11.53,169.18 ; JESA1.8 11.53,170.26 ; JESA1.8 10.45,170.26 ; JESA1.8 10.99,170.41 ; JESA1.8 10.45,169.18 ; JESA1.15 2.65,168.49 ; JESA1.15 0.93,171.51 ; JESA1.15 0.93,168.49 ; JESA1.15 2.65,170 ; JESA1.15 0.93,170 ; JESA1.15 1.79,168.49 ; JESA1.15 1.79,171.51 ; 28.56,16.2 H3.1 ; H3.1 29.07,17.62 ; H3.1 31.91,14.78 ; H3.1 30.49,14.27 ; H3.1 30.49,18.13 ; H3.1 32.42,16.2 ; H3.1 31.91,17.62 ; H3.1 29.07,14.78 ; JUSB2.4 294.09,100.25 ; JUSB2.4 293.9,99.61 ; JUSB2.4 293.26,101.08 ; JUSB2.4 292.63,99.61 ; JUSB2.4 293.26,99.42 ; JUSB2.4 293.9,100.88 ; H23.1 298.72,79.43 ; H23.1 295.46,76.17 ; H23.1 297.09,75.56 ; H23.1 299.33,77.8 ; H23.1 294.85,77.8 ; H23.1 298.72,76.17 ; H23.1 297.09,80.04 ; H23.1 295.46,79.43 ; JHDMI1.5 30.4,168.18 ; JHDMI1.5 29.48,168.18 ; JHDMI1.5 29.94,168.06 ; 292.63,122.71 JUSB1.4 ; JUSB1.4 294.09,123.34 ; JUSB1.4 293.9,123.98 ; JUSB1.4 293.26,124.17 ; JUSB1.4 293.26,122.51 ; JUSB1.4 293.9,122.71 ; 196.97,24.61 H18.1 ; H18.1 198.39,24.1 ; H18.1 200.32,26.03 ; H18.1 199.81,24.61 ; H18.1 199.81,27.45 ; H18.1 196.46,26.03 ; H18.1 198.39,27.96 ; H18.1 196.97,27.45 ; JESA1.12 21.05,171.51 ; JESA1.12 20.19,168.49 ; JESA1.12 21.05,168.49 ; JESA1.12 20.19,171.51 ; JESA1.12 19.33,170 ; JESA1.12 19.33,168.49 ; JESA1.12 21.05,170 ; 295.46,17.73 H24.1 ; H24.1 297.09,18.34 ; H24.1 294.85,16.1 ; H24.1 298.72,17.73 ; H24.1 298.72,14.47 ; H24.1 295.46,14.47 ; H24.1 299.33,16.1 ; H24.1 297.09,13.86 ; 300.94,136.7 JDP1.23 ; JDP1.23 303.5,137.47 ; JDP1.23 302.22,135.92 ; JDP1.23 300.94,137.47 ; JDP1.23 300.94,135.92 ; JDP1.23 303.5,135.92 ; JDP1.23 302.22,137.47 ; JDP1.23 303.5,136.7 ; JCRT1.17 75.08,171.19 ; JCRT1.17 72.97,171.19 ; JCRT1.17 72.97,174.41 ; JCRT1.17 75.08,174.41 JCRT1.16 ; JCRT1.17 75.08,172.8 ; JCRT1.17 74.02,171.19 ; JCRT1.17 74.02,174.41 ; JUSB2.12 300.41,91.23 ; JUSB2.12 301.72,89.47 ; JUSB2.12 299.1,91.23 ; JUSB2.12 301.72,90.35 ; JUSB2.12 300.41,89.47 ; JUSB2.12 301.72,91.23 ; JUSB2.12 299.1,90.35 ; JUSB2.12 299.1,89.47 ; JCRT1.18 100.07,172.31 ; JCRT1.18 100.07,173.36 ; 198.6,1.91 PBATT1.6 ; PBATT1.6 200.08,1.91 ; PBATT1.6 199.34,1.67 ; PBATT1.6 198.6,3.39 ; PBATT1.6 200.08,3.39 ; PBATT1.6 199.34,3.63 ; 68.07,166.28 H5.1 ; H5.1 68.07,169.12 ; H5.1 69.49,169.63 ; H5.1 71.42,167.7 ; H5.1 69.49,165.77 ; H5.1 70.91,169.12 ; H5.1 70.91,166.28 ; H5.1 67.56,167.7 ; JCRT1.16 75.08,172.31 ; JCRT1.16 75.08,173.36 ; 106.49,121.44 JDOCK1.159 ; JDOCK1.159 107.43,123.64 ; JDOCK1.159 105.55,121.76 ; JDOCK1.159 105.55,123.64 ; JDOCK1.159 106.49,123.96 ; JDOCK1.159 105.23,122.7 ; JDOCK1.159 107.43,121.76 ; JDOCK1.159 107.75,122.7 ; H27.1 105.87,157.9 ; H27.1 104.06,157.12 ; H27.1 104.84,158.93 ; H27.1 104.06,158.68 ; H27.1 104.84,156.87 ; H27.1 103.81,157.9 ; H27.1 105.62,157.12 ; H27.1 105.62,158.68 ; 46.93,170.17 JLOM1.15 ; JLOM1.15 46.93,171.92 ; JLOM1.15 47.79,168.42 ; JLOM1.15 46.93,168.42 ; JLOM1.15 47.79,171.92 ; 291.12,96.12 JUSB2.7 ; JUSB2.7 292.39,97.39 ; JUSB2.7 291.76,95.92 ; JUSB2.7 291.76,97.58 ; JUSB2.7 292.39,96.12 ; JUSB2.7 291.12,97.39 ; JUSB2.7 292.59,96.75 ; JUSB2.7 290.93,96.75 ; 6.9,171.56 JESA1.4 ; JESA1.4 8.25,170.97 ; JESA1.4 8.08,170.38 ; JESA1.4 6.73,170.97 ; JESA1.4 8.08,171.56 ; JESA1.4 7.49,171.73 ; JDP1.8 295.24,146.28 ; JDP1.8 295.24,147.21 ; JDP1.8 295.36,146.75 ; JDP1.16 295.36,142.75 ; JDP1.16 295.24,143.21 ; JDP1.16 295.24,142.28 ; 214.07,89.08 H16.1 ; H16.1 214.07,91.92 ; H16.1 216.91,91.92 ; H16.1 217.42,90.5 ; H16.1 215.49,88.57 ; H16.1 216.91,89.08 ; H16.1 215.49,92.43 ; H16.1 213.56,90.5 ; 140.27,144.58 H6.1 ; H6.1 141.69,147.93 ; H6.1 139.76,146 ; H6.1 143.62,146 ; H6.1 140.27,147.42 ; H6.1 141.69,144.07 ; H6.1 143.11,144.58 ; H6.1 143.11,147.42 ; H20.1 272.31,88.55 ; H20.1 272.31,85.71 ; H20.1 269.47,88.55 ; H20.1 270.89,85.2 ; H20.1 272.82,87.13 ; H20.1 269.47,85.71 ; H20.1 268.96,87.13 ; H20.1 270.89,89.06 ; 293.32,147.78 JDP1.5 ; JDP1.5 293.32,148.71 ; JDP1.5 293.2,148.25 ; JODD1.14 26.39,43.45 ; JODD1.14 24.61,44.5 ; JODD1.14 24.61,42.4 ; JODD1.14 26.39,44.5 ; JODD1.14 26.39,42.4 ; JODD1.14 22.84,43.45 ; JODD1.14 22.84,42.4 ; JODD1.14 22.84,44.5 ; JUSB1.7 292.59,119.84 ; JUSB1.7 292.39,119.21 ; JUSB1.7 291.12,119.21 ; JUSB1.7 291.76,119.01 ; JUSB1.7 290.93,119.84 ; JUSB1.7 292.39,120.48 ; JUSB1.7 291.12,120.48 ; JUSB1.7 291.76,120.67 ; JHDMI1.2 28.9,170.1 ; JHDMI1.2 28.44,170.22 ; JHDMI1.2 27.86,169.64 ; JHDMI1.2 27.98,170.1 ; 35.48,168.18 JHDMI1.17 ; JHDMI1.17 35.94,168.06 ; JHDMI1.17 36.4,168.18 ; JSATA1.24 203.58,70.49 ; JSATA1.24 200.23,71.47 ; JSATA1.24 200.23,69.52 ; JSATA1.24 200.23,70.49 ; JSATA1.24 203.58,71.47 ; JSATA1.24 201.91,69.52 ; JSATA1.24 203.58,69.52 ; JSATA1.24 201.91,71.47 ; 19.33,175.69 JESA1.13 ; JESA1.13 19.33,178.71 ; JESA1.13 21.05,178.71 ; JESA1.13 20.19,175.69 ; JESA1.13 20.19,178.71 ; JESA1.13 21.05,175.69 ; JESA1.13 19.33,177.2 ; JESA1.13 21.05,177.2 ; 75.93,119.75 JDOCK1.161 ; JDOCK1.161 77.99,117.8 ; JDOCK1.161 75.93,117.8 ; JDOCK1.161 75.93,118.77 ; JDOCK1.161 80.05,119.75 ; JDOCK1.161 77.99,119.75 ; JDOCK1.161 80.05,117.8 ; JDOCK1.161 80.05,118.77 ; JHDMI1.21 25.19,171.88 ; JHDMI1.21 26.12,168.22 ; JHDMI1.21 26.12,170.05 ; JHDMI1.21 24.26,168.22 ; JHDMI1.21 26.12,171.88 ; JHDMI1.21 25.19,168.22 ; JHDMI1.21 24.26,170.05 ; JHDMI1.21 24.26,171.88 ; H13.1 210.25,143.35 ; H13.1 206.57,143.35 ; H13.1 205.88,141.51 ; H13.1 206.57,139.67 ; H13.1 210.25,139.67 ; H13.1 210.94,141.51 ; H13.1 208.41,138.98 ; H13.1 208.41,144.04 ; 38.76,170.05 JHDMI1.20 ; JHDMI1.20 38.76,171.88 ; JHDMI1.20 38.76,168.22 ; JHDMI1.20 39.69,171.88 ; JHDMI1.20 39.69,168.22 ; JHDMI1.20 40.62,170.05 ; JHDMI1.20 40.62,171.88 ; JHDMI1.20 40.62,168.22 ; 105.44,118.77 JDOCK1.163 ; JDOCK1.163 106.49,119.75 ; JDOCK1.163 107.54,117.8 ; JDOCK1.163 106.49,117.8 ; JDOCK1.163 105.44,119.75 ; JDOCK1.163 107.54,119.75 ; JDOCK1.163 107.54,118.77 ; JDOCK1.163 105.44,117.8 ; 108.69,73.56 H7.1 ; H7.1 108.69,78.24 ; H7.1 110.39,74.2 ; H7.1 110.39,77.6 ; H7.1 106.35,75.9 ; H7.1 106.99,74.2 ; H7.1 111.03,75.9 ; H7.1 106.99,77.6 ; 200.23,32.1 JSATA1.23 ; JSATA1.23 203.58,33.08 ; JSATA1.23 201.91,34.05 ; JSATA1.23 203.58,34.05 ; JSATA1.23 203.58,32.1 ; JSATA1.23 201.91,32.1 ; JSATA1.23 200.23,33.08 ; JSATA1.23 200.23,34.05 ; JSATA2.24 99.54,32.39 ; JSATA2.24 99.54,29.04 ; JSATA2.24 98.57,32.39 ; JSATA2.24 97.59,30.71 ; JSATA2.24 97.59,29.04 ; JSATA2.24 98.57,29.04 ; JSATA2.24 97.59,32.39 ; JSATA2.24 99.54,30.71 ; 30.98,170.1 JHDMI1.8 ; JHDMI1.8 31.9,170.1 ; JHDMI1.8 31.44,170.22 ; JODD1.15 26.39,21.05 ; JODD1.15 22.84,20 ; JODD1.15 22.84,21.05 ; JODD1.15 24.61,20 ; JODD1.15 26.39,22.1 ; JODD1.15 22.84,22.1 ; JODD1.15 26.39,20 ; JODD1.15 24.61,22.1 ; JCRT1.7 82.85,172.42 ; JCRT1.7 82.32,173.65 ; JCRT1.7 81.63,172.96 ; JCRT1.7 82.32,172.27 ; JCRT1.7 81.78,172.42 ; JCRT1.7 83,172.96 ; 293.2,145.25 JDP1.11 ; JDP1.11 293.32,144.78 ; JDP1.11 293.32,145.71 ; H9.1 117.31,13.65 ; H9.1 114.47,10.81 ; H9.1 114.47,13.65 ; H9.1 117.31,10.81 ; H9.1 117.82,12.23 ; H9.1 115.89,14.16 ; H9.1 113.96,12.23 ; H9.1 115.89,10.3 ; H11.1 197.22,169.2 ; H11.1 196.71,170.62 ; H11.1 193.87,170.62 ; H11.1 193.87,167.78 ; H11.1 195.29,167.27 ; H11.1 196.71,167.78 ; H11.1 195.29,171.13 ; H11.1 193.36,169.2 ; 302.22,152.02 JDP1.24 ; JDP1.24 303.5,152.8 ; JDP1.24 300.94,152.02 ; JDP1.24 300.94,153.57 ; JDP1.24 303.5,152.02 ; JDP1.24 300.94,152.8 ; JDP1.24 303.5,153.57 ; JDP1.24 302.22,153.57 ; 293.58,102.27 JUSB2.11 ; JUSB2.11 293.58,104.03 ; JUSB2.11 297.14,102.27 ; JUSB2.11 293.58,103.15 ; JUSB2.11 297.14,104.03 ; JUSB2.11 295.36,104.03 ; JUSB2.11 297.14,103.15 ; JUSB2.11 295.36,102.27 ; 79.49,173.42 JCRT1.6 ; JCRT1.6 79.49,174.5 ; JCRT1.6 79.34,173.96 ; JCRT1.6 80.03,174.65 ; JCRT1.6 80.56,174.5 ; JCRT1.6 80.03,173.27 ; JCRT1.6 80.71,173.96 ; 106.49,125.65 JDOCK1.155 ; JDOCK1.155 105.44,127.6 ; JDOCK1.155 106.49,127.6 ; JDOCK1.155 107.54,127.6 ; JDOCK1.155 105.44,126.63 ; JDOCK1.155 107.54,126.63 ; JDOCK1.155 105.44,125.65 ; JDOCK1.155 107.54,125.65 ; 293.32,140.78 JDP1.19 ; JDP1.19 293.2,141.25 ; JDP1.19 293.32,141.71 ; JDP1.19 293.78,140.66 ; PBATT1.10 187.19,0.74 ; PBATT1.10 185.24,2.65 ; PBATT1.10 186.22,0.74 ; PBATT1.10 185.24,4.56 ; PBATT1.10 187.19,4.56 ; PBATT1.10 185.24,0.74 ; PBATT1.10 187.19,2.65 ; PBATT1.10 186.22,4.56 ; JCRT1.5 91.4,173.96 ; JCRT1.5 91.25,173.42 ; JCRT1.5 90.71,173.27 ; JCRT1.5 91.25,174.5 ; JCRT1.5 90.71,174.65 ; JCRT1.5 90.17,174.5 ; JCRT1.5 90.02,173.96 ; JDP1.2 295.24,150.21 ; JDP1.2 295.24,149.28 ; JDP1.2 294.78,150.33 ; JDP1.2 295.36,149.75 ; 14.8,169.03 JESA1.11 ; JESA1.11 15.49,169.72 ; JESA1.11 14.26,169.18 ; JESA1.11 15.34,169.18 ; JESA1.11 15.34,170.26 ; JDOCK1.153 80.05,125.65 ; JDOCK1.153 77.99,127.6 ; JDOCK1.153 75.93,126.63 ; JDOCK1.153 80.05,127.6 ; JDOCK1.153 75.93,125.65 ; JDOCK1.153 75.93,127.6 ; JDOCK1.153 77.99,125.65 ; JDOCK1.153 80.05,126.63
  BOTTOM w0.152: 83.89,75.3 84.63,75.3 84.7,75.22 v2(84.7,75.22)
  BOTTOM w0.178: UH1.BA40 83.89,75.3
  BOTTOM w0.203: U19.30 97.51,108.42 97.79,108.7 v3(97.79,108.9) ; U22.31 v3(289.56,74.04) ; PU200.21 v3(149.97,22.51) 150.01,22.56 150.01,23.32 149.97,23.36 PU200.3 ; v3(93.77,117.34) 93.74,117.37 JDOCK1.49 ; JDOCK1.137 117.74,119.76 118.01,120.03 v3(118.21,120.03) ; JDOCK1.63 98.24,117.87 98.47,117.64 98.47,117.16 98.02,116.71 98,116.71 97.97,116.73 v3(97.97,116.71) ; v3(92.58,116.85) 92.24,117.19 JDOCK1.43 ; JDOCK1.81 102.74,119.66 102.99,119.91 v3(106.05,119.91) ; v3(45.21,83.55) 44.82,83.95 JXDP2.37 ; v3(111.45,125.26) 111.74,125.55 JDOCK1.114 ; PU1001.5 261.47,27.27 v3(261.49,27.24) ; JDOCK1.69 99.74,116.42 99.39,116.07 v3(99.21,116.07) ; JDOCK1.93 105.74,117.06 v3(105.64,116.95) 105.64,116.98 105.61,117.01 105.61,117.08 105.24,117.45 JDOCK1.91 ; U629.57 36.51,125.73 35.71,126.53 35.71,127.29 R123.2 ; JDOCK1.61 97.74,117.58 v3(97.97,117.34) ; v3(95.83,117.34) 95.83,117.43 96.24,117.84 JDOCK1.55 ; v3(45.74,79.97) 45.22,79.45 JXDP2.19 ; v3(114.98,125.48) 114.74,125.72 JDOCK1.126 ; CE8.2 104.24,114.69 JDOCK1.87 ; JDOCK1.101 108.74,119.72 108.46,120 107.08,120 v3(107.03,119.95) 107.24,119.74 JDOCK1.95 ; JDOCK1.75 101.24,117.89 100.81,117.46 100.81,116.22 100.51,115.91 100.51,114.8 100.81,114.49 CE9.2 ; JXDP2.25 44.85,80.95 v3(45.24,80.56) ; R116.2 34.91,125.45 U629.53 ; U23.6 125.78,145.3 v3(125.58,145.1) ; JDOCK1.51 95.24,117.94 94.92,117.62 v3(94.92,117.34) ; v3(45.59,77.89) 45.06,77.36 45.06,76.8 44.71,76.45 JXDP2.7 ; U37.11 v3(58.32,16.57) ; v3(110.08,125.36) 110.24,125.52 JDOCK1.108 ; U629.8 v3(39.31,121.08) ; v2(39.27,117.01) 39.19,117.08 U629.18 ; v3(117,125.22) 117.08,125.22 117.74,125.88 JDOCK1.138 ; JDOCK1.37 90.74,117.47 v3(90.63,117.36) ; v3(92.86,108.19) 93.23,107.82 U19.20 ; v3(148.69,24.14) 149.04,24.14 PU200.1 ; U13.11 84.32,150.66 v3(84.17,150.81) ; JDOCK1.120 113.24,125.78 112.9,125.44 112.9,124.35 113.38,123.86 v3(113.66,123.86) ; v2(80.06,75.58) 79.91,75.43 79.75,75.43 79.46,75.13 UH1.AY29 ; v3(32.54,117.03) 32.54,117.03 32.58,117.08 U629.33 ; v3(45.16,78.37) 44.73,77.95 JXDP2.13 ; v3(93.78,116.7) 93.7,116.7 93.24,117.16 JDOCK1.47 ; v3(45.69,83.02) 45.12,82.45 JXDP2.31 ; 76.72,75.77 UH1.BC22 ; JDOCK1.57 96.74,117.51 95.93,116.7 v3(95.83,116.7) ; v3(155.78,24.04) 156.5,24.04 156.7,23.84 PQ205.4 ; UH1.L44 85.04,62.88 v2(84.83,63.08) ; 181.97,37.28 v3(180.99,37.28) ; JDOCK1.131 v3(116.24,120.04)
  BOTTOM w0.254: UH1.U42 84.94,65.48 v2(84.94,65.95) 85.31,65.95 UH1.V43 85.94,66.13 UH1.W44 ; v3(36.3,91.63) 36.3,91.22 36.15,91.08 U29.2 ; v2(73.73,64.96) 73.66,64.96 UH1.R14 ; v2(73.73,64.96) 73.89,65.11 73.97,65.11 UH1.U16 ; v2(73.73,64.96) 73.96,64.73 74.04,64.73 UH1.R16 ; JDOCK1.7 v3(83.24,117.36) ; JDOCK1.14 84.74,128.21 v3(84.74,128.21) ; UH1.A43 UH1.A44 85.83,58.52 UH1.B44 86.36,59.05 UH1.B45 UH1.C45 UH1.E45 86.85,60.15 v3(87.93,59.07) ; UH1.A43 UH1.A41 ; UH1.A43 85.32,58.07 v2(85.5,57.9) ; UH1.M17 74.34,62.84 v2(74.34,62.5) ; JDOCK1.70 99.74,128.16 v3(99.69,128.21) ; JXDP2.60 50.98,89.45 v3(51.21,89.22) ; v3(90.65,152.08) 90.67,152.11 U11.11 ; v2(70.49,62.07) 70.49,62.08 70.52,62.05 70.52,61.76 UH1.H7 UH1.G8 ; v3(94.33,104.2) 93.99,103.86 93.99,103.58 93.91,103.5 U19.10 ; v3(238.28,50.9) 238.28,50.9 238.42,50.77 U51.B18 ; 81.9,73.61 82.08,73.61 82.71,72.97 UH1.AT36 UH1.AT38 ; 81.9,73.61 v2(81.89,73.61) ; 81.9,73.61 81.57,73.94 UH1.AV33 ; U22.18 v3(284.92,78.68) ; UH1.P26 78.28,63.97 v2(78.61,64.3) 78.94,63.97 UH1.P28 UH1.P30 ; v2(110.01,117.44) 110.24,117.67 JDOCK1.107 ; v2(78.61,67.6) 78.94,67.27 UH1.AA28 UH1.Y28 ; v2(78.61,68.92) 78.28,69.25 UH1.AG26 ; v2(78.61,68.92) 78.94,69.25 UH1.AG28 ; v2(78.61,68.92) 78.69,68.92 UH1.AE28 ; UH1.R44 85.94,64.5 UH1.T43 85.53,64.82 v2(85.22,64.51) 85.53,64.2 UH1.P43 ; JDOCK1.26 v3(87.74,128.21) ; UH1.AG2 68.83,69.38 69.11,69.65 v2(69.32,69.65) 69.68,70.02 UH1.AJ6 ; UH1.AM16 UH1.AK16 74.09,70.57 v2(73.75,70.23) ; UH1.B39 83.63,59.67 v2(83.44,59.86) ; UH1.W2 v2(69.04,66.13) ; v2(69.05,66.13) 69.15,66.23 UH1.AA4 ; v2(69.05,66.13) 69.68,65.49 UH1.U6 ; v3(257.55,31.15) 257.58,31.18 PU1001.14 ; UH1.AN36 83.06,71.63 v2(83.06,71.49) 83.03,71.46 83.03,71.27 UH1.AL38 ; v2(78.86,71.82) 78.84,71.8 78.84,71.41 UH1.AM28 UH1.AM30 ; UH1.AJ16 74.07,69.91 v2(73.75,70.23) ; U51.B66 240.05,42.18 v2(240,42.23) ; UH1.Y40 84.5,66.2 v2(84.25,65.95) 84.25,65.84 UH1.U39 ; U22.3 v3(280.8,72.54) ; v3(15.62,126.94) JAPS1.14 ; JDOCK1.19 v3(86.24,117.36) ; UH1.AD30 79.91,67.93 v2(80.24,67.6) 80.56,67.93 UH1.AD32 ; v2(73.46,73.01) 73.53,73.01 73.86,73.34 UH1.AT15 ; v2(78.92,73.6) 78.76,73.6 78.51,73.34 UH1.AT26 ; JDOCK1.52 95.24,127.87 95.43,128.05 v3(95.43,128.26) ; JDOCK1.44 92.24,128.25 v3(92.25,128.26) ; v3(273.25,15.94) 272.66,15.94 JSIM1.17 ; U625.10 v3(273.76,74.24) ; UH1.U10 71.52,65.49 71.12,65.09 v2(71.12,65.02) 71.12,64.72 70.94,64.54 UH1.R8 ; v2(81.13,66.99) 81.13,67.04 81.52,67.44 UH1.AB34 ; UH1.AJ34 81.52,70.26 v2(81.79,70.52) 81.57,70.74 81.52,70.74 UH1.AL34 ; JDOCK1.32 89.24,128.04 v3(89.08,128.21) ; v3(34.9,93.03) 34.15,92.28 U29.6 ; UH1.R12 72.53,64.31 v2(72.53,64) 72.53,63.79 UH1.N12 ; UH1.AK14 73.41,70.57 v2(73.75,70.23) ; v3(50.98,79.64) 50.78,79.45 JXDP2.20 ; UH1.AJ38 83.03,69.74 v2(83.03,69.56) 83.03,69.32 UH1.AF38 ; UH1.U34 81.52,65.74 v2(81.76,65.98) 81.52,66.22 UH1.Y34 ; v2(70.95,75.66) 70.62,75.99 UH1.BD7 ; U22.24 v3(287.92,78.68) ; JDOCK1.123 114.24,119.96 v3(113.87,120.33) 113.83,120.3 113.82,120.3 113.24,119.72 JDOCK1.119 ; JXDP2.59 45.44,89.45 v3(45.54,89.55) ; v2(77.01,66.97) 77.01,66.99 ; 77.01,66.99 77.39,66.61 UH1.Y24 ; 77.01,66.99 76.73,67.27 UH1.AA22 ; UH1.BD19 75.5,75.72 v2(75.33,75.55) ; v3(104.27,128.21) 104.24,128.23 103.17,128.23 102.74,127.8 JDOCK1.82 ; v3(104.27,128.21) 104.27,128.23 104.24,128.21 v3(104.27,128.21) ; v3(104.27,128.21) 104.24,128.18 JDOCK1.88 ; UH1.AV24 77.59,73.94 v2(77.89,73.65) ; v2(73.73,66.27) 73.39,66.61 UH1.Y14 ; v2(73.73,66.27) 73.91,66.1 73.99,66.1 UH1.V16 ; v2(73.73,66.27) 73.66,66.27 73.34,65.95 UH1.V14 ; v2(73.73,66.27) 74.08,66.61 UH1.Y16 UH1.AA16 ; UH1.AP31 79.98,71.77 v2(79.91,71.77) 79.83,71.69 UH1.AM30 ; UH1.AD16 73.81,68.26 v2(73.75,68.26) 73.66,68.26 73.33,67.93 UH1.AD14 72.85,67.45 UH1.AB12 ; v3(229.51,30.8) 228.67,31.64 227.94,31.64 227.79,31.49 PU700.4 ; JXDP2.2 48.16,74.95 47.85,75.25 47.85,76.14 48.16,76.45 JXDP2.8 50.59,76.45 v3(50.82,76.21) ; UH1.AJ22 UH1.AJ20 75.67,69.91 v2(75.36,70.22) 75.05,69.91 UH1.AJ18 ; UH1.Y36 82.74,66.47 82.96,66.69 v2(82.96,66.96) 82.96,67.1 UH1.AB38 ; UH1.AG16 74.09,69.25 v2(73.75,68.92) 73.81,68.92 74.14,68.59 UH1.AE16 ; UH1.V26 78.28,65.95 v2(78.61,65.62) 78.71,65.62 79.02,65.32 UH1.U28 ; v3(47.65,81.93) 48.17,82.45 JXDP2.32 ; U46.B27 237.73,65.19 237.67,65.25 237.67,65.7 237.31,66.06 v2(236.98,66.06) ; v2(69.09,60.35) 69.09,60.33 69.14,60.28 69.14,60.04 UH1.D4 ; JSIM1.12 257.95,16.55 v3(257.75,16.75) ; UH1.K15 73.68,61.96 v2(73.38,61.96) 72.99,61.57 UH1.H13 ; U51.B11 239,47.17 v2(239.11,47.05) ; RP4.6 240.39,79.38 v3(240.16,79.62) 239.89,79.35 RP4.5 ; UH1.BE41 84.68,77.11 84.68,77.28 85.19,77.79 85.19,79.11 v2(85.06,79.24) ; v3(112.11,117.34) 111.74,117.71 JDOCK1.113 ; UH1.H36 82.32,61.59 82.14,61.76 81.93,61.76 v2(81.87,61.83) 81.68,61.83 UH1.K33 ; JDOCK1.38 90.74,127.84 90.91,128 v3(90.91,128.23) ; U29.3 35.65,91.03 35.05,91.63 v3(34.9,91.63) ; UH1.AR2 v2(69.04,72.63) ; JDOCK1.132 116.24,125.35 v3(116.36,125.24) ; v3(89.49,117.43) 89.24,117.68 JDOCK1.31 ; v3(265.35,31.2) 265.33,31.18 PU1001.32 ; v3(252.35,58.48) 252.08,58.75 U39.18 ; UH1.AD8 70.88,68.06 70.75,68.19 70.75,68.25 70.56,68.44 v2(70.56,68.54) 70.56,68.64 70.94,69.01 UH1.AF8 ; v2(83.03,64.96) 83.03,65.06 83.31,65.34 UH1.U38 ; JXDP2.50 48.17,86.95 47.75,86.53 v3(47.75,85.33) ; v2(84.5,59.65) 84.61,59.77 UH1.D42 ; UH1.AM30 UH1.AM32 ; v2(71.69,62.06) 71.74,62.06 71.93,61.87 UH1.H10 ; UH1.G44 85.87,61.25 UH1.F43 85.34,60.85 v2(84.96,60.47) ; 185.77,37.28 v3(186.77,37.28) ; v3(245.21,44.01) 245.21,43.4 245.82,42.79 245.82,42.05 246.05,41.82 U51.B54 ; UH1.AP13 72.92,72.1 v2(73.28,71.74) 73.33,71.69 UH1.AM14 73.09,70.99 UH1.AL12 ; UH1.L2 68.78,62.88 ; JXDP2.26 48.12,80.95 v3(47.85,81.22) ; UH1.AV7 UH1.AV6 69.26,73.93 v2(69.16,74.03) 68.93,74.26 UH1.AW2 ; JXDP2.1 41.07,74.95 v3(40.42,74.3) ; JDOCK1.13 v3(84.74,117.36) ; UH1.AC2 68.31,67.73 v2(69.04,67.73) 69.38,68.06 UH1.AD6 ; UH1.AD18 74.95,67.93 75.28,67.6 v2(75.36,67.6) 75.69,67.27 UH1.AA20 ; v2(77.8,70.85) 77.52,70.57 UH1.AK24 UH1.AJ24 ; JSIM1.13 258.32,9.7 257.75,9.7 v3(257.73,9.72) ; v2(71.42,73.11) 71.65,73.34 UH1.AT10 72.45,73.86 72.83,73.86 UH1.AV13 ; UH1.P32 80.97,63.97 UH1.R34 81.52,64.26 v2(81.76,64.02) 82.12,63.67 UH1.N35 ; v3(47.27,83.95) 47.27,83.91 47.3,83.95 JXDP2.38 ; JDOCK1.1 v3(81.74,117.36) ; v3(107.24,128.21) 107.24,128.21 JDOCK1.96 ; v2(84.35,68.54) 84.5,68.39 UH1.AD40 84.81,67.76 UH1.AC44 ; v3(96.54,128.21) 96.74,128.01 JDOCK1.58 ; UH1.R2 v2(69,64.5) ; v3(117.28,158.12) 117.49,157.91 117.49,157 C595.2 ; v3(123.67,138.24) 123.67,137.5 124.33,136.84 128.36,136.84 129.58,138.06 C109.2 ; JDOCK1.20 86.24,128.21 v3(86.24,128.21) ; UH1.Y8 70.94,66.77 v2(71.13,66.96) 70.94,67.15 UH1.AB8 ; JSIM1.16 272.66,9.7 v3(273.23,9.7) ; U51.B60 243.05,42.18 v2(243,42.23) ; JDOCK1.125 114.74,117.75 v3(114.35,117.36) ; UH1.AT29 79.58,73.34 v2(79.88,73.65) ; UH1.AV22 76.53,73.65 v2(76.34,73.65) 76.25,73.65 75.94,73.34 UH1.AT20 ; UH1.AL2 68.96,71.01 v2(69.26,70.7) ; UH1.K10 71.22,62.88 v2(71.22,63.08) 71.22,63.22 UH1.N10 ; UH1.BD31 80.38,75.93 80.06,75.61 v2(80.06,75.58) ; v2(80.87,73.7) 80.8,73.7 80.55,73.94 UH1.AV31 ; UH1.M22 76.58,63.6 UH1.P22 76.66,63.97 v2(76.99,64.3) 77.32,63.97 UH1.P24 77.43,63.93 UH1.M24 ; RP4.8 241.39,79.3 v3(241.12,79.57) 240.89,79.33 RP4.7 ; JDOCK1.25 v3(87.74,117.36) ; v3(83.24,128.03) JDOCK1.8 ; v2(75.33,73.67) 75.2,73.67 UH1.AT17 ; v2(83.31,61.6) 83.31,60.99 ; 83.31,60.99 83.4,61.07 84.05,61.07 84.5,61.53 UH1.H40 ; 83.31,60.99 UH1.G38 ; v2(83.62,64.96) 83.62,64.82 UH1.R38 ; v3(100.63,128.21) 100.61,128.21 101.19,127.62 101.24,127.62 JDOCK1.76 ; v3(98.07,128.21) 98.24,128.03 JDOCK1.64 ; PU1001.5 v3(261.47,29.5) ; JDOCK1.94 105.74,128.08 v3(105.54,128.28) ; JDOCK1.102 108.74,127.59 108.33,128 v3(108.25,128) ; JXDP2.49 42.48,86.95 v3(42.11,86.58) ; U629.41 v3(32.54,120.28) ; PR1018.2 261.57,36.31 261.26,36.01 261.26,34.82 261.47,34.62 PU1001.23 ; U625.21 v3(267.97,74.24) ; UH1.AK45 UH1.AK43 ; v3(50.9,78.3) 50.55,77.95 JXDP2.14 ; v2(84.86,69.56) 85.04,69.38 UH1.AG44
  BOTTOM w0.305: JAPS1.12 13.39,125.94 v3(13.1,125.65) 13.1,125.24 13.4,124.94 JAPS1.10 ; v3(87.93,59.07) 87.83,58.97 UH1.B45 ; JDEG2.1 v3(277.1,31.09) ; UH1.K39 83.91,62.66 83.64,62.93 v2(83.64,63.07) 83.64,63.27 UH1.N39 ; UH1.AM26 78.21,71.51 v2(77.9,71.81) 77.75,71.81 77.43,72.14 UH1.AP24 ; JDIMM2.66 169.72,72.27 169.72,73.36 170.05,73.68 171.27,73.68 171.54,73.41 JDIMM2.60 ; v2(77.8,70.85) 77.42,71.23 UH1.AM24 ; v3(12.95,124.02) 13.02,123.94 JAPS1.8
  BOTTOM w0.356: JDIMM4.127 149.04,48.64 v2(148.54,48.14) ; v2(180.11,48.14) 180.24,48.27 JDIMM4.31 ; v2(187.2,52.85) 187.2,52.59 186.84,52.23 JDIMM4.9 ; JDIMM2.134 146.94,74.17 146.79,74.32 v2(146.79,74.35) ; v2(135.43,68.91) 135.19,69.15 135.19,70.55 135.54,70.9 JDIMM2.172 135.54,73.45 135.19,73.8 133.99,73.8 133.74,73.54 JDIMM2.178 ; v3(130.3,48.11) 130.44,48.25 JDIMM4.189 ; JDIMM2.28 181.14,70.24 181.49,69.89 181.49,69.01 181.09,68.61 v2(180.85,68.61) ; 171.54,59.53 JDIMM4.60 ; v2(144.02,66.67) 144.61,66.67 145.44,65.85 JDIMM2.139 145.44,62.78 v2(145.74,62.47) ; JDIMM2.150 142.14,73.22 142.52,73.6 143.57,73.6 143.94,73.23 JDIMM2.144 143.94,70.86 142.56,69.49 v2(141.96,69.49) ; JDIMM4.25 182.04,48.39 v2(181.79,48.14) ; JDIMM4.134 146.94,59.25 ; JDIMM4.49 174.84,48.23 v2(174.93,48.14) ; JDIMM2.71 168.24,62.68 ; 138.84,62.73 JDIMM2.161 138.84,65.14 138.2,65.78 138.2,66.29 v2(138.74,66.82) ; JDIMM4.196 128.34,59.22 v2(128.6,59.47) ; JDIMM4.63 170.64,48.52 v2(170.25,48.14) 170.04,48.35 JDIMM4.65 ; JDIMM4.184 131.94,59.36 ; JDIMM4.2 v2(188.94,59.73) ; v2(131.67,67.96) 130.44,66.73 JDIMM2.189 ; JDIMM2.136 146.34,70.68 146.05,70.4 146.05,68.2 v2(145.29,67.44) ; JDIMM4.37 178.44,48.3 v2(178.28,48.14) ; v2(185.15,66.47) 185.76,65.87 185.76,65.13 185.64,65.02 JDIMM2.13 ; JDIMM4.155 140.64,50.87 139.57,51.94 v2(139.57,52.46) ; JDIMM4.195 128.64,48.22 v2(128.73,48.14) ; v2(176.4,48.14) 176.64,48.38 JDIMM4.43 ; v2(138.74,69.87) 138.16,70.44 138.16,70.87 138.54,71.24 JDIMM2.162 ; JDIMM4.20 183.54,59.22 v2(183.87,59.55) ; JDIMM4.133 147.24,48.41 v3(146.94,48.11) ; JDIMM4.38 178.14,60.07 178.4,60.32 v2(178.4,60.24) ; JDIMM4.162 138.54,59.26 ; v2(185.78,59.6) 185.34,59.16 JDIMM4.14 ; v2(140.41,62.62) 140.64,62.85 JDIMM2.155 ; JDIMM4.54 173.34,59.21 v2(173.61,59.47) ; JDIMM2.196 128.34,73.45 128.79,73.89 129.78,73.89 130.14,73.53 JDIMM2.190 130.14,71.18 129.74,70.78 129.74,69.99 v2(129.87,69.86) ; JDIMM4.32 179.94,59.56 ; JDIMM4.128 148.74,59.65 v2(148.87,59.78) ; 136.14,59.37 JDIMM4.170 ; v2(187,68.37) 186.24,67.62 JDIMM2.11 ; JDIMM2.170 136.14,70.61 v2(136.7,70.05) ; JDIMM4.144 143.94,59.3 ; v2(140.95,52.87) 140.94,52.86 140.59,52.86 140.33,52.6 140.33,52.06 140.81,51.59 140.84,51.59 141.24,51.19 JDIMM4.153 ; JDIMM2.26 181.74,70.65 182.92,69.47 v2(183.15,69.47) ; v2(168.37,59.58) 168.36,59.58 167.94,59.16 JDIMM4.72 ; 133.44,62.69 JDIMM2.179 133.44,65.1 133.12,65.42 133.12,66.42 v2(133.7,67) ; JDIMM2.8 187.14,70.02 188.63,68.53 188.63,68.58 188.63,68.58 v2(188.63,68.58) ; v2(174.39,69.99) 174.61,69.99 175.14,70.51 JDIMM2.48 ; JDIMM2.173 135.24,62.83 135.3,62.83 v2(135.51,62.62) ; JDIMM4.151 141.84,48.41 v3(142.14,48.11) ; JDIMM4.190 130.14,59.49 ; JDIMM2.25 182.04,65.08 182.27,65.32 182.27,66.95 182.62,67.3 182.62,67.79 183,68.17 v2(183.15,68.17) ; v2(179.47,69.49) 179.69,69.49 180.16,69.96 180.16,70.83 179.94,71.05 JDIMM2.32 ; 187.14,59.47 JDIMM4.8 ; v2(185.34,48.14) 185.64,48.44 JDIMM4.13 ; JDIMM4.185 131.64,48.35 v2(131.85,48.14) ; v2(179.51,68.25) 179.29,68.25 178.36,69.19 178.36,71.03 178.14,71.25 JDIMM2.38 ; v2(171.47,48.14) 171.24,48.37 JDIMM4.61 ; JDIMM2.61 171.24,62.6 ; v2(133.64,59.82) 133.74,59.72 JDIMM4.178 ; v2(145.29,69.72) 145.29,70.49 145.74,70.94 JDIMM2.138 ; v2(140.26,66.44) 140.27,66.43 140.27,65.99 141.24,65.02 JDIMM2.153 141.24,62.72 ; JDIMM4.161 138.84,48.41 v3(138.54,48.11) ; JDIMM2.65 170.04,62.68 ; v2(140.26,68.73) 140.34,68.81 JDIMM2.156 ; JDIMM4.136 146.34,59.31 ; JDIMM2.128 148.74,69.57 148.1,68.93 147.26,68.93 v2(146.86,69.34) ; JDIMM4.19 183.84,48.27 v3(184,48.11) ; JDIMM2.2 188.94,70.92 189.4,70.46 191.72,70.46 191.79,70.53 191.79,70.6 191.77,70.63 v3(191.77,70.65) ; JDIMM4.150 142.14,59.43 ; JDIMM2.31 180.24,65.42 180.85,66.04 v2(180.85,66.42) ; v2(169.43,68.16) 168.21,68.16 167.64,68.73 167.64,71.09 167.94,71.39 JDIMM2.72 ; 131.04,62.68 JDIMM2.187 131.04,65.96 131.51,66.43 v2(131.67,66.43) ; v2(187,66.09) 186.84,65.93 JDIMM2.9 ; JDIMM2.195 128.64,62.96 v2(128.93,62.68) ; v2(173.13,48.14) 173.04,48.22 JDIMM4.55 ; v2(143.84,48.14) 143.64,48.34 JDIMM4.145 ; v2(188.77,48.14) 188.75,48.14 188.62,48.27 188.62,49.85 JDIMM4.3 ; JDIMM2.133 147.24,62.62 ; JDIMM4.26 181.74,59.47 ; v2(169.43,69.68) 169.75,69.68 170.1,70.03 170.1,70.61 169.74,70.97 JDIMM2.66 ; JDIMM4.11 v3(186.24,48.11) ; v2(139.05,74.07) 137.22,74.07 136.74,73.58 JDIMM2.168 ; JDIMM2.43 176.64,62.68 ; JDIMM4.168 136.74,59.7 v2(136.61,59.83) ; JDIMM2.46 175.74,68.72 v2(175.78,68.67) ; v2(183.17,66.7) 183.3,66.7 183.68,66.32 183.68,65.15 183.84,64.99 JDIMM2.19 ; v2(185.15,67.99) 184.04,67.99 183.9,68.13 183.9,70.97 183.54,71.34 JDIMM2.20 183.54,73.78 183.69,73.93 184.65,73.93 185.34,73.24 JDIMM2.14 ; JDIMM4.156 140.34,59.31 ; v2(135.43,66.62) 135.56,66.62 137.04,65.14 JDIMM2.167 137.04,62.71 ; JDIMM4.46 175.74,59.42 ; v2(146.85,67.64) 146.87,67.66 146.87,67.66 146.93,67.6 148.37,67.6 149.04,66.93 JDIMM2.127 ; 174.84,62.56 JDIMM2.49 174.84,65.59 v2(175.81,66.56) ; v2(171.01,66.14) 170.64,65.77 JDIMM2.63 170.64,62.69 ; v2(179.48,66.74) 179.35,66.74 178.44,65.84 JDIMM2.37 ; v2(188.63,62.69) 188.64,62.7 JDIMM2.3 ; v2(174.39,68.46) 173.34,69.51 JDIMM2.54 ; v2(142,66.66) 141.8,66.66 141.4,66.26 141.4,65.74 141.84,65.3 JDIMM2.151 141.84,62.68 ; 143.64,62.72 JDIMM2.145 ; v2(177.38,69.99) 177.09,69.99 176.34,70.74 JDIMM2.44 ; v2(131.46,74.8) 131.46,74.31 131.94,73.84 JDIMM2.184 ; JDIMM4.173 v2(135.24,48.14) ; JDIMM4.139 145.44,48.39 v2(145.69,48.14) ; JDIMM4.28 181.14,59.44 ; JDIMM4.179 133.44,48.17 v3(133.5,48.11) ; JDIMM4.71 168.24,48.23 v2(168.15,48.14) ; JDIMM4.44 176.34,59.28 ; 135.54,59.53 JDIMM4.172 ; JDIMM4.187 131.04,50.85 130.55,51.33 130.3,51.33 130.05,51.59 130.05,52.35 130.3,52.6 130.72,52.6 v2(130.73,52.62) ; JDIMM4.138 145.74,59.47 ; JDIMM4.48 175.14,59.34 ; JDIMM2.185 131.64,62.71 ; v2(172.28,68.05) 173.43,66.89 173.43,65.39 173.04,64.99 JDIMM2.55 ; JDIMM4.66 169.74,59.57 v2(169.82,59.65) ; JDIMM4.167 v2(137.04,48.14)
  BOTTOM w0.381: v3(70.14,108.84) 70.14,110.19 Q110.4 ; v2(73.84,53.12) 73.84,53.15 73.81,53.18 73.8,53.16 73.4,53.56 72.59,53.56 72.11,54.04 RH119.2 ; C614.2 257.54,63.95 U39.3 ; C717.2 234.85,62.29 v3(234.87,62.32) ; v3(102.59,162.52) 102.76,162.69 U54.3 ; PQ1082.3 223.86,46.4 223.59,46.14 222.74,46.14 222.48,46.41 PQ1080.1 ; v3(55.4,68.16) 55.65,68.42 56.23,68.42 56.67,67.98 RH47.2 ; U50.3 238.72,56.56 239.39,55.89 v3(239.39,55.74) ; U59.1 6.87,138.64 PC19.2 7.01,137.99 U59.2 ; Q110.1 v3(68.79,112.92) ; v3(96.42,165.49) 96.49,165.42 96.52,165.42 96.95,164.99 C727.2 ; C606.1 C603.2 124.05,154.88 124.99,153.94 125.58,153.94 125.98,153.53 125.98,153.28 v3(126.01,153.25) ; U39.11 v3(257.43,58.75) ; v3(202.36,65.55) 202.72,65.19 202.74,65.19 Q29.4 ; v3(101.7,70.3) 101.67,70.3 100.73,69.35 C746.2 ; v3(94.58,160.8) 94.69,160.91 U55.3 ; PQ1071.1 v3(251.22,20.55) ; PC219.2 159.41,24.5 159.82,24.09 PQ204.4 ; PQ205.1 158,20.35 PC220.2 ; v3(45.57,105.35) 45.57,105.42 45.58,105.42 Q347.4 ; v3(44.04,105.09) 43.04,104.09 U10.3 ; v3(220.8,48.31) 221.18,48.69 PQ1080.4 ; PC216.2 161.12,20 PQ204.1 ; U39.8 257.38,60.7 v3(257.53,60.55) ; v3(44.26,107.25) 44.28,107.28 Q347.1 ; C48.2 259.13,62.8 258.63,63.3 U39.4 ; C370.2 14.46,87.76 15.53,87.76 15.59,87.82 v3(15.59,87.85) ; v3(235.25,16.3) 235.23,16.27 PQ708.1 ; U39.25 v3(249.03,63.3) ; v3(237.44,62.22) 237.44,61.61 237.56,61.48 C713.2 ; v2(165.06,105.31) 165.05,105.3 165.05,103.98 162.94,101.87 162.94,99.73 163.23,99.45 RC72.2 ; U39.2 257.12,64.6 257.5,64.99 v3(257.5,65.57) 257.12,65.57 256.8,65.25 U39.1 ; PU1080.3 223.19,60.5 v3(223.14,60.55) ; PQ1071.4 249.92,21.94 v3(250.34,22.37) ; PQ706.1 237.72,20.64 v3(237.46,20.38) ; v3(233.07,62.24) 233.07,61.66 C712.2 ; RH117.1 91.59,63.06 v3(91.71,63.18) ; v3(241.58,22.42) 241.1,21.94 PQ706.4 ; v3(59.99,54.62) 60.23,54.86 U12.3 ; Q339.1 v3(289.8,60.64) ; v3(288.97,111.29) 289.15,111.47 D14.3 ; PQ707.1 v2(254.04,14.57) ; PQ708.4 v3(233.39,14.97) ; Q339.4 v3(288.5,63.93) ; PU1081.3 222.62,50.6 v3(222.25,50.97) ; PU704.3 247.28,21.78 v3(247.06,22) ; UC3.3 v3(67.59,83.62)
  BOTTOM w0.432: PR717.2 256.01,16.23 255.64,15.87 PQ707.4 v3(254.56,15.87)
  BOTTOM w0.457: PC19.2 7.57,138.54 7.57,138.67 7.59,138.69 7.59,138.9 v3(7.62,138.93) ; v2(76.05,53.16) 76.05,53.38 CH44.2 ; v3(86.26,82.39) 86.36,82.49 RH176.2
  BOTTOM w0.508: v3(103.55,115.05) 103.55,114.62 CE8.2 ; v3(236.6,18.58) 237.27,18.58 PR746.2 ; JDIMM2.205 126.19,80.15 v3(127.05,79.29) ; v3(249.53,54.04) C327.2 ; v3(96.52,167.26) 96.07,167.26 R1137.2 ; C610.2 257.86,41 v3(257.5,40.64) ; v3(103.05,31.55) 102.59,31.09 PC406.2 ; C359.2 54.08,113.68 53.64,113.25 v3(53.64,112.76) ; v3(239.39,55.74) 239.32,55.74 239.11,55.54 C739.2 C1349.2 ; v2(123.04,170.63) 122.4,170.63 121.89,170.11 JMINI2.21 ; R123.2 35.76,127.32 v3(36.35,126.73) ; v3(16.86,89.57) 15.66,89.57 C330.2 ; C248.2 103.53,169.15 104.04,169.66 v3(104.06,169.66) ; v3(117.7,61.61) 116.98,61.61 116.61,61.24 RD20.1 ; RC45.2 v3(169.14,148.1) ; JMINI2.43 130.69,169.36 132.03,170.7 v3(132.03,170.85) ; C453.2 v3(275.64,70.12) ; C630.2 v3(265.4,22.26) ; C614.2 258.24,64.65 v3(258.24,65.6) ; JMINI1.54 269.09,69.76 v3(269.06,69.79) ; v3(130.91,140.02) 130.91,139.51 130.28,138.88 C109.2 129.08,139.37 C110.2 v3(130.02,140.02) ; U52.4 111.87,65.6 v3(112.17,65.29) ; Q52.3 254.47,49.61 v3(253.92,50.15) 253.52,50.56 R843.1 ; R869.1 251.94,46.88 v3(252.68,46.88) 253.34,46.88 R892.1 ; R869.1 251.89,47.18 252.25,47.54 v3(252.68,47.54) ; R869.1 C781.2 251.89,45.15 R812.1 ; PC17.1 1.4,139.03 v3(1.4,139.54) ; v3(24.18,159.75) 23.94,159.51 ; 23.94,159.51 23.24,158.81 JMINI4.27 ; 23.94,159.51 23.94,158.79 24.04,158.69 JMINI4.29 ; C419.2 v3(186.28,42.99) ; JMINI3.27 v3(76.94,21.74) ; JAPS1.17 v3(10.79,116.65) ; PJPDC1.11 13.78,76.78 13.14,77.42 v3(11.96,77.42) ; C733.2 233.4,39.61 233.71,39.92 v3(233.71,40.04) ; PC791.2 222.22,30.93 v3(221.84,31.31) ; PR105.2 32.94,40.5 PR102.1 32.01,41.21 v3(31.6,41.62) ; RH70.2 v3(69.01,85.94) ; C468.2 112.75,93.28 v3(112.88,93.16) ; C757.2 C736.2 v3(243.94,36.69) ; R406.2 28.27,92.65 27.86,92.24 v3(27.86,91.99) ; JMINI2.4 v3(111.89,161.2) ; R121.2 32.87,125.9 v3(32.61,125.64) ; v3(277.7,76.52) 277.82,76.65 C496.2 ; v3(19.12,150.79) 19.64,150.27 JMINI4.18 ; v3(90.91,128.23) 90.91,128.82 90.24,129.48 90.24,131.61 90.6,131.97 C696.2 R2160.2 ; v3(97.56,161.53) 97.92,161.18 97.92,161.05 98.07,160.9 98.07,160.72 R1138.2 ; C1174.2 v3(68.78,114.31) ; C1216.2 100.73,62.09 100.51,62.32 99.8,62.32 99.44,61.96 v3(99.44,61.68) ; v3(182.88,14.64) 182.88,14.87 183.12,15.11 PC1004.2 ; PC926.2 190.49,147.08 v3(189.94,147.08) ; CD71.2 154.91,43.63 155.55,42.99 v3(156.06,42.99) ; v3(91.29,112.74) C695.2 R757.2 ; PC942.2 187.74,146.9 v3(187.02,146.9) ; R747.2 v3(294.08,65.67) ; JFAN1.1 226.75,80.67 v3(227.32,80.67) ; RC40.1 v3(205.81,128.46) ; v3(81.3,112.89) 81.19,112.78 C703.2 ; C21.2 v3(80.62,161.99) ; v3(246.61,62.68) C550.2 C553.2 ; C762.2 v3(277.34,40.32) ; v3(292.17,57.93) 291.74,57.93 291.39,58.28 C669.2 v3(292.2,58.74) ; v3(282.22,84.2) R1613.1 281.52,83.4 C715.2 ; R889.1 v3(252.42,50.86) ; C794.2 v3(288.52,90.56) ; RC85.2 209.78,125.84 209.78,124.96 v3(209.79,124.94) ; v3(61.01,82.97) 61.36,82.61 RH167.2 RH169.2 RH219.1 ; C1353.2 240.74,37.33 v3(240.54,37.53) ; C14.2 v3(89.38,169.43) ; 182.49,42.16 R85.1 ; 182.49,42.16 182.68,41.97 v3(182.68,40.63) ; 182.49,42.16 182.5,42.18 C24.1 ; v3(31.42,111.24) 31.44,111.27 31.44,112.28 R115.2 ; v3(281.41,45.4) 281.41,44.39 C1176.2 ; C1149.2 C1159.2 v3(77.82,154.24) ; R809.1 v3(271.63,70.12) ; v3(255.05,28.68) PC1008.2 255.55,30.02 PC1009.2 ; C1345.2 233.83,41.42 v3(233.78,41.47) ; R1995.2 132.82,145.2 v3(132.74,145.12) ; C88.2 292.02,70.18 v3(292.32,70.48) ; v3(277.7,73.22) R77.2 R75.1 ; CD7.2 150.72,78.94 v2(150.34,79.32) ; C629.2 v3(264.26,22.26) ; R431.2 40.89,95.57 v3(41.25,95.92) ; C621.2 v3(22.88,146.16) ; C742.2 234.24,46.55 v3(233.78,47) ; PR224.2 v3(158.3,18.37) ; C1182.2 v3(92.24,108.88) ; v3(12.3,139.84) 12.66,140.2 R739.2 ; v3(40.2,41.02) 40.61,40.61 PC199.2 ; R879.1 234.16,36 v3(233.7,35.55) ; RH81.1 69.87,54.17 69.39,53.68 69.39,53.36 69.11,53.08 v3(69.11,53.12) ; v3(109.19,84.7) C1177.2 108.86,85.48 108.53,85.15 v3(108.53,84.7) ; Q45.3 33.87,81.91 v3(34.34,82.39) ; v3(55.6,58) 55.83,58.23 C290.2 C289.2 ; v3(155.78,24.04) PC217.2 155.75,24.81 PR225.2 ; R102.1 228.19,66.61 227.66,66.08 v3(227.66,66.03) ; v3(159.49,43.75) 159.49,43.82 CD77.2 ; v2(71.22,51.25) CH55.2 CH56.2 CH57.2 ; R62.1 v3(277.7,75.76) ; v3(158.88,20.71) 158.3,20.14 PC220.2 ; R86.2 v3(183.87,34.1) ; C320.2 R425.2 235.56,55.69 v3(235.58,55.72) ; v3(102.74,165.42) 102.74,165.44 103.16,165.87 U3.3 ; v3(22.5,150.99) 22.84,150.65 JMINI4.26 ; PC783.2 PR732.1 232.26,34 232.71,34.46 v3(233.53,34.46) ; v2(154.37,82.01) 153.54,82.01 CD12.2 ; R82.2 v3(182.85,34.1) ; RH56.2 RH54.2 61.24,69.28 60.65,69.28 v3(60.63,69.25) ; v3(128.75,153.92) 128.46,154.22 C250.2 ; Q47.3 253.96,41.41 253.54,41.82 v3(253.24,41.82) 253.21,41.85 C292.2 ; v3(99.54,114.29) 100.79,114.29 CE9.2 ; PC745.2 v3(224.93,22.78) ; PC407.2 v2(99.39,23.44) ; CH77.2 94.16,56.58 v3(94.23,56.65) ; U53.4 v3(109.68,58.48) ; v3(9.98,86.93) 10.49,87.44 JFAN2.1 ; PC1006.2 v3(264.01,23.66) ; v3(113.97,155) 113.51,155.46 C605.2 ; CD11.2 150.34,82.74 v2(150.35,82.74) ; C1176.2 283.18,44.39 v3(283.18,45.4) ; C1176.2 v3(282.3,45.4) ; PC744.1 v3(231.37,32.14) ; PC746.2 229.79,47.99 v3(230.81,47.99) 231.11,47.69 C779.2 ; C484.2 v3(47.73,143.57) ; v3(284.69,93.62) 284.69,94.44 284.14,95 D17.1 ; C1179.2 C277.2 35.99,87.62 v3(35.81,87.8) ; RD37.1 v3(131.42,44.56) ; CD42.2 CD15.2 v2(147.42,78.83) ; C46.2 v3(38.38,162.67) ; JMINI1.43 v3(268.09,45) ; v3(33.81,125.77) 33.78,125.79 33.78,126.38 R116.2 ; v3(100.42,31.55) 100.81,31.16 PR404.2 ; v3(248.99,59.7) 248.94,59.75 CE3.2 ; JFAN1.6 223.04,87.44 v3(222.35,87.44) ; v3(28.65,96.66) 28.98,96.33 C274.2 ; v3(62.3,86.02) 62.28,86.02 62.25,85.99 62.25,85.15 CH10.2 ; JMINI4.54 6.79,155.87 6.93,155.72 v3(6.93,155.03) ; C12.2 C13.2 88.03,163.67 87.7,164 v3(87.7,164.02) ; C709.2 R17.1 245.64,72.07 v2(245.52,72.2) ; JMINI2.50 v3(133.49,161.53) ; JTAG1.2 252.65,38.04 v3(252.86,38.24) ; R131.1 41.07,90.74 v3(41.55,91.22) ; v3(115.21,87.41) 115.21,87.01 115.59,86.63 C1178.2 v3(115.92,87.41) ; PC936.2 v3(176.41,145.38) ; PC729.2 PR744.2 238.26,14.49 238.26,13.31 v3(238.38,13.2) ; v3(112.88,91.89) 113.13,92.14 C464.2 ; v3(226.8,17.39) 227,17.59 PC732.2 ; R2201.1 v3(272.13,77.84) ; R79.2 288.11,67.53 v3(288.11,66.84) ; v3(243.51,21.03) 243.99,20.55 PC733.1 ; RD19.1 116.61,58.34 116.04,57.77 116.04,54.7 116.95,53.79 ; v3(172.74,24.32) PC1003.2 173.76,24.33 PC1002.2 ; RH89.1 61.38,58.33 ; 61.38,58.33 61.03,57.99 61.03,57.61 v2(61.14,57.51) ; 61.38,58.33 61.19,58.33 60.11,59.41 U18.2 ; JMINI2.54 108.07,167.4 v3(109.7,165.77) ; JMINI1.27 v3(271.22,51.4) ; JDEG2.11 277.81,37.69 v3(278.79,38.67) ; v3(94,75.45) 93.6,75.05 CH14.1 ; v2(166.06,130.31) 166.95,130.31 167.73,129.53 RC59.2 ; PC114.1 30.9,38.32 v3(30.53,38.7) ; v3(102.3,57.53) 102.23,57.6 CE2.2 ; C1354.2 234.66,34 v3(234.17,34.48) ; v3(12.09,159.63) 12.84,158.88 JMINI4.9 ; C720.2 v3(234.54,57.01) ; RC83.2 210.49,127.17 v3(209.71,127.94) ; C740.2 v3(252.68,40.07) ; R96.1 30.07,117.03 v3(29.28,117.82) ; CH13.1 89.92,72.67 v3(90.23,72.35) ; JMINI1.29 v3(271.24,50.6) ; v3(269.85,40.2) 269.85,39.31 JMINI1.53 ; v3(162.08,18.74) PR217.2 PC216.2 162.02,19.79 162.1,19.87 v3(162.1,19.98) ; JMINI3.29 v3(76.14,21.74) ; R105.1 v3(269.09,77.84) ; v3(298.8,63.56) U45.11 ; C716.2 234.16,78.65 v3(234.57,79.06) ; v3(54.3,143.55) 54.08,143.78 C480.2 ; v3(237.78,23.38) 237.78,22.99 237.34,22.54 PC736.2 ; PU703.4 236.93,17.87 237.36,17.44 PR745.2 ; C450.2 v3(268.07,77.84) ; RC71.2 v3(155.45,123.25) ; JMINI3.54 94.43,20.95 v3(95.23,21.75) ; v3(83.89,161.96) 83.92,161.99 R54.2 C23.2 ; v3(132.64,154.14) 132.99,154.5 C604.2 ; v3(28.7,95.39) 28.7,95.38 28.72,95.36 29.31,95.36 R404.2 ; PC527.1 v3(147.81,174.86) ; v2(163.3,80.25) 164.54,79.01 164.57,79.01 CD10.2 ; v3(2.75,150.08) 2.75,150.64 3.22,151.11 R851.2 ; v3(91.39,165.19) 90.97,165.61 U6.2 ; v3(233.78,47) 234.21,47.44 C1348.2 ; v3(233.78,47) 233.32,46.55 C744.2 ; v3(111.2,154.34) 111.1,154.45 C608.2 ; C637.1 v3(76.99,31.64) ; v3(60.63,78.68) CH17.2 ; v3(159.33,82.72) 159.1,82.49 CD13.2 ; v3(150.72,43.75) 150.21,44.26 CD73.2 ; C612.2 258.22,52.52 v3(258.22,51.85) ; v3(239.72,37.4) 240.21,36.92 C743.2 ; v3(91.87,75.55) 91.87,75.55 91.11,75.55 CH64.2 ; R773.1 v3(273.15,77.84) ; C741.2 237.39,36.84 v3(236.96,37.28) ; JMINI2.27 124.29,169.34 v3(124.36,169.41) 124.61,169.41 125.09,168.93 JMINI2.29 ; R775.1 v3(226.24,72.45) ; RH226.2 61.31,74.54 60.7,74.54 v3(60.68,74.56) ; R1207.1 v3(276.35,76.52) ; CH63.2 90.78,77.98 90.78,78.58 v3(90.83,78.63) ; v3(150.72,42.99) 151.48,42.99 151.74,43.24 CD74.2 ; JRTC1.4 57.39,102.37 v3(58.82,103.8) ; JMINI3.50 v3(67.74,29.93) ; RC86.2 204.77,117.26 v3(204.44,116.93) ; R122.2 31.62,126.25 v3(31.62,125.79) ; v3(238.73,78.93) 238.73,78.52 238.45,78.25 C719.2 ; R2200.1 v3(264.87,76.39) ; C497.2 280.34,67.25 v3(280.34,66.84) ; v3(26.77,159.07) 26.44,158.74 JMINI4.35 ; JMINI2.34 v3(127.09,161.2) ; C87.2 278.36,69.58 v3(277.7,69.58) ; PC210.2 v3(152.12,17.29) ; JFAN2.6 8.25,81.47 7.57,82.15 v3(7.57,82.66) ; v3(91.03,59.53) 91.18,59.37 RH146.2 91.11,58.53 CH78.2 ; C97.1 30.2,122.57 v3(27.51,122.57) ; v3(91.69,61.05) 91.67,61.02 RH115.1 ; CD85.2 CD86.2 v3(147.55,43.75) ; JMINI4.34 26.04,150.5 25.55,150.99 v3(25.3,150.99) ; C710.2 228.48,70.17 227.74,70.91 v3(227.74,71.03) ; v3(40.84,69.47) 40.47,69.1 PR307.1 40.11,69.71 39.79,70.03 PC307.2 ; v3(28.43,38.43) 27.77,39.09 PC120.2 ; v3(41.15,91.73) 41.05,91.63 R424.2 C319.2 ; v3(128.01,44.56) 128.41,44.96 CD87.2 CD88.2 126.72,45.2 124.79,43.27 JDIMM3.205 ; v3(271.3,61.81) 271.28,61.8 JMINI1.9 ; RC41.1 v3(199.74,151.19) ; CD76.2 157.45,44.39 158.85,42.99 v3(159.49,42.99) ; RC49.2 RC42.2 RC55.2 198.4,99.3 198.88,99.78 198.88,101.5 198,102.38 v2(197.85,102.38) ; CD51.2 162.79,43.75 163.55,42.99 v3(164.06,42.99) ; PR758.2 232.92,27.62 v3(233.17,27.37) ; v3(116.99,169.36) 116.29,168.66 JMINI2.15 ; v3(41.55,127.8) 41.34,128.02 C783.2 ; C631.2 268.07,22.26 v3(268.04,22.29) ; C611.2 v3(272.01,48.2) ; PC219.2 159.44,24.81 PR220.2 159.44,26.07 159.23,26.28 v3(159.23,26.53) ; JMINI1.50 v3(263.09,42.2) ; v3(32.03,150.89) 32.44,150.48 JMINI4.50 ; JMINI1.53 268.32,39.32 v3(268.32,40.2) ; JMINI1.53 v3(269.09,40.2) ; PC213.2 v3(150.86,16.88) ; PC704.2 225.14,33.87 v3(225.7,34.43) ; JMINI4.43 29.64,156.83 v3(30.33,156.15) ; JDIMM2.206 v2(190.39,82.89) ; R657.2 259.79,60.26 v3(260.02,60.49) ; D15.1 v3(296.77,123.22) ; v2(177.75,165.93) 178.28,165.93 PC534.2 ; v3(223.86,48.44) PQ1082.3 ; v3(261.77,35.65) 261.77,36.13 PR1018.2 ; R100.1 130.2,148.12 v3(130.94,148.12) ; PC1007.2 v3(262.61,23.66) ; v3(259.84,22.26) 260.01,22.1 C645.2 ; R876.2 242.16,34.62 241.91,34.37 v3(241.91,33.97) ; PC215.2 v3(153.64,16.98) ; v3(227.98,40.86) 227.98,41.15 229.14,42.32 C343.2 ; v3(227.96,34.46) PC702.1 ; C780.2 248.87,37.1 v3(248.87,36.69) ; PR104.1 32.89,35.12 PR106.2 v3(33.59,35.11) ; C670.2 v3(298.32,59.07) ; CD4.2 v2(155.27,81.42) ; v3(34.01,146.5) 33.81,146.29 C623.2 ; C616.2 C643.2 v3(262.23,22.26) ; R59.1 290.3,81.75 v3(290.27,81.78) ; CD23.2 CD24.2 196.77,65.27 197.38,65.88 v3(197.81,65.88) ; v3(110.09,169.51) 110.31,169.51 C601.2 ; v3(60.7,70.52) 60.73,70.5 61.29,70.5 RH55.2 ; R808.2 64.06,58.2 v3(63.55,58.71) ; C504.2 v3(37.34,127.52) ; v3(113.89,166.15) 113.89,166.16 JMINI2.9 ; JFAN1.5 229.85,80.63 v3(228.12,80.63) ; v2(162.83,79.78) 162.56,80.06 162.56,80.91 162.18,81.29 CD2.2 ; R793.2 v3(247.7,69.66) ; R492.1 81.33,131.97 81.07,131.71 v3(81.07,130.39) ; v3(252.68,52.82) 252.65,52.79 251.86,52.79 C777.2 ; v3(34.47,156.53) 35.09,157.15 JMINI4.53 ; v3(262.86,65.62) 262.91,65.57 262.91,64.15 262.57,63.8 JMINI1.4 ; C552.2 C551.2 v3(259.94,58.48) ; CD5.2 155.88,78.37 v2(155.56,78.69) 155.47,78.61 CD8.2 ; JMINI3.34 v3(74.14,29.93) ; R90.1 187.16,32.5 187.53,32.87 187.53,33.85 187.3,34.07 v2(186.85,34.07) ; v3(179.32,145.38) 179.34,145.39 PC935.2 ; v3(276.2,79.06) 276.69,78.57 Q338.3 ; v3(251.43,56.22) 251.43,56.19 250.8,55.55 C782.2 ; v3(94.18,78.91) 94.64,78.45 94.65,78.45 CH38.2 ; C20.2 R53.2 v3(82.93,161.74) ; CD54.2 v3(164.06,43.75) ; v2(100.06,160.1) 100.06,160.32 Q22.3 ; v3(99.45,32.85) 99.93,33.33 PR405.2 ; RH230.2 60.91,75.76 v3(60.7,75.96) ; YH2.4 v3(96.21,73.47) ; v3(206.48,58.18) 205.09,56.79 C5.2 ; C628.2 v3(266.55,22.26) ; v3(221.37,53.89) 221.37,53.26 PC1081.1 ; JMINI3.9 v3(87.34,21.76) ; v3(259.87,54.95) 259.92,55 JMINI1.18 ; C287.2 v3(42.59,100.24) ; PC2.2 v3(49.19,104.85) ; v3(81.02,51.16) 81.02,51.54 80.71,51.85 CH9.2 ; C45.2 259.23,61.41 v3(259.82,61.99) 259.82,61.99 C48.2 ; PC214.2 v3(153.31,27.54) ; C748.2 v3(292.96,110.66) ; JSIM1.18 v3(270.19,20.18) ; JMINI2.26 v3(123.89,161.23) ; Q318.4 v3(292.9,107.65) ; v3(52.65,100.98) 53.21,100.42 53.21,98.95 52.84,98.57 JRTC1.2 ; JMINI4.4 10.84,150.45 v3(11.38,150.99) ; C22.2 v3(91.41,161.1) ; CD72.2 160.63,44.69 160.63,43.5 161.14,42.99 v3(161.52,42.99) ; v3(246.61,36.69) C735.2 R836.2 ; v3(205.69,50.18) 204.72,50.18 C404.2 ; R840.2 2.04,152.13 v3(2.16,152.25) ; v3(220.27,60.57) 220.32,60.52 220.78,60.52 PC1080.1 ; v3(230.22,24.65) 229.72,25.15 PC786.2 ; R733.2 v3(53.57,14.42) ; v3(117.73,70.83) 118.16,70.83 CD37.2 ; v3(264.13,20.03) 264.14,20.03 JSIM1.5 ; v3(214.1,19.24) 215.31,19.24 PC717.2 ; PC728.2 PC727.2 227.3,20.33 v3(226.8,20.33) ; v3(158.57,79.39) 159.1,78.86 CD9.2 ; v3(115.39,46.88) 114.83,47.44 JSPI1.22 ; CD50.2 v3(161.52,43.75) ; C479.2 55.35,143.64 v3(55.44,143.55) ; C462.2 111.15,85.04 v3(111.15,84.7) ; PR1028.2 v3(254.89,32.7) ; v3(56.36,93.97) 56.36,94.32 54.79,95.89 JRTC1.3 ; v3(23.34,78.3) 23.29,78.35 PC11.2 21.87,79.01 PD8.2 ; RH231.2 58.98,71.21 v3(58.22,71.21) ; C701.2 113.33,131.97 113.46,132.09 113.47,132.09 v3(113.49,132.08) ; PR745.2 236.65,17.18 v3(236.57,17.11) ; PR745.2 PC730.2 ; CD75.2 153.39,44.26 v3(153.9,43.75) ; PR207.1 v3(154.43,26.27) ; v3(120.74,161.2) 120.72,161.2 120.69,161.18 JMINI2.18 ; JMINI4.21 20.84,156.8 v3(20.32,156.27) ; v3(89.71,103.06) 90.09,102.68 C1181.2 ; v3(241.54,19.9) 241.24,19.6 PQ1083.6 ; v3(262.99,51.6) 262.79,51.8 JMINI1.26 ; JMINI1.35 v3(271.12,48.2) ; JMINI3.26 v3(77.34,29.93) ; C467.2 110.34,93.41 v3(110.59,93.16) ; v3(187.81,42.99) 188.85,41.95 JDIMM3.206 ; v3(273.77,48.62) 273.4,48.25 C613.2 274.16,47.82 274.42,48.07 v3(274.42,48.58) ; JMINI1.34 v3(260.05,48.6) ; JMINI4.15 15.24,157.26 v3(16.18,156.32) ; CD69.2 v3(156.06,43.75) ; R88.2 v3(185.39,40.63) ; v3(107.77,161.94) 107.67,162.04 R1139.2 ; v3(74.29,85.66) 74.4,85.77 CH52.2 ; C406.2 C395.2 205.18,60.01 v3(205.38,60.21) ; JMINI3.21 v3(79.34,21.74) ; R101.1 v3(130.81,141.29) ; C639.2 v3(71.22,16.27) ; C718.2 v3(228.5,71.06) ; C1352.2 v3(235.18,37.81) 235.18,38.19 235.46,38.47 C734.2 ; v3(238.68,81.19) 238.61,81.12 R803.2 ; v3(249.44,18.24) 249.42,18.27 PQ1011.3 ; RH116.1 91.17,61.91 v3(91.85,61.91) ; C420.2 v3(181.96,30.09) ; C1341.2 v3(289.15,58.48) ; v3(121.79,152.08) 122.55,151.32 C112.2 ; C704.2 v3(112.88,114.97) ; R720.2 v3(274.5,36.51) ; JMINI3.18 v3(80.54,29.93) ; C486.2 v3(46.46,143.57) ; R87.2 v3(184.38,40.63) ; R55.2 v3(91.41,161.99) ; JMINI1.21 v3(271.23,53.8) ; R108.1 v3(274.67,70.12) ; CD67.2 CD68.2 190.73,45.45 v3(191.03,45.76) ; v3(112.93,90.62) 113.1,90.44 C469.2 C463.2 ; PR1031.1 v3(244.63,29.66) ; PR748.2 v3(226.8,16.7) ; CD3.2 162.09,78.31 v2(162.09,78.79) ; PC731.2 v3(229.89,15.71) ; R103.1 v3(270.1,77.84) ; RC75.2 v3(166.85,152.72) 167.56,152.01 QC6.3 ; JMINI1.15 v3(271.24,59.4) ; v3(30.71,119.39) 30.25,118.94 C494.2 ; C714.2 v3(228.07,69.03) ; JFAN2.5 v3(10.2,89.99) ; JSIM1.11 260.08,20.04 v3(259.84,20.28) ; C634.2 66.25,31.64 C633.2 65.75,32.13 v3(63.98,30.37) ; C541.2 v3(271.68,41.14) ; CD38.2 v3(117.7,70.04) ; v3(262.74,20.05) JSIM1.10 ; JMINI3.15 v3(84.94,21.76) ; C793.2 v3(292.33,112.15) ; PC735.2 v3(226.64,19.5) ; JMINI2.35 v3(127.49,169.42) ; v3(129.89,172.23) C607.1 ; Q55.3 v3(292.47,62.31) ; JMINI3.4 v3(89.34,29.93) ; v3(243.36,59.58) 243.36,59.93 243.18,60.11 C708.2 R804.2 ; C617.2 v3(28.04,161.48) ; YH2.2 v3(96.22,75.07) ; C298.2 91.17,157.56 91.34,157.72 v3(91.34,157.98) ; R107.1 v3(271.12,77.84) ; JMINI3.53 v3(64.09,22.94) ; C495.2 v3(27.51,123.89) ; C542.2 v3(13.84,147.08) ; v3(40.59,86.22) 40.26,85.89 40.26,85.54 CH2.2 ; R81.2 v3(277.7,70.55) ; JMINI2.53 v3(137.14,169.73) ; Q29.1 204.97,62.61 205.81,63.46 v3(205.81,63.51) ; C499.2 v3(38.51,111.54) ; C753.2 v3(293.98,110.66) ; C618.2 v3(29.64,160.8) ; v3(102.34,64.83) CE1.2 ; R904.2 v3(294.99,110.66) ; C638.1 v3(91.92,33.54) ; PC1005.2 v3(193.74,23.24) ; C754.2 v3(296.01,110.66) ; C624.2 v3(72.11,16.31) ; C403.2 v3(205.69,51.12) ; JDEG2.12 v3(277.79,30.67) ; U49.9 v3(12.1,143.57) ; C726.2 v3(106.7,163.82) ; R89.2 v3(184.89,34.1) ; R104.1 v3(273.66,70.12) ; RH227.2 v3(60.68,72.45) ; JMINI3.43 v3(70.54,21.74) ; JMINI3.35 v3(73.74,21.74) ; R106.1 v3(272.64,70.12)
  vias: v2(5.4,144.34) v2(5.88,143.92) v2(16.41,160.49) v2(18.06,99.3) v2(22.63,96.58) v2(25.14,93.41) v2(25.98,91.96) v2(26.16,94.37) v2(27.3,162.29) v2(28.32,94.15) v2(35.58,111.87) v2(37.74,151.27) v2(37.84,154.5) v2(37.84,153.25) v2(38.35,156.6) v2(40.84,165.32) v2(41.17,110.55) v2(42.85,117.77) v2(42.85,115.86) v2(42.85,113.96) v2(42.98,125.16) v2(43,123.28) v2(43,121.37) v2(43.37,113.69) v2(43.86,119.98) v2(45.69,142.89) v2(49.5,117.26) v2(51,150.74) v2(52.78,150.74) v2(54.56,150.74) v2(55.75,112.87) v2(55.85,140.09) v2(56.34,150.74) v2(56.82,139.41) v2(58.11,150.74) v2(58.75,109) v2(58.98,141.87) v2(59.16,139.71) v2(59.89,150.74) v2(60.2,142.13) v2(61.67,150.74) v2(62.99,140.73) v2(63.3,138.32) v2(63.45,150.74) v2(65.23,150.74) v2(66.39,138.32) v2(66.83,76.24) v2(67,150.74) v2(67.31,58.23) v2(67.77,77.41) v2(67.97,141.04) v2(68.78,150.74) v2(69.11,79.36) v2(69.16,130.39) v2(69.21,61.45) v2(69.49,138.32) v2(70.59,150.74) v2(70.71,71.49) v2(70.76,59.83) v2(71.07,141.04) v2(71.27,78.4) v2(71.27,70.47) v2(72.34,150.74) v2(72.29,85.26) v2(72.41,75.6) v2(73.18,89.04) v2(73.33,87.8) v2(73.56,59.96) v2(73.91,79.34) v2(74.12,150.74) v2(74.78,81.9) v2(75.49,80.81) v2(75.89,150.74) v2(76.1,141.04) v2(76.22,79.97) v2(76.33,62.5) v2(76.33,61.89) v2(76.96,141.04) v2(77.34,59.8) v2(77.67,150.74) v2(77.92,61.86) v2(78.31,94.5) v2(78.9,61.86) v2(79.55,81.01) v2(79.55,79.26) v2(79.88,61.86) v2(81.86,59.96) v2(83.06,37.81) v2(83.62,38.29) v2(83.82,55.44) v2(84.15,55.92) v2(84.89,72.45) v2(85.01,80.3) v2(85.52,141.11) v2(86.94,37.96) v2(88.64,78.12) v2(92.4,86.7) v2(93.62,87.26) v2(94.79,87.59) v2(94.77,68.26) v2(96.93,86.78) v2(96.95,85.66) v2(97.56,124.57) v2(98.22,124.24) v2(98.75,81.55) v2(99.8,120.61) v2(100.02,123.1) v2(101.52,121.81) v2(103.48,123.71) v2(103.45,121.78) v2(103.66,141.87) v2(104.65,63.69) v2(105,141.85) v2(105.07,19.62) v2(105.7,19.62) v2(106.5,141.82) v2(107.85,141.9) v2(108.85,109.96) v2(111.47,109.21) v2(113.13,87.36) v2(113.25,108.55) v2(114.27,106.21) v2(123.8,170.65) v2(127.32,55.31) v2(127.32,53.78) v2(127.33,52.26) v2(128.34,67.96) v2(128.34,66.43) v2(129.27,55.08) v2(129.27,52.79) v2(129.87,67.58) v2(130.45,61.16) v2(130.45,60.53) v2(130.73,55.36) v2(130.73,53.89) v2(132.48,62.66) v2(132.69,55.41) v2(132.7,54.14) v2(132.7,52.87) v2(133.7,68.53) v2(133.68,60.44) v2(134.57,54.9) v2(134.56,52.83) v2(135.92,55.37) v2(135.92,54.1) v2(135.92,52.83) v2(136.61,60.47) v2(136.7,68.53) v2(137.79,108.06) v2(138.07,55.49) v2(138.07,54.22) v2(138.06,52.95) v2(138.43,109.54) v2(138.52,60.67) v2(138.51,59.93) v2(139.6,54.85) v2(139.83,110.91) v2(140.95,55.41) v2(140.95,54.14) v2(143.05,61.08) v2(143.06,60.42) v2(143.05,59.79) v2(143.3,55.28) v2(143.3,53.76) v2(144.02,69.21) v2(144.25,87) v2(144.33,56.42) v2(144.33,54.89) v2(144.42,88.98) v2(144.67,87.4) v2(144.84,89.41) v2(145.07,87.84) v2(145.25,89.82) v2(145.32,54.33) v2(145.32,52.03) v2(145.52,88.27) v2(145.54,60.17) v2(145.68,90.25) v2(146.6,55.42) v2(146.6,54.15) v2(146.6,52.76) v2(164.06,122.31) v2(164.06,121.31) v2(167.08,109.3) v2(168.44,122.24) v2(168.66,119.71) v2(168.87,120.57) v2(169.01,125.73) v2(169.04,124) v2(169.28,119.61) v2(169.45,123) v2(169.44,122.09) v2(169.47,118.05) v2(170.03,127.51) v2(170.01,55.5) v2(170.01,54.11) v2(170.01,52.58) v2(170.06,132.31) v2(170.06,119.48) v2(170.06,115.31) v2(170.79,125.73) v2(170.79,121.86) v2(170.84,124.04) v2(170.9,120.63) v2(171,119.76) v2(171.06,115.28) v2(171.17,123) v2(171.44,118.05) v2(171.91,165.93) v2(171.99,127.51) v2(172.06,115.31) v2(172.19,119.63) v2(172.28,66.52) v2(172.44,124.02) v2(172.38,121.03) v2(172.57,125.73) v2(172.63,121.86) v2(172.82,122.94) v2(173.04,115.28) v2(173.06,54.97) v2(173.06,53.7) v2(173.06,52.43) v2(173.18,62.68) v2(173.39,120.59) v2(173.54,118.05) v2(174.03,127.51) v2(174.03,122.78) v2(174.03,121.83) v2(174.09,119.89) v2(174.06,115.31) v2(174.28,124.08) v2(174.34,125.73) v2(174.99,55.12) v2(174.99,53.85) v2(174.99,52.58) v2(175.11,134.33) v2(175.06,115.29) v2(175.5,118.05) v2(175.98,124.07) v2(176.06,127.51) v2(176.12,125.73) v2(176.04,119.89) v2(176.06,115.31) v2(176.06,114.31) v2(176.86,55.48) v2(176.86,53.32) v2(177.05,115.28) v2(177.06,37.3) v2(177.35,122.79) v2(177.35,121.78) v2(177.35,120.76) v2(177.38,68.46) v2(177.34,66.87) v2(177.66,118.05) v2(177.76,119.87) v2(177.96,125.73) v2(178.01,124.07) v2(178.09,127.51) v2(178.08,122.35) v2(178.08,121.27) v2(178.09,120.59) v2(178.06,115.31) v2(178.38,60.91) v2(178.39,55.23) v2(178.39,53.83) v2(178.39,52.56) v2(178.9,122.73) v2(178.92,119.89) v2(179.07,115.28) v2(179.23,121.41) v2(179.31,118.05) v2(179.68,124.08) v2(179.81,125.73) v2(180.04,106.35) v2(180.06,127.51) v2(180.11,119.89) v2(180.06,115.31) v2(180.06,114.31) v2(180.06,107.32) v2(180.38,123.06) v2(180.38,121.41) v2(180.51,55.33) v2(180.51,54.06) v2(180.51,52.79) v2(181.03,118.05) v2(181.06,115.31) v2(181.19,119.81) v2(182.03,127.45) v2(182.14,119.89) v2(182.06,115.31) v2(182.24,55.62) v2(182.24,53.46) v2(182.9,119.87) v2(182.93,118.05) v2(182.98,81.19) v2(183.12,115.25) v2(183.06,114.31) v2(183.36,125.79) v2(183.36,124.14) v2(183.41,81.64) v2(183.56,55.29) v2(183.56,54.02) v2(183.56,52.75) v2(183.74,123.13) v2(183.74,121.6) v2(183.79,120.09) v2(183.8,82.07) v2(183.87,60.16) v2(184.06,127.51) v2(184.07,115.28) v2(184.23,82.46) v2(184.43,165.95) v2(184.68,120.19) v2(184.65,118.05) v2(185.14,125.79) v2(185.14,123) v2(185.13,121.01) v2(185.06,115.31) v2(185.2,124.14) v2(185.7,120.17) v2(185.82,52.82) v2(185.85,55.87) v2(185.86,54.34) v2(186.03,127.51) v2(185.95,60.16) v2(186.06,115.31) v2(186.49,118.05) v2(186.54,60.72) v2(186.8,79.31) v2(186.92,125.79) v2(186.92,124.14) v2(186.84,120.13) v2(187.11,122.56) v2(187.06,115.31) v2(187.19,79.75) v2(187.18,55.11) v2(187.6,80.17) v2(187.98,120.13) v2(188.03,80.6) v2(188.06,127.51) v2(188.06,115.31) v2(188.09,62.24) v2(188.33,117.98) v2(188.63,122.62) v2(188.54,66.05) v2(188.7,125.79) v2(188.7,124.21) v2(189.08,115.28) v2(189.11,55.87) v2(189.11,54.34) v2(189.11,52.82) v2(189.19,120.13) v2(189.23,119.46) v2(189.35,116.59) v2(189.71,127.51) v2(189.7,123.34) v2(190.2,124.07) v2(192.45,163.18) v2(196.88,146.61) v2(196.89,145.99) v2(279.63,82.74) v2(280.19,81.19) v2(282.88,81.75) v2(284.89,81.78) v2(286.66,81.75) v2(288.34,83.12) v2(292.91,102.48) v2(297.92,115.13) v3(0.52,161.12) v3(0.51,156.05) v3(0.51,150.97) v3(0.51,145.89) v3(0.51,140.81) v3(0.51,135.73) v3(0.51,130.65) v3(0.51,125.57) v3(0.51,120.49) v3(0.51,115.41) v3(0.51,110.33) v3(0.51,105.25) v3(0.51,91.4) v3(0.51,86.32) v3(0.51,81.24) v3(0.51,76.16) v3(0.51,71.08) v3(0.51,66) v3(0.51,60.92) v3(0.66,166.74) v3(1.01,171.41) v3(1.24,161.95) v3(1.9,56.71) v3(2.18,164.14) v3(2.56,178.68) v3(2.64,174.05) v3(2.67,160.16) v3(3.78,175.83) v3(4.16,168.59) v3(4.44,164.22) v3(4.61,140.23) v3(4.55,131.01) v3(4.67,127.44) v3(4.82,160.41) v3(4.81,129.72) v3(4.89,176.9) v3(5.03,148.76) v3(5.05,174.05) v3(5.05,150.06) v3(5.24,140.23) v3(5.71,162.45) v3(5.69,149.42) v3(5.74,101.46) v3(5.75,96.38) v3(5.94,171.01) v3(6.34,148.77) v3(6.96,168.21) v3(6.98,56.71) v3(7.72,166.31) v3(8.01,173.56) v3(7.97,129.22) v3(9.14,127.22) v3(10.11,62.32) v3(10.39,166.18) v3(10.41,61.74) v3(10.6,65.55) v3(10.74,66.29) v3(10.74,62.34) v3(11.1,61.79) v3(11.15,168.21) v3(11.28,125.08) v3(11.45,62.4) v3(11.91,66.49) v3(12.04,144.65) v3(12.06,56.71) v3(13.18,173.68) v3(15.09,153.84) v3(15.39,104.42) v3(16.48,99.17) v3(16.81,95.54) v3(17.12,56.74) v3(17.73,174.31) v3(18.01,93.89) v3(18.03,79.16) v3(18.13,162.5) v3(18.13,161.86) v3(19.18,178.68) v3(20.17,173.55) v3(20.7,67.96) v3(20.67,64.28) v3(20.67,63.56) v3(20.67,62.93) v3(20.93,100.07) v3(20.88,97.93) v3(20.86,96.28) v3(21.31,63.56) v3(21.31,62.93) v3(21.39,62.29) v3(21.94,63.56) v3(21.94,62.93) v3(22.02,62.27) v3(22.15,101.92) v3(22.15,64.25) v3(22.22,56.71) v3(22.5,42.63) v3(22.5,37.55) v3(22.5,32.47) v3(22.5,27.39) v3(22.5,22.31) v3(22.58,176.47) v3(22.6,63.59) v3(22.6,62.95) v3(22.71,170.37) v3(22.68,62.29) v3(23.21,66.59) v3(23.21,65.22) v3(23.34,173.7) v3(23.52,85.31) v3(23.85,66.59) v3(23.85,65.22) v3(23.93,18.4) v3(24.1,52.77) v3(24.1,47.69) v3(24.13,13.42) v3(24.17,8.45) v3(24.26,178.68) v3(24.43,155.66) v3(24.81,85.31) v3(26.77,166.94) v3(27.28,156.15) v3(27.28,154.24) v3(27.28,152.21) v3(27.79,120.28) v3(27.91,171.77) v3(28.07,51.16) v3(28.07,48.81) v3(28.29,15.94) v3(28.37,178.17) v3(28.8,156.15) v3(28.8,154.24) v3(28.8,152.21) v3(29.03,5.45) v3(29.08,167.4) v3(29.07,33.2) v3(29.04,32.4) v3(29.18,25.59) v3(29.18,17.97) v3(29.39,173.77) v3(29.56,14.16) v3(29.69,26.86) v3(29.69,26.23) v3(30.33,154.24) v3(30.33,152.21) v3(31.22,75.12) v3(31.39,119.39) v3(31.34,18.23) v3(31.47,171.64) v3(31.44,121.48) v3(31.72,146.62) v3(31.72,77.66) v3(31.72,14.42) v3(31.92,0.57) v3(32.61,16.45) v3(32.76,50.33) v3(33.09,49.77) v3(33.2,50.86) v3(33.15,32.79) v3(33.15,32.16) v3(33.15,31.52) v3(33.15,30.89) v3(33.25,73.34) v3(33.5,94.43) v3(33.5,93.03) v3(33.5,91.63) v3(33.78,32.79) v3(33.78,32.16) v3(33.78,31.52) v3(33.78,30.89) v3(34.26,78.42) v3(34.42,32.79) v3(34.42,32.16) v3(34.42,31.52) v3(34.42,30.89) v3(34.52,171.9) v3(34.9,122.49) v3(34.9,120.84) v3(34.9,119.19) v3(34.9,117.54) v3(34.9,94.43) v3(35.2,10.53) v3(35.28,50.23) v3(35.41,38.49) v3(35.41,37.45) v3(35.46,174.05) v3(35.48,50.84) v3(35.66,74.11) v3(35.79,49.82) v3(35.91,123.25) v3(35.91,121.6) v3(35.91,120.08) v3(35.91,118.43) v3(35.91,116.9) v3(36.04,178.32) v3(36.07,50.43) v3(36.17,76.65) v3(36.3,94.43) v3(36.3,93.03) v3(36.43,38.49) v3(36.5,132.68) v3(36.47,37.43) v3(36.73,49.7) v3(36.8,64.83) v3(36.85,133.97) v3(36.85,133.34) v3(36.93,122.49) v3(36.93,120.84) v3(36.93,119.19) v3(36.93,117.54) v3(37.08,132.3) v3(37.08,1.33) v3(37.62,53.68) v3(37.62,53.05) v3(38.05,65.32) v3(38.3,53.68) v3(38.3,53.05) v3(38.58,64.86) v3(39.06,53.68) v3(39.06,53.05) v3(39.13,27.68) v3(39.13,27.05) v3(39.13,26.41) v3(39.13,25.78) v3(39.62,135.14) v3(39.78,53.66) v3(39.78,53.02) v3(39.75,5.53) v3(39.85,129.1) v3(40.26,135.14) v3(40.44,53.02) v3(40.99,178.68) v3(41.21,162.66) v3(41.27,66.36) v3(41.38,38.72) v3(41.4,38.09) v3(41.86,162.65) v3(42.21,175.1) v3(42.46,49.27) v3(42.52,48.58) v3(42.62,91.4) v3(42.9,41.09) v3(42.9,40.45) v3(43.15,49.21) v3(43.15,48.58) v3(43.41,168.72) v3(43.69,90.95) v3(43.66,41.09) v3(43.66,40.45) v3(43.79,172.78) v3(44.51,131.47) v3(44.51,130.79) v3(44.5,65.39) v3(44.83,5.53) v3(45.82,170.63) v3(45.87,91) v3(47.24,174.94) v3(47.4,89.68) v3(48.18,172.4) v3(49.91,5.53) v3(51.15,84.6) v3(51.28,74.77) v3(52.04,11.24) v3(54.99,5.53) v3(56.11,85.08) v3(56.08,83.58) v3(56.23,16.57) v3(57.48,142.76) v3(57.55,103.8) v3(60.07,5.53) v3(60.81,16.07) v3(60.93,14.8) v3(61.19,16.7) v3(61.31,17.84) v3(61.44,11.24) v3(61.57,14.8) v3(61.7,16.07) v3(61.95,17.84) v3(62.97,56.45) v3(63.4,172.81) v3(63.98,56.45) v3(64.62,90.31) v3(64.72,85.84) v3(65.15,5.53) v3(65.35,174.94) v3(65.61,171.63) v3(65.76,157.04) v3(65.76,156.4) v3(65.76,155.77) v3(65.76,155.13) v3(65.89,89.19) v3(66.01,172.91) v3(67.16,168.97) v3(67.16,166.94) v3(68.05,174.1) v3(69.16,40.83) v3(69.44,170.24) v3(69.44,165.16) v3(69.82,172.66) v3(69.8,40.83) v3(70.23,5.53) v3(70.43,174.94) v3(71.73,169.23) v3(71.73,166.43) v3(71.86,157.93) v3(72.24,11.49) v3(72.49,156.78) v3(72.62,159.07) v3(73.76,156.78) v3(73.89,158.94) v3(74.52,157.8) v3(75.03,170.24) v3(75.31,5.53) v3(75.51,174.94) v3(75.51,40.7) v3(76.15,40.7) v3(76.55,172.02) v3(77.82,158.69) v3(77.95,157.04) v3(78.36,167.4) v3(79.09,169.48) v3(79.45,84.67) v3(79.63,165.62) v3(80.39,5.53) v3(80.59,174.94) v3(81,150.81) v3(81.41,169.69) v3(81.79,165.88) v3(82.29,110.55) v3(82.52,150.81) v3(82.52,149.16) v3(82.52,147.51) v3(82.68,167.91) v3(82.78,10.73) v3(84.17,149.16) v3(84.17,147.51) v3(84.15,110.55) v3(85.47,5.53) v3(85.67,174.94) v3(86.05,110.55) v3(86.16,120.05) v3(86.87,62.14) v3(87.35,121.53) v3(87.43,61.79) v3(87.96,110.58) v3(88.07,121.41) v3(88.8,123.18) v3(90.55,5.53) v3(90.75,174.94) v3(92.18,150.43) v3(92.18,148.78) v3(93.19,172.28) v3(93.7,152.08) v3(93.7,150.43) v3(93.7,148.78) v3(94.18,82.41) v3(94.33,106.91) v3(94.33,105.47) v3(95.63,5.53) v3(95.73,171.77) v3(95.73,106.85) v3(95.73,105.47) v3(95.73,104.2) v3(95.83,174.94) v3(96.46,148.78) v3(96.8,153.07) v3(97.03,106.9) v3(97.13,105.47) v3(97.13,104.18) v3(97.05,53.58) v3(97.51,155.16) v3(97.92,150.84) v3(97.97,154.66) v3(98.02,54.85) v3(100.05,163.13) v3(100.74,49.09) v3(100.71,5.53) v3(100.91,174.94) v3(101.37,49.09) v3(101.75,39.24) v3(102.03,49.09) v3(102.67,49.09) v3(103.48,157.93) v3(103.87,31.6) v3(103.9,30.76) v3(104.11,156.78) v3(104.24,159.07) v3(104.76,31.59) v3(104.79,30.75) v3(105.21,176.69) v3(105.38,156.78) v3(105.51,158.94) v3(105.64,31.56) v3(105.68,30.73) v3(105.79,5.53) v3(105.94,86.91) v3(106.15,157.8) v3(106.27,75.12) v3(106.51,24.98) v3(106.78,77.66) v3(107.15,24.98) v3(107.29,29.53) v3(107.78,24.98) v3(108.05,102.81) v3(108.05,29.53) v3(108.3,73.34) v3(108.42,24.98) v3(108.58,160.3) v3(108.84,8.29) v3(109.07,171.9) v3(109.32,78.42) v3(109.7,102.81) v3(110.29,176.69) v3(110.59,91.89) v3(110.64,90.62) v3(110.72,74.11) v3(111.17,161.2) v3(111.23,102.81) v3(111.23,76.65) v3(111.73,93.16) v3(111.73,91.89) v3(111.78,90.62) v3(112.62,161.2) v3(112.88,102.81) v3(113.56,8.73) v3(113.77,12) v3(113.93,158.09) v3(114.23,38.74) v3(114.4,102.81) v3(114.65,14.03) v3(114.91,38.75) v3(115.04,10.22) v3(115.29,76.9) v3(115.37,176.69) v3(116.18,78.93) v3(116.17,47.94) v3(116.56,75.12) v3(116.81,14.29) v3(116.91,52.49) v3(117.07,154.55) v3(117.19,65.29) v3(117.17,62.75) v3(117.19,10.48) v3(117.3,38.75) v3(117.58,52.49) v3(117.7,64.81) v3(117.68,62.34) v3(117.75,64.07) v3(118.08,12.51) v3(118.34,79.19) v3(118.72,75.38) v3(118.77,8.73) v3(119.07,36.36) v3(119.26,155.02) v3(119.73,77.41) v3(120.45,176.69) v3(120.56,157.86) v3(120.78,7.4) v3(121.79,5.53) v3(121.87,9.41) v3(122.27,146.75) v3(122.27,145.1) v3(122.27,143.45) v3(123.32,172.58) v3(123.93,146.75) v3(123.93,145.1) v3(123.93,143.45) v3(124.38,111.44) v3(124.38,110.81) v3(124.38,9.61) v3(124.87,5.53) v3(125.04,157.52) v3(125.68,176.69) v3(125.73,7.61) v3(128.14,9.74) v3(130.76,176.69) v3(133.2,9.89) v3(135.36,157.93) v3(135.84,176.69) v3(135.99,156.78) v3(136.12,159.07) v3(137.26,156.78) v3(137.39,158.94) v3(138.02,157.8) v3(138.17,10.83) v3(138.78,21.78) v3(138.78,21.02) v3(139.42,21.78) v3(139.42,21.02) v3(139.42,20.38) v3(139.53,145.75) v3(140.18,21.78) v3(140.18,21.02) v3(140.18,20.38) v3(140.42,147.78) v3(140.8,143.97) v3(140.92,176.69) v3(141.2,21.78) v3(141.2,21.02) v3(141.2,20.38) v3(141.83,21.78) v3(141.83,21.02) v3(141.83,20.38) v3(142.58,148.03) v3(142.59,20.38) v3(142.72,22.16) v3(142.72,21.53) v3(142.96,144.22) v3(143.23,20.38) v3(143.25,10.83) v3(143.61,22.16) v3(143.85,146.25) v3(144.68,97.88) v3(144.78,98.51) v3(144.85,99.15) v3(145.41,98.57) v3(146,176.69) v3(148.33,10.83) v3(149.24,19.48) v3(149.5,23) v3(149.45,22) v3(149.47,20.09) v3(150.01,27.5) v3(150.42,22) v3(150.49,22.95) v3(151.08,176.69) v3(153.41,10.83) v3(155.42,169.86) v3(155.42,168.59) v3(156.16,176.69) v3(156.18,169.1) v3(156.95,169.86) v3(156.95,168.34) v3(157.89,47.31) v3(158.49,10.83) v3(161.24,176.69) v3(163.57,10.83) v3(166.32,176.69) v3(168.07,162.67) v3(168.45,161.91) v3(168.45,160.01) v3(168.65,10.83) v3(168.83,162.67) v3(169.47,161.91) v3(169.47,160.01) v3(169.72,162.67) v3(170.48,162.67) v3(170.48,161.91) v3(170.48,160.01) v3(171.37,176.69) v3(171.5,162.67) v3(171.5,161.91) v3(171.5,160.01) v3(171.93,173.42) v3(171.93,172.66) v3(172.74,163.61) v3(173.73,10.83) v3(174.22,162.62) v3(174.6,161.86) v3(174.6,159.96) v3(174.73,173.42) v3(174.73,172.66) v3(174.8,152.85) v3(174.98,162.62) v3(175.61,161.86) v3(175.61,159.96) v3(175.87,162.62) v3(176,153.78) v3(176.4,154.42) v3(176.48,176.69) v3(176.63,162.62) v3(176.63,161.86) v3(176.63,159.96) v3(176.91,153.73) v3(177.34,152.85) v3(177.65,162.62) v3(177.65,161.86) v3(177.65,159.96) v3(177.82,154.37) v3(178.36,153.76) v3(178.81,10.83) v3(179.02,164.02) v3(178.99,154.42) v3(179.04,173.55) v3(179.04,172.78) v3(179.6,153.71) v3(179.81,140.65) v3(180.29,152.85) v3(180.44,162.7) v3(180.36,154.42) v3(180.57,141.8) v3(180.57,7.33) v3(180.82,161.94) v3(180.82,160.03) v3(180.75,2.17) v3(180.95,153.73) v3(181.2,162.7) v3(181.56,176.69) v3(181.61,154.42) v3(181.84,173.53) v3(181.84,172.77) v3(181.84,161.94) v3(181.84,160.03) v3(182.09,162.7) v3(182.05,140.64) v3(182.47,6.67) v3(182.81,141.78) v3(182.85,162.7) v3(182.85,161.94) v3(182.85,160.03) v3(183.13,36.54) v3(183.16,37.99) v3(183.87,162.7) v3(183.87,161.94) v3(183.87,160.03) v3(183.87,37.28) v3(184.2,140.64) v3(184.38,4) v3(184.61,38.01) v3(184.6,36.55) v3(184.91,152.74) v3(184.97,141.78) v3(185.22,164.12) v3(185.24,153.76) v3(185.65,154.5) v3(186.1,153.73) v3(186.11,140.64) v3(186.28,173.55) v3(186.28,172.78) v3(186.46,162.67) v3(186.64,176.69) v3(186.61,154.5) v3(186.84,161.91) v3(186.84,160.01) v3(186.87,141.78) v3(187.22,162.67) v3(187.17,0.73) v3(187.3,153.68) v3(187.43,152.79) v3(187.86,161.91) v3(187.86,160.01) v3(187.88,154.47) v3(188.11,162.67) v3(188.14,140.64) v3(188.44,153.71) v3(188.82,173.55) v3(188.82,172.78) v3(188.87,162.67) v3(188.87,161.91) v3(188.87,160.01) v3(188.9,141.78) v3(189.03,154.47) v3(189.58,153.68) v3(189.89,162.67) v3(189.89,161.91) v3(189.89,160.01) v3(190.14,154.42) v3(190.17,152.79) v3(190.22,140.65) v3(190.68,153.71) v3(190.98,141.8) v3(191.08,154.34) v3(191.72,176.69) v3(191.84,0.71) v3(193.13,168.95) v3(194.02,170.98) v3(194.4,167.17) v3(194.46,162.42) v3(194.84,161.66) v3(194.84,160.16) v3(195.22,162.42) v3(195.45,154.6) v3(195.73,153.84) v3(195.81,19.62) v3(195.81,18.99) v3(195.86,161.66) v3(195.86,160.16) v3(196.11,162.42) v3(196.18,171.23) v3(196.15,60.72) v3(196.19,25.72) v3(196.56,167.42) v3(196.8,176.69) v3(196.87,162.42) v3(196.87,161.66) v3(196.87,160.16) v3(196.92,0.71) v3(197.08,27.75) v3(197.45,169.45) v3(197.46,23.94) v3(197.89,162.42) v3(197.89,161.66) v3(197.89,160.16) v3(199.24,28) v3(199.62,24.19) v3(200.43,162.42) v3(200.52,160.95) v3(200.47,160.31) v3(200.59,174.09) v3(200.63,26.23) v3(200.75,169.47) v3(200.81,161.66) v3(201.19,162.42) v3(201.23,161.07) v3(201.14,160.39) v3(201.36,174.1) v3(201.48,169.47) v3(201.52,19.75) v3(201.52,19.11) v3(201.83,161.66) v3(201.88,176.69) v3(201.86,162.42) v3(202,0.71) v3(202.13,174.09) v3(202.16,19.75) v3(202.16,19.11) v3(202.79,19.75) v3(202.79,19.11) v3(202.87,174.1) v3(202.92,138.37) v3(202.92,137.73) v3(203.22,159.75) v3(203.62,138.29) v3(203.66,137.66) v3(203.86,162.42) v3(203.86,161.66) v3(203.86,159.75) v3(204.09,173.19) v3(204.27,137.99) v3(204.57,167.7) v3(206.96,176.69) v3(207.83,170.27) v3(207.83,165.19) v3(208.53,160.92) v3(211,171.72) v3(212.04,176.69) v3(212.77,2.1) v3(213.08,7.15) v3(213.33,90.23) v3(213.56,160.63) v3(213.82,173.9) v3(213.82,155.56) v3(213.82,150.48) v3(213.82,145.4) v3(213.82,140.32) v3(213.82,135.24) v3(213.82,130.16) v3(213.82,125.08) v3(213.82,120) v3(214.23,114.95) v3(214.22,92.27) v3(214.3,109.89) v3(214.6,88.46) v3(214.76,34.61) v3(216.03,105.17) v3(216.18,10.46) v3(216.38,92.52) v3(216.46,34.61) v3(216.61,26) v3(216.76,88.71) v3(217.12,34.61) v3(217.24,26.02) v3(217.65,90.74) v3(217.75,34.61) v3(217.88,26.02) v3(218.16,77.03) v3(218.16,15.3) v3(218.41,25.46) v3(218.41,24.83) v3(218.41,24.19) v3(218.54,17.72) v3(218.67,79.44) v3(218.74,26.02) v3(219.05,25.46) v3(219.05,24.83) v3(219.05,24.19) v3(219.4,100.93) v3(219.68,25.46) v3(219.68,24.83) v3(219.68,24.19) v3(220.06,75.38) v3(220.06,13.65) v3(220.32,25.46) v3(220.32,24.83) v3(221.08,80.2) v3(221.08,18.48) v3(221.26,10.46) v3(222.35,76.14) v3(222.35,14.42) v3(222.61,96.59) v3(222.86,78.55) v3(222.86,16.83) v3(226.24,92.9) v3(226.21,25.92) v3(226.34,10.46) v3(226.69,29.64) v3(226.76,28.47) v3(226.74,26.38) v3(227.2,63.59) v3(227.29,29.02) v3(227.84,63.59) v3(227.9,29.62) v3(227.87,28.46) v3(230.22,89.85) v3(231.42,10.46) v3(232.78,13.3) v3(234.62,87.36) v3(236.07,71.57) v3(236.07,69.41) v3(236.07,67.18) v3(236.5,10.46) v3(238.23,71.57) v3(238.23,69.41) v3(238.23,67.25) v3(238.86,34.86) v3(239.17,85.56) v3(240.38,71.57) v3(240.38,69.41) v3(240.38,67.25) v3(240.77,55.72) v3(240.89,48.32) v3(240.89,46.23) v3(240.89,44.01) v3(241.48,55.72) v3(241.58,10.46) v3(243.05,48.32) v3(243.05,46.17) v3(243.05,44.01) v3(244.22,84.32) v3(245.21,48.32) v3(245.21,46.17) v3(246.66,10.46) v3(249.27,83.81) v3(251.74,10.46) v3(254.33,84) v3(255.57,7.63) v3(256.79,3.47) v3(257.68,4.31) v3(259.23,84.87) v3(259.76,32.87) v3(259.76,31.18) v3(259.75,29.46) v3(261.47,32.87) v3(261.47,31.18) v3(262.58,57.04) v3(263.18,32.87) v3(263.18,31.18) v3(263.14,29.5) v3(263.46,72.19) v3(264.06,86.42) v3(264.35,3.47) v3(265.19,74.09) v3(266.01,62.47) v3(266.04,60.52) v3(268.43,65.7) v3(268.71,86.81) v3(269.43,3.47) v3(269.54,89.06) v3(269.98,85.15) v3(269.96,75.38) v3(269.96,74.49) v3(269.96,73.61) v3(270.86,75.38) v3(270.86,74.49) v3(270.86,73.61) v3(271.75,89.09) v3(271.77,75.38) v3(271.77,74.49) v3(271.77,73.61) v3(271.88,40.2) v3(272.13,85.28) v3(273.02,87.31) v3(273.12,61.25) v3(273.4,4.28) v3(273.53,92.04) v3(274.42,39.18) v3(274.5,3.47) v3(276.35,74.16) v3(277.25,95.54) v3(278.46,84.98) v3(279.53,84.98) v3(279.55,2.82) v3(280.32,6.07) v3(280.44,99.51) v3(280.97,66.84) v3(282.09,1.66) v3(282.17,100.6) v3(283.03,103.87) v3(282.95,66.84) v3(283.31,143.42) v3(283.3,138.94) v3(283.42,96.14) v3(283.62,8.5) v3(283.69,75.88) v3(283.69,74.36) v3(283.69,72.71) v3(283.74,133.34) v3(284.05,147.94) v3(284.06,103.81) v3(284.58,6.19) v3(284.86,66.84) v3(284.99,108.55) v3(285.22,75.88) v3(285.22,74.36) v3(285.22,72.71) v3(285.25,103.81) v3(285.62,128.61) v3(285.87,3.05) v3(286.31,113.48) v3(286.71,123.64) v3(286.74,75.88) v3(286.74,74.36) v3(286.74,72.71) v3(286.76,66.84) v3(286.92,118.58) v3(286.9,51) v3(286.9,50.11) v3(286.9,49.23) v3(287.76,94.81) v3(287.76,6.8) v3(288.52,149.92) v3(288.64,8.83) v3(288.75,66.84) v3(289.03,5.02) v3(289.79,159.93) v3(289.79,154.85) v3(290.56,66.84) v3(290.82,158.15) v3(290.8,9.08) v3(290.85,72.43) v3(291.21,160.8) v3(291.18,5.27) v3(292.07,7.3) v3(292.28,132.12) v3(292.77,156.81) v3(292.96,127.95) v3(293.62,163.13) v3(293.7,168.21) v3(293.91,173.1) v3(293.95,161.57) v3(294.36,169.48) v3(294.74,77.03) v3(294.74,15.3) v3(295.25,171.51) v3(295.25,79.44) v3(295.25,17.72) v3(295.43,157.27) v3(295.5,129.99) v3(295.63,167.7) v3(295.88,100.9) v3(295.94,159.89) v3(296.65,75.38) v3(296.65,13.65) v3(297.41,171.77) v3(297.66,80.2) v3(297.66,18.48) v3(297.79,167.96) v3(297.82,11.17) v3(297.92,128.21) v3(298.04,102.93) v3(298.04,62.04) v3(298.17,113.48) v3(298.68,169.99) v3(298.8,62.93) v3(298.93,76.14) v3(298.93,14.42) v3(299.13,173.17) v3(299.06,152.97) v3(299.39,158.64) v3(299.39,156.83) v3(299.44,78.55) v3(299.44,16.83) v3(299.57,100.52) v3(299.82,144.97) v3(299.82,138.11) v3(299.82,130.75) v3(299.95,147.89) v3(299.95,120.97) v3(300.07,116.52) v3(300.2,93.79) v3(300.33,140.91) v3(300.33,97.47) v3(300.46,135.07) v3(300.46,124.02) v3(301.09,149.92) v3(301.09,142.94) v3(301.34,128.84) v3(301.85,92.27) v3(302.11,116.14) v3(302.23,119.95) v3(302.49,140.02) v3(302.61,101.03) v3(302.61,96.58) v3(302.84,11.14) v3(303.12,132.04) v3(303.12,111.82) v3(303.18,172.35) v3(303.18,167.27) v3(303.34,86.81) v3(303.34,81.73) v3(303.34,76.65) v3(303.34,71.57) v3(303.34,66.49) v3(303.34,61.41) v3(303.34,56.33) v3(303.34,51.25) v3(303.34,46.17) v3(303.34,41.09) v3(303.34,36.01) v3(303.34,30.93) v3(303.34,25.85) v3(303.34,20.77) v3(303.34,15.69) v3(303.38,150.94) v3(303.38,147.13) v3(303.38,142.05) v3(303.38,104.84) v3(303.5,138.49) v3(303.63,123.89) v3(303.73,162.47) v3(305.34,157.09) v3(305.33,127.39) v3(305.33,122.31) v3(305.33,117.23) v3(305.33,112.15) v3(305.33,107.07) v3(305.33,101.99) v3(305.33,96.91) v3(305.33,91.83) v3(305.34,152.01) v3(305.34,146.93) v3(305.34,141.85) v3(305.34,136.77) v4(13.71,165.25) v4(22.74,172.5) v4(23.33,68.25) v4(23.82,63.6) v4(32.75,10.94) v4(34.91,7.56) v4(43.1,170.74) v4(45.39,171.96) v4(81.79,164.26) v4(83.45,169.42) v4(94.49,171.55) v4(144.19,99) v4(157.63,170.38) v4(163,169) v4(164.15,163.49) v4(173.21,161.28) v4(174.93,155.11) v4(185.06,160.99) v4(196.98,175.16) v4(204.04,160.76) v4(205.66,167.23) v4(271.31,5.49) v4(277.54,6.21) v4(279.03,20.63) v4(281.13,18.29) v4(285.29,146.63) v4(288.31,131.51) v4(288.81,148.58) v4(289.86,146.44) v4(290.61,128.79) v4(297.93,134.33) v4(297.86,71.45) v4(300.23,161.34)
