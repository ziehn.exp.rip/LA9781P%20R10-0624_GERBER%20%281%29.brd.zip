# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D0: length 87.4
  TOP w0.102: JCPU1.AR18 195.59,121.78 v2(196.06,121.31)
  TOP w0.14: v2(189.11,56.63) 188.68,56.63 188.04,57.27 JDIMM3.5
  IN3 w0.127: v2(189.11,56.63) 189.32,56.83 189.46,56.83 189.58,56.71 189.58,55.56 189.71,55.44 189.97,55.44 190.09,55.56 190.09,57.74 196.67,64.32 196.67,72.27 203.86,79.45 203.86,83.93 204.06,84.14 204.44,84.14 204.57,84.27 204.57,84.52 204.44,84.65 204.06,84.65 203.94,84.77 203.94,85.03 204.06,85.15 204.44,85.15 204.57,85.28 204.57,85.54 204.44,85.66 204.06,85.66 203.94,85.79 203.94,86.04 204.06,86.17 204.44,86.17 204.57,86.3 204.57,86.55 204.45,86.67 203.95,86.67 203.86,86.76 203.86,87.02 204.62,87.78 204.62,98.11 205.41,98.9 205.41,114.02 198.62,120.8 196.57,120.8 v2(196.06,121.31)
  BOTTOM w0.14: v2(189.11,56.63) 188.72,56.63 188.34,57.01 JDIMM4.4
DDR_B_D1: length 87.9
  TOP w0.102: JCPU1.AT18 196.59,121.78 v2(197.06,121.31)
  TOP w0.14: v2(189.11,55.11) 187.44,56.78 JDIMM3.7
  IN3 w0.127: v2(189.11,55.11) 189.55,54.67 190.09,54.67 190.45,55.03 190.45,57.62 197.07,64.25 197.07,72.19 204.32,79.44 204.32,82.61 204.44,82.74 204.82,82.74 204.95,82.87 204.95,83.12 204.83,83.25 204.44,83.25 204.32,83.38 204.32,83.63 204.44,83.76 204.82,83.76 204.95,83.89 204.95,97.97 205.79,98.8 205.79,114.11 198.59,121.31 v2(197.06,121.31)
  BOTTOM w0.14: v2(189.11,55.11) 189.09,55.11 188.59,55.6 188.59,55.87 187.74,56.72 JDIMM4.6
DDR_B_D2: length 92.6
  TOP w0.102: JCPU1.AM17 192.59,120.78 v2(193.06,120.31)
  TOP w0.14: v2(185.86,52.03) 184.74,50.91 JDIMM3.16
  IN3 w0.089: 197.51,116.45 197.24,116.72 196.85,116.72 196.49,117.07 196.49,117.44 196.19,117.74 194.73,117.74 194.46,118.01 194.46,118.47 194.23,118.71 193.82,118.71 193.49,119.04 193.49,119.6 193.06,120.03 v2(193.06,120.31)
  IN3 w0.127: v2(185.86,52.03) 185.09,52.81 185.09,57.07 187.18,59.16 187.18,59.54 189.97,62.33 190.43,62.33 191.84,63.74 191.84,63.92 191.67,64.1 191.49,64.1 190.19,62.8 190.01,62.8 189.86,62.96 189.86,63.14 193.7,66.98 193.7,73.48 201.03,80.81 201.03,88.24 201.79,89 201.79,99.44 202.61,100.26 202.61,112.89 199.35,116.15 197.8,116.15 197.51,116.45
  BOTTOM w0.14: JDIMM4.15 185.04,51.21 v2(185.86,52.03)
DDR_B_D3: length 93.5
  TOP w0.102: v2(193.06,121.31) 192.59,121.78 JCPU1.AM18
  TOP w0.14: JDIMM3.18 184.14,50.94 185.22,52.02 185.22,52.91 v2(185.86,53.56)
  IN3 w0.089: 197.38,116.91 196.93,116.91 196.68,117.15 196.68,117.52 196.27,117.93 194.81,117.93 194.65,118.09 194.65,118.55 194.3,118.9 193.9,118.9 193.68,119.12 193.68,119.69 193.49,119.88 193.49,120.87 v2(193.06,121.31)
  IN3 w0.127: 197.38,116.91 197.4,116.93 198.04,116.93 198.04,116.91 199.07,116.91 202.95,113.03 202.95,100.13 202.13,99.3 202.13,88.86 201.36,88.1 201.36,80.67 194.05,73.36 194.05,66.86 191.81,64.61 191.81,64.43 191.97,64.28 192.15,64.28 192.58,64.71 192.76,64.71 192.93,64.53 192.93,64.35 190.57,62 190.11,62 187.51,59.4 187.51,59.02 185.42,56.93 185.42,53.81 185.67,53.56 v2(185.86,53.56)
  BOTTOM w0.14: v2(185.86,53.56) 185.2,52.9 185.2,52.01 184.44,51.24 JDIMM4.17
DDR_B_D4: length 88.6
  TOP w0.102: JCPU1.AR17 195.59,120.78 v2(196.06,120.31)
  TOP w0.14: JDIMM3.4 188.34,51.28 v2(189.11,52.06)
  IN3 w0.127: v2(196.06,120.31) 196.44,120.31 196.98,119.77 198.7,119.77 204.71,113.77 204.71,99.24 203.95,98.47 203.95,88.06 203.19,87.3 203.19,79.9 195.93,72.64 195.93,64.54 188.28,56.88 188.28,53.85 187.68,53.25 187.68,53.02 187.81,52.9 188.19,52.9 188.31,52.77 188.31,52.52 188.19,52.39 187.81,52.39 187.68,52.26 187.68,52.01 187.81,51.88 188.99,51.88 189.11,52.01 v2(189.11,52.06)
  BOTTOM w0.14: JDIMM4.5 188.04,50.98 v2(189.11,52.06)
DDR_B_D5: length 88.7
  TOP w0.102: JCPU1.AT17 196.59,120.78 v2(197.06,120.31)
  TOP w0.14: v2(189.11,53.58) 188.29,52.76 188.29,51.96 187.74,51.41 JDIMM3.6
  IN3 w0.127: v2(189.11,53.58) 188.65,53.12 188.47,53.12 188.34,53.25 188.34,53.43 188.67,53.77 188.67,56.79 196.32,64.44 196.32,72.55 203.52,79.76 203.52,87.16 204.28,87.92 204.28,98.34 205.05,99.1 205.05,113.91 198.76,120.19 197.18,120.19 v2(197.06,120.31)
  BOTTOM w0.14: v2(189.11,53.58) 187.44,51.91 JDIMM4.7
DDR_B_D6: length 92.8
  TOP w0.102: JCPU1.AN17 193.59,120.78 v2(194.06,120.31)
  TOP w0.14: JDIMM3.17 184.44,56.5 v2(185.86,55.08)
  IN3 w0.089: v2(194.06,120.31) 194.65,119.72 194.65,119.09 194.84,118.9 196.3,118.9 196.65,118.55 196.65,118.09 196.84,117.91 197.52,117.91 197.59,117.84
  IN3 w0.127: 197.59,117.84 197.65,117.78 199.15,117.78 203.63,113.3 203.63,99.86 202.8,99.02 202.8,88.59 202.04,87.82 202.04,80.39 194.82,73.17 194.82,64.99 190.57,60.74 190.45,60.74 190.22,60.97 190.04,60.97 189.85,60.78 189.85,60.6 190.05,60.4 190.05,60.22 187.07,57.24 187.07,55.72 186.74,55.39 186.74,52.85 186.61,52.72 186.41,52.72 186.28,52.85 186.28,54.95 186.16,55.08 v2(185.86,55.08)
  BOTTOM w0.14: JDIMM4.18 184.14,56.25 185.25,55.14 185.8,55.14 v2(185.86,55.08)
DDR_B_D7: length 90.4
  TOP w0.102: v2(194.06,121.31) 193.59,121.78 JCPU1.AN18
  TOP w0.14: JDIMM3.15 185.04,56.69 185.12,56.61 v2(185.86,56.61)
  IN3 w0.089: 197.46,117.51 197.25,117.72 196.76,117.72 196.46,118.01 196.46,118.47 196.23,118.71 194.76,118.71 194.61,118.86 194.46,119.01 194.46,119.49 194.19,119.76 193.93,119.76 193.68,120 193.68,120.93 v2(194.06,121.31)
  IN3 w0.127: v2(185.86,56.61) 185.88,56.63 186.16,56.63 186.28,56.5 186.28,55.87 186.41,55.74 186.61,55.74 186.74,55.87 186.74,56.76 186.41,57.09 186.41,57.44 186.56,57.6 186.95,57.6 187.14,57.79 187.14,58.18 187.28,58.31 187.67,58.31 187.85,58.49 187.85,59.09 188,59.25 188.16,59.25 188.29,59.12 188.47,59.12 188.62,59.27 188.62,59.45 188.4,59.66 188.4,59.82 190.25,61.66 190.71,61.66 194.44,65.39 194.44,65.57 194.28,65.72 194.1,65.72 193.31,64.92 193.13,64.92 192.95,65.1 192.95,65.28 193.8,66.13 194.23,66.13 194.39,66.29 194.39,73.22 201.7,80.53 201.7,87.96 202.46,88.72 202.46,99.16 203.28,99.99 203.28,113.17 199.14,117.31 197.66,117.31 197.46,117.51
  BOTTOM w0.14: v2(185.86,56.61) 185.19,56.61 184.74,57.05 JDIMM4.16
DDR_B_D8: length 79.6
  TOP w0.102: JCPU1.AT12 v2(197.06,116.31)
  TOP w0.14: v2(183.56,56.05) 183.24,56.38 JDIMM3.21
  IN3 w0.089: 196.03,114.46 195.46,115.02 195.46,116.36 195.85,116.74 196.45,116.74 196.88,116.31 v2(197.06,116.31)
  IN3 w0.127: v2(183.56,56.05) 183.56,57.63 185.02,59.09 185.02,60.34 192.23,67.54 192.23,69.15 191.32,70.05 191.32,71.1 190.6,71.82 190.6,72.41 199.59,81.41 199.59,88.84 200.35,89.6 200.35,100.04 201.15,100.84 201.15,111.26 199.7,112.72 199.28,112.72 198.25,113.75 198.25,114.08 197.99,114.34 196.15,114.34 196.03,114.46
  BOTTOM w0.14: v2(183.56,56.05) 182.94,56.68 JDIMM4.22
DDR_B_D9: length 82.8
  TOP w0.102: JCPU1.AR12 v2(196.06,116.31)
  TOP w0.14: v2(183.56,54.65) 182.83,55.39 182.83,56.51 182.64,56.7 JDIMM3.23
  IN3 w0.089: v2(196.06,116.31) 195.65,115.9 195.65,115.18 196.16,114.67 197.32,114.67 197.38,114.72 197.48,114.72
  IN3 w0.127: v2(183.56,54.65) 183.98,55.07 183.98,57.57 185.36,58.95 185.36,60.2 192.56,67.4 192.56,71.13 192.38,71.31 191.74,71.31 191.62,71.44 191.62,72.96 199.93,81.27 199.93,88.7 200.69,89.46 200.69,99.9 201.49,100.7 201.49,111.4 199.84,113.05 199.42,113.05 198.6,113.87 198.6,114.49 198.37,114.72 197.48,114.72
  BOTTOM w0.14: v2(183.56,54.65) 183.52,54.65 183.06,55.12 183.06,55.99 182.34,56.71 JDIMM4.24
DDR_B_D10: length 85.8
  TOP w0.102: JCPU1.AN12 193.59,115.78 v2(194.06,115.31)
  TOP w0.14: JDIMM3.33 179.64,56.37 180.05,55.96 v2(180.51,55.96)
  IN3 w0.089: v2(194.06,115.31) 193.46,114.71 193.46,112.34 193.99,111.81 195.45,111.81 195.67,111.59 196.37,111.59 196.62,111.34
  IN3 w0.127: 196.62,111.34 197.59,111.34 199.04,109.88 199.04,101.82 198.26,101.03 198.26,90.5 197.49,89.73 197.49,82.33 186.84,71.68 186.84,71.49 187.09,71.24 187.09,71.1 186.97,70.98 186.59,70.98 186.43,70.83 186.43,70.57 186.56,70.44 186.94,70.44 187.07,70.32 187.07,70.06 186.94,69.94 186.56,69.94 186.43,69.81 186.43,69.56 186.56,69.43 186.94,69.43 187.07,69.3 187.07,69.05 186.94,68.92 186.56,68.92 186.43,68.79 186.43,66.05 186.92,65.57 186.92,65.28 182.22,60.59 182.22,59.37 179.65,56.8 179.65,53.84 179.78,53.71 179.96,53.71 180.08,53.84 180.08,55.82 180.23,55.96 v2(180.51,55.96)
  BOTTOM w0.14: v2(180.51,55.96) 180.33,55.96 179.34,56.95 JDIMM4.34
DDR_B_D11: length 88
  TOP w0.102: JCPU1.AM11 v2(193.06,115.31)
  TOP w0.14: JDIMM3.36 178.74,50.76 179.56,51.59 179.56,52.47 v2(180.51,53.42)
  IN3 w0.089: 197.25,111.97 195.85,111.97 195.65,112.16 195.65,112.66 195.41,112.91 194.89,112.91 194.45,113.35 194.45,115.55 194.28,115.72 193.47,115.72 v2(193.06,115.31)
  IN3 w0.127: v2(180.51,53.42) 180.77,53.17 181.06,53.17 181.44,53.56 181.44,53.67 181.08,54.04 181.08,54.29 181.44,54.66 181.44,57.65 182.89,59.09 182.89,60.31 187.76,65.18 187.76,68.82 189.19,70.24 189.19,71.33 188.95,71.57 188.06,71.57 187.93,71.69 187.93,71.82 188.19,72.07 189.06,72.07 189.19,72.2 189.19,72.34 188.95,72.58 188.95,72.84 198.16,82.05 198.16,89.45 198.93,90.22 198.93,100.75 199.71,101.54 199.71,110.25 197.97,112 197.28,112 197.25,111.97
  BOTTOM w0.14: v2(180.51,53.42) 180.33,53.42 179.55,52.64 179.55,51.43 179.04,50.92 JDIMM4.35
DDR_B_D12: length 80.4
  TOP w0.102: JCPU1.AT11 v2(197.06,115.31)
  TOP w0.14: v2(183.56,52.11) 182.34,50.89 JDIMM3.24
  IN3 w0.127: v2(197.06,115.31) 197.23,115.48 198.78,115.48 202.18,112.08 202.18,100.44 201.36,99.62 201.36,89.18 200.6,88.42 200.6,80.99 193.23,73.62 193.23,67.12 189.4,63.29 189.4,62.37 186.74,59.72 186.74,59.34 184.65,57.25 184.65,53.2 v2(183.56,52.11)
  BOTTOM w0.14: v2(183.56,52.11) 183.49,52.11 182.64,51.26 JDIMM4.23
DDR_B_D13: length 83.6
  TOP w0.102: JCPU1.AR11 v2(196.06,115.31)
  TOP w0.14: v2(183.56,53.38) 184.05,52.9 184.05,51.87 183.69,51.51 183.5,51.51 182.94,50.95 JDIMM3.22
  IN3 w0.089: 197.32,114.99 197.23,114.9 196.47,114.9 v2(196.06,115.31)
  IN3 w0.127: v2(183.56,53.38) 183.77,53.18 184.07,53.18 184.32,53.42 184.32,57.43 186.41,59.52 186.41,59.86 189.06,62.51 189.06,63.43 192.9,67.26 192.9,71.28 192.61,71.57 192.61,73.47 200.26,81.13 200.26,88.56 201.02,89.32 201.02,99.76 201.82,100.56 201.82,111.54 200.23,113.14 200.23,113.55 198.7,115.08 197.41,115.08 197.32,114.99
  BOTTOM w0.14: JDIMM4.21 183.24,50.87 184.23,51.85 184.23,52.98 183.82,53.38 v2(183.56,53.38)
DDR_B_D14: length 87.2
  TOP w0.102: JCPU1.AM12 v2(193.06,116.31)
  TOP w0.14: v2(180.51,52.15) 180,51.64 180,51.34 179.34,50.68 JDIMM3.34
  IN3 w0.089: 195.74,112.93 195.46,113.22 195.46,113.48 195.23,113.71 194.95,113.71 194.64,114.02 194.64,115.63 194.36,115.91 193.46,115.91 v2(193.06,116.31)
  IN3 w0.127: v2(180.51,52.15) 180.75,52.39 181.08,52.39 181.2,52.26 181.2,51.88 181.33,51.75 181.67,51.75 181.8,51.88 181.8,55.91 181.96,56.07 182.35,56.07 182.47,56.2 182.47,56.45 182.35,56.58 181.96,56.58 181.84,56.71 181.84,56.96 181.96,57.09 182.35,57.09 182.47,57.21 182.47,57.47 182.35,57.6 182.35,57.95 183.33,58.93 183.33,60.26 186.88,63.82 186.88,63.82 188.1,65.04 188.1,67.25 188.22,67.37 188.44,67.37 188.57,67.5 188.57,67.88 188.44,68.01 188.19,68.01 188.1,68.1 188.1,68.68 189.52,70.1 189.52,72.94 198.49,81.91 198.49,89.31 199.27,90.09 199.27,100.62 200.05,101.4 200.05,110.63 199.4,111.28 199.17,111.28 197.56,112.89 195.79,112.89 195.74,112.93
  BOTTOM w0.14: v2(180.51,52.15) 180.39,52.27 180.08,52.27 179.92,52.11 179.92,51.14 179.64,50.86 JDIMM4.33
DDR_B_D15: length 86.8
  TOP w0.102: JCPU1.AN11 193.59,114.78 v2(194.06,114.31)
  TOP w0.14: v2(180.51,54.69) 179.9,54.69 179.04,55.55 JDIMM3.35
  IN3 w0.089: 197.79,111.65 196.75,111.65 196.61,111.78 195.77,111.78 195.46,112.08 195.46,112.58 195.33,112.72 193.86,112.72 193.66,112.92 193.66,113.91 v2(194.06,114.31)
  IN3 w0.127: 197.79,111.65 199.38,110.06 199.38,101.68 198.6,100.89 198.6,90.36 197.82,89.59 197.82,82.19 187.43,71.79 187.43,71.31 187.55,71.18 188.7,71.18 188.82,71.06 188.82,70.8 188.7,70.68 187.55,70.68 187.43,70.55 187.43,70.3 187.55,70.17 188.06,70.17 188.18,70.04 188.18,69.79 188.06,69.66 187.55,69.66 187.43,69.53 187.43,65.32 182.56,60.45 182.56,59.23 181.11,57.79 181.11,57.09 180.92,56.91 180.23,56.91 179.99,56.67 179.99,56.53 180.11,56.4 180.85,56.4 180.97,56.27 180.97,54.85 180.81,54.69 v2(180.51,54.69)
  BOTTOM w0.14: v2(180.51,54.69) 180.2,54.69 179.45,55.45 179.45,56.18 178.74,56.89 JDIMM4.36
DDR_B_D16: length 74
  TOP w0.102: v2(196.06,108.31) 195.59,108.78 JCPU1.AR5
  TOP w0.14: v2(178.39,51.92) 177.98,51.92 176.94,50.88 JDIMM3.42
  IN3 w0.127: v2(178.39,51.92) 178.02,51.55 177.42,51.55 177.29,51.68 177.29,53.51 177.95,54.17 177.95,56.05 177.57,56.43 177.57,56.75 180.78,59.97 180.78,61.44 184.25,64.91 184.25,71.12 196.05,82.92 196.05,95.07 196.82,95.85 196.82,104.03 197.56,104.76 197.56,106.59 197.31,106.85 196.92,106.85 196.54,107.23 196.54,107.63 196.06,108.12 v2(196.06,108.31)
  BOTTOM w0.14: JDIMM4.41 177.24,51.29 177.87,51.92 v2(178.39,51.92)
DDR_B_D17: length 76.6
  TOP w0.102: v2(196.06,109.31) 195.59,109.78 JCPU1.AR6
  TOP w0.14: JDIMM3.40 177.54,50.74 178.13,51.33 178.4,51.33 178.82,51.75 178.82,52.77 v2(178.39,53.19)
  IN3 w0.127: v2(196.06,109.31) 196.52,109.77 197.25,109.77 198.61,108.41 198.61,101.99 197.83,101.21 197.83,90.68 197.05,89.91 197.05,82.51 185.98,71.43 185.98,64.95 181.79,60.76 181.79,59.55 179.22,56.98 179.22,53.86 178.55,53.19 v2(178.39,53.19)
  BOTTOM w0.14: JDIMM4.39 177.84,51.05 178.08,51.29 178.55,51.29 179.11,51.85 179.11,52.93 178.85,53.19 v2(178.39,53.19)
DDR_B_D18: length 77.2
  TOP w0.102: JCPU1.AM5 v2(193.06,109.31)
  TOP w0.14: JDIMM3.52 173.94,52.17 v2(174.99,53.22)
  IN3 w0.089: v2(193.06,109.31) 193.45,109.7 194.21,109.7 194.47,109.44 194.47,107.06 194.81,106.72 195.28,106.72 195.46,106.53 195.46,102.81
  IN3 w0.127: v2(174.99,53.22) 174.99,53.29 175.18,53.48 175.39,53.48 175.54,53.33 175.54,53.05 175.66,52.92 175.92,52.92 176.05,53.05 176.05,57.24 179.29,60.48 179.29,61.98 182.37,65.06 182.37,71.26 194.58,83.46 194.58,96.2 194.72,96.35 195.29,96.35 195.39,96.44 195.39,102.74 195.46,102.81
  BOTTOM w0.14: JDIMM4.53 173.64,51 174.47,51.83 174.47,52.7 v2(174.99,53.22)
DDR_B_D19: length 76.5
  TOP w0.102: JCPU1.AM6 v2(193.06,110.31)
  TOP w0.14: JDIMM3.50 174.54,51.5 v2(174.99,51.95)
  IN3 w0.089: v2(193.06,110.31) 193.47,109.89 194.29,109.89 194.66,109.52 194.66,107.14 194.89,106.91 195.35,106.91 195.66,106.6 195.66,105.19 195.78,105.07
  IN3 w0.127: v2(174.99,51.95) 175.31,51.95 175.44,52.08 175.44,52.39 175.56,52.52 175.79,52.52 175.92,52.39 175.92,51.7 176.05,51.58 176.25,51.58 176.38,51.7 176.38,57.1 179.62,60.34 179.62,61.84 182.71,64.92 182.71,71.12 194.91,83.32 194.91,95.49 195.72,96.31 195.72,102.62 195.78,102.68 195.78,105.07
  BOTTOM w0.14: v2(174.99,51.95) 174.99,51.81 174.24,51.06 JDIMM4.51
DDR_B_D20: length 74.5
  TOP w0.102: v2(197.06,108.31) 196.59,108.78 JCPU1.AT5
  TOP w0.14: JDIMM3.41 177.24,56.49 177.81,55.92 177.81,55.05 v2(178.39,54.46)
  IN3 w0.127: v2(197.06,108.31) 197.7,108.31 198.28,107.73 198.28,102.2 197.49,101.42 197.49,92.88 197.37,92.75 196.85,92.75 196.72,92.62 196.72,92.37 196.85,92.24 197.37,92.24 197.49,92.11 197.49,91.86 197.37,91.73 196.85,91.73 196.72,91.61 196.72,91.35 196.85,91.22 197.25,91.22 197.38,91.1 197.38,90.84 197.25,90.72 196.85,90.72 196.72,90.59 196.72,82.65 185.6,71.52 185.6,65.05 181.45,60.9 181.45,59.69 178.87,57.1 178.87,55 178.39,54.53 v2(178.39,54.46)
  BOTTOM w0.14: v2(178.39,54.46) 178.39,54.58 177.94,55.03 177.94,55.81 176.94,56.81 JDIMM4.42
DDR_B_D21: length 73.5
  TOP w0.102: v2(197.06,109.31) 196.59,109.78 JCPU1.AT6
  TOP w0.14: v2(178.39,55.86) 178.39,56.2 177.84,56.75 JDIMM3.39
  IN3 w0.127: v2(197.06,109.31) 196.72,109.31 196.57,109.16 196.57,108.19 196.95,107.81 197.64,107.81 197.92,107.53 197.92,104.1 197.76,103.95 197.31,103.95 197.16,103.8 197.16,103.59 197.28,103.47 197.79,103.47 197.94,103.32 197.94,103.11 197.79,102.96 197.29,102.96 197.16,102.83 197.16,102.6 197.38,102.38 197.38,102.01 197.16,101.79 197.16,95.24 196.98,95.06 196.56,95.06 196.38,94.88 196.38,94.74 196.54,94.58 197.01,94.58 197.15,94.44 197.15,94.24 197.01,94.09 196.54,94.09 196.39,93.95 196.39,93.74 196.54,93.59 197.01,93.59 197.15,93.45 197.15,93.25 197.01,93.1 196.54,93.1 196.38,92.95 196.38,82.78 184.68,71.08 184.68,64.87 181.12,61.3 181.12,59.83 178.06,56.77 178.06,56.41 178.39,56.08 v2(178.39,55.86)
  BOTTOM w0.14: JDIMM4.40 177.54,56.73 177.71,56.56 178.18,56.56 178.39,56.35 v2(178.39,55.86)
DDR_B_D22: length 77.3
  TOP w0.102: v2(194.06,108.31) 193.59,108.78 JCPU1.AN5
  TOP w0.14: JDIMM3.53 173.64,56.49 174.22,55.9 174.22,55.26 v2(174.99,54.49)
  IN3 w0.089: v2(194.06,108.31) 193.66,107.91 193.66,107.14 193.89,106.91 194.35,106.91 194.66,106.6 194.66,105.17 195.27,104.56 195.27,103.13 195.17,103.04
  IN3 w0.127: 195.17,103.04 195.03,102.89 195.03,102.73 194.66,102.37 194.66,102.17 195.03,101.81 195.03,98.92 194.9,98.79 194.37,98.79 194.24,98.67 194.24,98.34 194.37,98.21 194.93,98.21 195.05,98.08 195.05,97.83 194.93,97.7 194.37,97.7 194.24,97.57 194.24,97.32 194.37,97.19 194.93,97.19 195.05,97.07 195.05,96.81 194.93,96.69 194.37,96.69 194.24,96.56 194.24,83.62 182.04,71.42 182.04,65.2 177.96,61.12 177.96,59.66 175.71,57.41 175.71,56.2 175.46,55.95 175.46,55.69 175.71,55.44 175.71,55.18 175.44,54.9 175.44,54.7 175.71,54.43 175.71,54.21 175.56,54.06 175.39,54.06 174.99,54.46 v2(174.99,54.49)
  BOTTOM w0.14: JDIMM4.52 173.94,56.7 174.08,56.56 174.08,54.61 174.26,54.43 174.93,54.43 v2(174.99,54.49)
DDR_B_D23: length 76.6
  TOP w0.102: JCPU1.AN6 193.59,109.78 v2(194.06,109.31)
  TOP w0.14: v2(174.99,55.76) 174.24,56.51 JDIMM3.51
  IN3 w0.089: 194.94,103.42 195.08,103.55 195.08,104.48 194.47,105.09 194.47,106.53 194.28,106.72 193.81,106.72 193.47,107.06 193.47,108.72 v2(194.06,109.31)
  IN3 w0.127: v2(174.99,55.76) 174.81,55.76 174.7,55.87 174.7,56.23 174.85,56.38 175.25,56.38 175.38,56.5 175.38,56.77 175.23,56.91 174.98,56.91 174.85,57.04 174.85,57.24 176.38,58.76 176.38,58.99 176.19,59.17 176.19,59.68 176.32,59.8 176.53,59.8 176.66,59.68 176.66,59.3 176.78,59.17 176.98,59.17 177.11,59.3 177.11,59.65 177.21,59.75 177.47,59.75 177.6,59.88 177.6,60.16 177.47,60.29 177.14,60.29 177.01,60.41 177.01,60.59 177.14,60.72 177.47,60.72 177.62,60.87 177.62,61.26 181.7,65.34 181.7,71.56 193.91,83.76 193.91,99.05 194.03,99.18 194.57,99.18 194.69,99.3 194.69,99.56 194.57,99.68 194.03,99.68 193.91,99.81 193.91,100.07 194.03,100.19 194.57,100.19 194.69,100.32 194.69,100.57 194.57,100.7 194.03,100.7 193.91,100.83 193.91,101.08 194.03,101.21 194.57,101.21 194.69,101.34 194.69,101.59 194.57,101.72 194.03,101.72 193.91,101.84 193.91,102.17 194.46,102.73 194.46,102.94 194.94,103.42
  BOTTOM w0.14: JDIMM4.50 174.54,56.63 174.71,56.46 174.92,56.46 174.99,56.39 v2(174.99,55.76)
DDR_B_D24: length 74.9
  TOP w0.102: v2(190.06,107.31) 189.59,107.78 JCPU1.AJ4
  TOP w0.14: v2(173.06,51.79) 172.44,51.79 172.14,51.49 JDIMM3.58
  IN3 w0.089: 194.64,103.8 194.64,104.54 194.3,104.88 193.91,104.88 193.65,105.14 193.65,106.53 193.24,106.93 192.8,106.93 192.64,107.09 192.64,107.48 192.42,107.71 190.46,107.71 v2(190.06,107.31)
  IN3 w0.127: v2(173.06,51.79) 174.27,53.01 174.27,57.27 175.76,58.76 175.76,60.01 181.27,65.52 181.27,71.73 193.47,83.94 193.47,102.25 194.03,102.81 194.03,103.19 194.64,103.8
  BOTTOM w0.14: JDIMM4.59 171.84,51.04 172.6,51.79 v2(173.06,51.79)
DDR_B_D25: length 76
  TOP w0.102: v2(191.06,107.31) 190.59,107.78 JCPU1.AK4
  TOP w0.14: v2(173.06,53.06) 173.48,52.64 173.48,51.62 172.81,50.95 172.74,50.95 JDIMM3.56
  IN3 w0.089: 194.31,103.92 194.45,104.06 194.45,104.46 194.22,104.69 193.84,104.69 193.46,105.06 193.46,106.45 193.17,106.74 192.02,106.74 191.46,107.31 v2(191.06,107.31)
  IN3 w0.127: 194.31,103.92 193.7,103.31 193.7,103.02 193.14,102.47 193.14,84.08 180.94,71.87 180.94,70.88 180.81,70.75 180.39,70.75 180.26,70.63 180.26,70.37 180.39,70.24 180.8,70.24 180.92,70.12 180.92,69.89 180.8,69.76 180.36,69.76 180.26,69.66 180.26,66.18 180.52,65.93 180.52,65.67 180.26,65.42 180.26,65.03 175.38,60.14 175.38,58.96 173.94,57.52 173.94,53.95 v2(173.06,53.06)
  BOTTOM w0.14: v2(173.06,53.06) 173.34,53.06 173.66,52.74 173.66,51.72 173.01,51.07 172.57,51.07 172.44,50.95 JDIMM4.57
DDR_B_D26: length 72.2
  TOP w0.102: JCPU1.AJ1 189.59,104.78 v2(190.06,104.31)
  TOP w0.14: v2(170.01,51.82) 169.53,51.82 168.54,50.84 JDIMM3.70
  IN3 w0.127: v2(170.01,51.82) 169.69,51.5 168.5,51.5 168.38,51.63 168.38,51.88 168.5,52.01 169.39,52.01 169.52,52.13 169.52,52.39 169.39,52.52 168.76,52.52 168.63,52.64 168.63,52.9 168.76,53.02 169.39,53.02 169.59,53.22 169.59,56.31 170.62,57.35 170.62,58.63 171.08,59.09 171.08,59.95 176.23,65.09 176.23,71.87 186.01,81.65 186.01,83 190.32,87.32 190.32,104.05 v2(190.06,104.31)
  BOTTOM w0.14: v2(170.01,51.82) 169.18,51.82 168.84,51.48 JDIMM4.69
DDR_B_D27: length 74.9
  TOP w0.102: v2(190.06,105.31) 189.59,105.78 JCPU1.AJ2
  TOP w0.14: v2(170.01,53.35) 170.43,52.92 170.43,51.65 169.92,51.13 169.48,51.13 169.14,50.79 JDIMM3.68
  IN3 w0.089: 191.62,103.65 191.65,103.68 191.65,105.25 191.21,105.69 190.44,105.69 v2(190.06,105.31)
  IN3 w0.127: 191.62,103.65 191.33,103.36 191.33,85.42 177.85,71.94 177.85,65.29 172.54,59.98 172.54,58.6 172.09,58.15 172.09,56.74 170.94,55.59 170.94,52.49 170.81,52.36 170.56,52.36 170.43,52.49 170.43,53.22 170.31,53.35 v2(170.01,53.35)
  BOTTOM w0.14: JDIMM4.67 169.44,50.85 169.8,51.2 170.37,51.2 170.7,51.53 170.7,52.65 v2(170.01,53.35)
DDR_B_D28: length 70
  TOP w0.102: v2(193.06,104.31) 192.59,104.78 JCPU1.AM1
  TOP w0.14: v2(173.06,55.6) 172.79,55.6 171.84,56.55 JDIMM3.59
  IN3 w0.127: v2(173.06,55.6) 173.22,55.77 173.22,57.75 174.7,59.24 174.7,60.42 179.04,64.76 179.04,71.61 179.71,72.28 179.89,72.28 180.05,72.12 180.23,72.12 180.41,72.3 180.41,72.48 180.25,72.64 180.25,72.82 180.43,73 180.61,73 180.77,72.84 180.95,72.84 181.13,73.02 181.13,73.2 180.97,73.36 180.97,73.54 181.15,73.72 181.33,73.72 181.49,73.56 181.67,73.56 181.85,73.74 181.85,73.92 181.69,74.08 181.69,74.26 181.87,74.44 182.05,74.44 182.21,74.28 182.39,74.28 182.57,74.46 182.57,74.64 182.41,74.8 182.41,74.98 182.59,75.16 182.77,75.16 182.93,75 183.11,75 183.29,75.18 183.29,75.35 183.13,75.51 183.13,75.69 183.31,75.87 183.49,75.87 183.65,75.71 183.83,75.71 184.01,75.89 184.01,76.07 183.85,76.23 183.85,76.41 184.03,76.59 184.21,76.59 184.37,76.43 184.55,76.43 184.73,76.61 184.73,76.79 184.56,76.95 184.56,77.13 184.74,77.31 184.92,77.31 185.08,77.15 185.26,77.15 185.44,77.33 185.44,77.51 185.28,77.67 185.28,77.85 185.46,78.03 185.64,78.03 185.8,77.87 185.98,77.87 186.16,78.05 186.16,78.23 186,78.39 186,78.57 186.24,78.8 186.92,78.8 191.39,83.27 191.39,83.95 192.47,85.04 192.47,102.81 193.03,103.37 193.03,104.28 v2(193.06,104.31)
  BOTTOM w0.14: v2(173.06,55.6) 173.06,56.28 172.14,57.19 JDIMM4.58
DDR_B_D29: length 70.6
  TOP w0.102: JCPU1.AN1 194.06,104.37 v2(194.06,104.31)
  TOP w0.14: JDIMM3.57 172.44,56.82 173.48,55.78 173.48,54.76 v2(173.06,54.33)
  IN3 w0.127: v2(173.06,54.33) 173.06,54.32 173.18,54.19 173.43,54.19 173.56,54.32 173.56,57.62 175.04,59.1 175.04,60.28 179.93,65.17 179.93,70.4 179.8,70.52 179.51,70.52 179.38,70.65 179.38,71.47 179.56,71.66 179.82,71.66 179.96,71.51 179.96,71.26 180.08,71.13 180.47,71.13 180.6,71.26 180.6,72.01 192.8,84.22 192.8,102.61 193.36,103.16 193.36,103.61 v2(194.06,104.31)
  BOTTOM w0.14: v2(173.06,54.33) 173.23,54.33 173.63,54.73 173.63,56.3 172.74,57.19 JDIMM4.56
DDR_B_D30: length 73.9
  TOP w0.102: JCPU1.AK2 190.59,105.78 v2(191.06,105.31)
  TOP w0.14: JDIMM3.69 168.84,56.04 v2(170.01,54.87)
  IN3 w0.089: v2(191.06,105.31) 191.46,104.9 191.46,104.05 191.26,103.85
  IN3 w0.127: v2(170.01,54.87) 170.01,54.64 170.13,54.52 170.48,54.52 170.61,54.65 170.61,55.53 170.45,55.69 170.45,56.22 170.58,56.36 170.71,56.36 170.86,56.2 171.08,56.2 171.75,56.88 171.75,57.04 171.6,57.19 171.42,57.19 171.29,57.32 171.29,57.49 171.45,57.65 171.63,57.65 171.75,57.77 171.75,57.97 171.63,58.1 171.53,58.1 171.37,58.26 171.37,58.43 171.56,58.62 172.09,58.62 172.21,58.74 172.21,59 172.08,59.12 171.88,59.12 171.75,59.25 171.75,59.45 171.88,59.58 172.06,59.58 172.21,59.72 172.21,60.12 177.31,65.22 177.31,65.38 177.21,65.47 177.04,65.47 176.9,65.61 176.9,71.06 177.02,71.18 177.39,71.18 177.51,71.31 177.51,71.52 177.42,71.62 177.29,71.62 177.19,71.72 177.19,71.87 190.99,85.67 190.99,85.99 190.89,86.09 190.73,86.09 190.36,85.73 190.18,85.73 190.02,85.89 190.02,86.07 190.99,87.04 190.99,103.58 191.26,103.85
  BOTTOM w0.14: JDIMM4.70 168.54,57 169.29,56.25 169.29,55.43 169.85,54.87 v2(170.01,54.87)
DDR_B_D31: length 71.4
  TOP w0.102: v2(191.06,104.31) 190.59,104.78 JCPU1.AK1
  TOP w0.14: JDIMM3.67 169.44,56.5 169.8,56.14 v2(170.01,56.14)
  IN3 w0.127: v2(170.01,56.14) 170.01,56.26 170.96,57.21 170.96,58.49 171.42,58.95 171.42,59.81 176.56,64.95 176.56,71.73 190.01,85.18 190.01,85.36 189.86,85.51 189.68,85.51 186.7,82.53 186.52,82.53 186.35,82.7 186.35,82.88 190.66,87.18 190.66,103.91 v2(191.06,104.31)
  BOTTOM w0.14: JDIMM4.68 169.14,57.01 v2(170.01,56.14)
DDR_B_D32: length 78.7
  TOP w0.102: v2(171.06,105.31) JCPU1.L2
  TOP w0.14: v2(146.6,54.79) 147.6,55.78 147.6,56.22 148.44,57.07 JDIMM3.129
  IN3 w0.127: v2(146.6,54.79) 146.15,55.24 146.15,57.75 145.87,58.03 145.87,59.25 145.12,59.99 145.12,64.48 146.06,65.42 146.06,71.91 147.55,73.4 147.55,77.28 149.22,78.95 149.22,79.48 150.02,80.28 150.32,80.28 150.86,80.82 150.86,81.62 150.69,81.8 150.45,81.8 150.29,81.96 150.29,82.18 150.45,82.33 150.69,82.33 150.86,82.51 150.86,82.79 153.01,84.93 154.55,84.93 156.84,87.22 156.85,87.22 157.43,87.79 157.43,88.03 156.97,88.48 156.97,88.66 159.24,90.93 159.42,90.93 159.9,90.45 160.08,90.45 160.26,90.63 160.26,90.81 159.78,91.29 159.78,91.47 159.96,91.65 160.14,91.65 160.62,91.17 160.8,91.17 160.98,91.35 160.98,91.53 160.5,92.01 160.5,92.19 160.68,92.37 160.86,92.37 161.34,91.89 161.52,91.89 161.7,92.07 161.7,92.25 161.22,92.73 161.22,92.91 161.4,93.09 161.58,93.09 162.06,92.61 162.24,92.61 162.97,93.34 162.97,94.66 169.47,101.16 169.47,101.87 171.06,103.46 v2(171.06,105.31)
  BOTTOM w0.14: v2(146.6,54.79) 148.14,56.32 JDIMM4.130
DDR_B_D33: length 78.5
  TOP w0.102: v2(172.06,105.31) JCPU1.M2
  TOP w0.14: v2(146.6,53.39) 147.32,52.68 147.32,52.11 148.14,51.29 JDIMM3.130
  IN3 w0.089: v2(172.06,105.31) 171.66,105.71 170.83,105.71 170.66,105.54 170.66,103.62 170.48,103.44
  IN3 w0.127: v2(146.6,53.39) 146.47,53.39 146.18,53.68 146.18,54.74 145.81,55.11 145.81,57.61 145.33,58.1 145.33,59.32 144.79,59.86 144.79,64.66 145.73,65.6 145.73,72.05 147.22,73.54 147.22,75.39 147.09,75.52 146.78,75.52 146.63,75.66 146.63,75.87 146.78,76.02 147.09,76.02 147.22,76.15 147.22,77.42 148.88,79.09 148.88,79.62 149.86,80.59 149.86,82.89 150.32,83.35 150.44,83.35 150.58,83.21 150.8,83.21 150.96,83.37 150.96,83.74 151.15,83.93 151.54,83.93 152.93,85.32 154.47,85.32 156.54,87.39 156.54,88.7 161.43,93.6 161.73,93.6 162.13,93.21 162.36,93.21 162.52,93.37 162.52,93.6 162.05,94.07 162.05,94.22 169.09,101.25 169.09,102.05 170.48,103.44
  BOTTOM w0.14: JDIMM4.129 148.44,51.56 v2(146.6,53.39)
DDR_B_D34: length 82.9
  TOP w0.102: v2(171.06,107.31) JCPU1.L4
  TOP w0.14: JDIMM3.142 144.54,50.77 142.72,52.59 142.72,53.94 v2(143.3,54.52)
  IN3 w0.089: 167.6,103.77 167.6,105.41 167.9,105.7 168.29,105.7 168.66,106.07 168.66,107.51 168.88,107.73 170.63,107.73 v2(171.06,107.31)
  IN3 w0.127: v2(143.3,54.52) 142.88,54.94 142.88,58.42 141.94,59.36 141.94,65.42 141.52,65.83 141.52,70.91 144.29,73.68 144.29,80.56 148.18,84.45 148.44,84.45 150.02,86.04 150.54,86.56 150.72,86.56 150.85,86.43 151.03,86.43 151.21,86.61 151.21,86.79 151.08,86.92 151.08,87.1 151.26,87.28 151.44,87.28 151.57,87.15 151.75,87.15 151.93,87.33 151.93,87.51 151.8,87.64 151.8,87.81 154.87,90.89 155.05,90.89 155.27,90.66 155.45,90.66 155.63,90.84 155.63,91.02 155.41,91.24 155.41,91.42 155.59,91.6 155.77,91.6 155.99,91.38 156.17,91.38 166.43,101.64 166.43,102.44 167.6,103.62 167.6,103.77
  BOTTOM w0.14: JDIMM4.143 144.24,51.01 142.7,52.55 142.7,54.36 142.9,54.56 143.26,54.56 v2(143.3,54.52)
DDR_B_D35: length 81.2
  TOP w0.102: JCPU1.M4 172.53,107.84 v2(172.06,108.31)
  TOP w0.14: v2(143.3,53) 143.3,52.71 145.14,50.87 JDIMM3.140
  IN3 w0.089: v2(172.06,108.31) 171.68,108.69 168.9,108.69 168.47,108.26 168.47,106.15 168.21,105.89 167.82,105.89 167.41,105.49 167.41,103.95 167.28,103.82
  IN3 w0.127: v2(143.3,53) 143.3,52.74 143.17,52.62 142.67,52.62 142.54,52.74 142.54,57.8 141.6,58.74 141.6,65.28 141.19,65.69 141.19,71.05 143.96,73.81 143.96,80.7 148.07,84.81 148.32,84.81 151.28,87.77 151.28,87.77 167.28,103.77 167.28,103.82
  BOTTOM w0.14: JDIMM4.141 144.84,50.94 143.3,52.48 v2(143.3,53)
DDR_B_D36: length 76
  TOP w0.102: JCPU1.L1 171.59,104.78 v2(172.06,104.31)
  TOP w0.14: JDIMM3.131 147.84,57 146.9,56.06 v2(146.6,56.06)
  IN3 w0.127: v2(172.06,104.31) 172.06,103.95 170,101.89 170,101.22 163.3,94.52 163.3,93.2 159.91,89.81 159.73,89.81 159.4,90.14 159.19,90.14 159.04,89.99 159.04,89.78 159.37,89.45 159.37,89.27 159.19,89.09 159.01,89.09 158.55,89.55 158.34,89.55 158.19,89.4 158.19,89.19 158.66,88.73 158.66,88.55 158.48,88.37 158.3,88.37 157.84,88.83 157.62,88.83 157.48,88.68 157.48,88.47 157.94,88.01 157.94,87.83 154.7,84.6 153.15,84.6 151.2,82.65 151.2,80.38 150.77,79.95 150.16,79.95 149.55,79.34 149.55,78.81 147.89,77.14 147.89,73.26 146.4,71.77 146.4,71.5 146.56,71.34 146.76,71.34 146.89,71.21 146.89,70.8 146.76,70.68 146.57,70.68 146.4,70.5 146.4,65.16 146.23,64.99 146.23,64.55 146.1,64.42 145.59,64.42 145.46,64.3 145.46,64.04 145.59,63.92 146.12,63.92 146.25,63.79 146.25,63.54 146.12,63.41 145.59,63.41 145.46,63.28 145.46,63.08 145.59,62.95 146.07,62.95 146.2,62.83 146.2,62.17 146.07,62.04 145.58,62.04 145.46,61.91 145.46,61.71 145.58,61.58 146.07,61.58 146.2,61.46 146.2,61.21 146.09,61.1 145.57,61.1 145.46,60.99 145.46,60.72 145.58,60.59 146.07,60.59 146.2,60.47 146.2,58.17 146.49,57.88 146.49,56.18 v2(146.6,56.06)
  BOTTOM w0.14: JDIMM4.132 147.54,56.76 146.84,56.06 v2(146.6,56.06)
DDR_B_D37: length 75.7
  TOP w0.102: JCPU1.M1 v2(173.06,105.31)
  TOP w0.14: v2(146.6,52.12) 146.61,52.12 147.54,51.19 JDIMM3.132
  IN3 w0.089: 170.23,103.67 170.47,103.91 170.47,105.62 170.75,105.9 172.47,105.9 v2(173.06,105.31)
  IN3 w0.127: 170.23,103.67 168.63,102.07 168.63,101.27 154.11,86.75 154.11,86.49 154.35,86.25 154.35,86.01 154.18,85.84 153.94,85.84 153.69,86.09 153.45,86.09 153.02,85.66 152.79,85.66 151.4,84.27 150.77,84.27 149.52,83.02 149.52,80.73 148.55,79.75 148.55,79.22 146.1,76.78 146.1,72.89 145.39,72.19 145.39,70.45 144.87,69.93 144.87,65.55 144.45,65.12 144.45,59.72 144.99,59.18 144.99,57.96 145.48,57.47 145.48,54.97 145.79,54.65 145.79,52.93 v2(146.6,52.12)
  BOTTOM w0.14: v2(146.6,52.12) 146.64,52.12 147.84,50.93 JDIMM4.131
DDR_B_D38: length 80.3
  TOP w0.102: v2(171.06,108.31) JCPU1.L5
  TOP w0.14: JDIMM3.143 144.24,57.01 143.3,56.07 v2(143.3,56.05)
  IN3 w0.089: v2(171.06,108.31) 171.45,107.92 171.45,107.16 171.22,106.93 169.66,106.93 169.44,106.72 169.44,106.16 169.21,105.93 168.83,105.93 168.48,105.58 168.48,104.02 168.38,103.92
  IN3 w0.127: 168.38,103.92 166.9,102.44 166.9,101.64 155.27,90.01 155.09,90.01 154.92,90.18 154.74,90.18 154.56,90 154.56,89.83 154.73,89.65 154.73,89.47 154.55,89.29 154.37,89.29 154.2,89.47 154.02,89.47 153.84,89.29 153.84,89.11 154.01,88.93 154.01,88.75 153.83,88.57 153.65,88.57 153.48,88.75 153.3,88.75 153.12,88.57 153.12,88.39 153.3,88.21 153.3,88.03 153.12,87.85 152.94,87.85 152.76,88.03 152.58,88.03 152.4,87.85 152.4,87.67 152.58,87.49 152.58,87.31 152.34,87.08 152.2,87.08 150.82,85.71 150.16,85.71 148.57,84.12 148.32,84.12 144.63,80.42 144.63,79.95 144.75,79.82 145.02,79.82 145.16,79.68 145.16,79.48 145.02,79.34 144.75,79.34 144.63,79.21 144.63,73.54 143.95,72.86 143.95,72.2 143.67,71.92 143.31,71.92 142.97,71.57 142.97,71.02 142.82,70.88 142.64,70.88 142.43,71.1 142.2,71.1 142.05,70.94 142.05,70.72 142.61,70.15 142.61,65.04 142.74,64.92 142.8,64.92 142.92,64.79 142.92,64.54 142.8,64.41 142.44,64.41 142.29,64.26 142.29,64.05 142.44,63.9 142.8,63.9 142.92,63.77 142.92,63.52 142.8,63.39 142.44,63.39 142.29,63.24 142.29,63.03 142.44,62.89 142.8,62.89 142.92,62.76 142.92,62.5 142.8,62.38 142.45,62.38 142.27,62.2 142.27,59.5 142.84,58.94 143.14,58.94 143.55,58.52 143.55,58.19 143.43,58.07 143.36,58.07 143.23,57.94 143.23,56.12 v2(143.3,56.05)
  BOTTOM w0.14: v2(143.3,56.05) 143.3,56.09 144.05,56.85 144.28,56.85 144.54,57.1 JDIMM4.142
DDR_B_D39: length 80.9
  TOP w0.102: v2(173.06,108.31) 172.59,108.78 JCPU1.M5
  TOP w0.14: v2(144.33,55.66) 144.84,56.17 JDIMM3.141
  IN3 w0.089: 168.67,103.8 168.67,105.5 168.91,105.74 169.29,105.74 169.63,106.08 169.63,106.64 169.74,106.74 171.3,106.74 171.64,107.08 171.64,107.56 171.91,107.82 172.57,107.82 v2(173.06,108.31)
  IN3 w0.127: v2(144.33,55.66) 143.89,56.09 143.89,58.66 143.28,59.27 142.98,59.27 142.61,59.64 142.61,61.39 142.85,61.63 143.2,61.63 143.37,61.8 143.37,65.07 142.95,65.5 142.95,70.29 143.5,70.85 143.5,71.03 143.3,71.22 143.3,71.43 143.45,71.58 143.66,71.58 143.86,71.38 144.04,71.38 144.28,71.63 144.28,72.72 144.98,73.42 144.98,78.81 145.71,79.53 145.71,79.71 145.17,80.25 145.17,80.46 145.32,80.61 145.53,80.61 146.07,80.07 146.25,80.07 146.48,80.3 146.48,80.66 146.4,80.73 146.25,80.73 146.05,80.94 146.05,81.37 146.67,81.99 146.85,81.99 147.26,81.58 147.47,81.58 147.62,81.72 147.62,81.94 147.21,82.35 147.21,82.53 147.39,82.71 147.57,82.71 148.03,82.24 148.24,82.24 148.39,82.39 148.39,82.6 147.93,83.07 147.93,83.25 148.46,83.78 148.71,83.78 150.3,85.37 150.96,85.37 152.34,86.74 152.48,86.74 167.33,101.6 167.33,102.4 168.67,103.73 168.67,103.8
  BOTTOM w0.14: JDIMM4.140 145.14,56.47 v2(144.33,55.66)
DDR_B_D40: length 83
  TOP w0.102: v2(167.06,110.31) JCPU1.G7
  TOP w0.14: JDIMM3.149 142.44,57.17 141.32,56.05 v2(140.95,56.05)
  IN3 w0.089: 166.32,104.86 166.47,105.01 166.47,109.72 v2(167.06,110.31)
  IN3 w0.127: 166.32,104.86 147.7,86.25 147.47,86.25 142.34,81.12 142.34,80.96 142.52,80.79 142.52,80.58 142.39,80.46 141.83,80.46 141.71,80.33 141.71,80.07 141.83,79.95 142.34,79.95 142.47,79.82 142.47,79.57 142.34,79.44 141.83,79.44 141.71,79.31 141.71,79.06 141.83,78.93 142.34,78.93 142.47,78.8 142.47,78.55 142.34,78.42 141.83,78.42 141.71,78.3 141.71,78.04 141.83,77.92 142.34,77.92 142.47,77.79 142.47,77.53 142.34,77.41 141.83,77.41 141.71,77.28 141.71,77.03 141.83,76.9 142.39,76.9 142.52,76.77 142.52,76.52 142.39,76.39 141.83,76.39 141.71,76.26 141.71,76.01 141.83,75.88 142.37,75.88 142.49,75.76 142.49,75.5 142.37,75.38 141.83,75.38 141.71,75.25 141.71,74.99 141.83,74.87 142.34,74.87 142.52,74.69 142.52,74.45 142.43,74.36 141.83,74.36 141.71,74.23 141.71,73.64 139.16,71.1 139.16,65.21 139.04,65.09 138.86,65.09 138.73,64.96 138.73,64.49 139.07,64.16 139.16,64.06 139.16,63.66 138.73,63.23 138.73,62.7 139.65,61.79 139.93,61.79 140.16,61.55 140.16,56.09 140.44,55.82 140.72,55.82 v2(140.95,56.05)
  BOTTOM w0.14: JDIMM4.148 142.74,57.27 141.52,56.05 v2(140.95,56.05)
DDR_B_D41: length 85.2
  TOP w0.102: JCPU1.J8 169.53,111.84 v2(169.06,112.31)
  TOP w0.14: v2(140.95,53.51) 141.15,53.51 143.34,51.32 JDIMM3.146
  IN3 w0.089: v2(169.06,112.31) 168.63,111.88 168.63,111.02 168.44,110.83 168.44,110.11 168.15,109.82 167.82,109.82 167.46,109.46 167.46,106.17 166.93,105.64 166.93,104.52 166.81,104.4
  IN3 w0.127: v2(140.95,53.51) 140.97,53.51 141.32,53.15 141.58,53.15 141.78,53.35 141.78,56.76 141.58,56.96 140.97,56.96 140.84,57.09 140.84,57.34 140.97,57.47 141.32,57.47 141.45,57.6 141.45,57.81 141.28,57.98 140.94,57.98 140.83,58.08 140.83,62.94 140.71,63.06 139.93,63.06 139.83,63.15 139.83,68.95 140.42,69.53 140.42,71.41 143.19,74.17 143.19,81.02 147.75,85.58 147.98,85.58 166.81,104.4
  BOTTOM w0.14: JDIMM4.147 143.04,51.27 141.9,52.41 141.9,52.93 141.32,53.51 v2(140.95,53.51)
DDR_B_D42: length 83.5
  TOP w0.102: v2(167.06,112.31) 167.53,111.84 JCPU1.G8
  TOP w0.14: JDIMM3.160 139.14,50.97 138.26,51.85 138.26,52.11 v2(138.06,52.31)
  IN3 w0.089: 164.61,104.69 164.66,104.74 164.66,110.48 164.89,110.71 165.35,110.71 165.66,111.01 165.66,111.48 165.89,111.71 166.35,111.71 166.95,112.31 v2(167.06,112.31)
  IN3 w0.127: v2(138.06,52.31) 138.28,52.31 138.4,52.18 138.4,51.25 138.53,51.12 138.83,51.12 138.96,51.25 138.96,60.85 137.6,62.21 137.6,71.2 140.54,74.14 140.54,80.96 149.21,89.64 149.21,89.99 151.76,92.55 152.47,92.55 164.61,104.69
  BOTTOM w0.14: v2(138.06,52.31) 138.07,52.31 139.44,50.94 JDIMM4.159
DDR_B_D43: length 84.8
  TOP w0.102: JCPU1.G9 167.53,112.84 v2(167.06,113.31)
  TOP w0.14: JDIMM3.158 139.74,50.91 138.97,51.67 138.97,52.68 v2(138.07,53.58)
  IN3 w0.089: v2(167.06,113.31) 167.06,112.95 166.66,112.55 166.66,112.28 166.28,111.9 165.81,111.9 165.47,111.55 165.47,111.09 165.28,110.9 164.81,110.9 164.47,110.55 164.47,105.02 164.29,104.84
  IN3 w0.127: v2(138.07,53.58) 138.15,53.58 138.58,54.01 138.58,56.21 138.4,56.38 138.4,56.66 138.58,56.83 138.58,57.04 138.4,57.21 138.28,57.21 138.15,57.34 138.15,57.6 138.28,57.72 138.4,57.72 138.58,57.9 138.58,58.09 138.44,58.23 138.28,58.23 138.15,58.36 138.15,58.61 138.28,58.74 138.4,58.74 138.58,58.92 138.58,59.12 138.45,59.25 138.28,59.25 138.07,59.45 138.07,61.26 137.26,62.07 137.26,71.34 140.2,74.28 140.2,81.1 148.87,89.78 148.87,90.13 151.62,92.88 152.33,92.88 164.29,104.84
  BOTTOM w0.14: v2(138.07,53.58) 138.07,53.53 138.7,52.91 138.7,52.22 140.04,50.88 JDIMM4.157
DDR_B_D44: length 83.6
  TOP w0.102: v2(169.06,111.31) 169.53,110.84 JCPU1.J7
  TOP w0.14: JDIMM3.148 142.74,50.7 141.21,52.23 141.01,52.23 v2(140.95,52.24)
  IN3 w0.089: v2(169.06,111.31) 169.06,111.18 168.63,110.75 168.63,109.2 168.27,108.84 167.94,108.84 167.65,108.55 167.65,106.09 167.12,105.56 167.12,104.24
  IN3 w0.127: 167.12,104.24 167.12,104.22 151.1,88.2 151.1,88.2 148.14,85.24 147.89,85.24 143.52,80.88 143.52,73.99 140.76,71.23 140.76,66.1 140.63,65.98 140.31,65.98 140.18,65.85 140.18,65.6 140.31,65.47 140.8,65.47 140.94,65.32 140.94,65.09 140.82,64.96 140.31,64.96 140.18,64.83 140.18,64.58 140.31,64.45 141.07,64.45 141.17,64.35 141.17,64.07 141.04,63.95 140.31,63.95 140.18,63.82 140.18,63.56 140.31,63.44 140.94,63.44 141.17,63.21 141.17,58.56 142.11,57.62 142.11,53.18 141.17,52.24 v2(140.95,52.24)
  BOTTOM w0.14: v2(140.95,52.24) 141.48,52.24 142.44,51.28 JDIMM4.149
DDR_B_D45: length 84.5
  TOP w0.102: JCPU1.J9 169.53,112.84 v2(169.06,113.31)
  TOP w0.14: JDIMM3.147 143.04,56.86 v2(140.95,54.78)
  IN3 w0.089: 166.53,104.6 166.66,104.73 166.66,109.59 166.89,109.82 167.31,109.82 167.61,110.12 167.61,110.49 167.91,110.78 168.12,110.78 168.44,111.1 168.44,112.69 v2(169.06,113.31)
  IN3 w0.127: v2(140.95,54.78) 140.95,54.67 141.08,54.55 141.32,54.55 141.44,54.66 141.44,56.45 141.31,56.58 140.63,56.58 140.5,56.71 140.5,62.04 140.37,62.17 139.74,62.17 139.07,62.84 139.07,63.09 139.5,63.52 139.5,64.2 139.17,64.53 139.17,64.71 139.5,65.04 139.5,69.49 139.67,69.66 139.93,69.66 140.05,69.79 140.05,70.04 139.93,70.17 139.63,70.17 139.5,70.3 139.5,70.5 139.67,70.68 139.93,70.68 140.05,70.8 140.05,71.51 142.85,74.31 142.85,81.16 147.61,85.91 147.84,85.91 166.53,104.6
  BOTTOM w0.14: JDIMM4.146 143.34,57.16 141.97,55.79 141.97,55.48 141.27,54.78 v2(140.95,54.78)
DDR_B_D46: length 84.5
  TOP w0.102: v2(167.06,114.31) 167.53,113.84 JCPU1.G10
  TOP w0.14: JDIMM3.157 140.04,56.78 138.11,54.85 v2(138.07,54.85)
  IN3 w0.089: v2(167.06,114.31) 166.46,113.71 166.46,113.14 166.22,112.9 165.77,112.9 165.47,112.6 165.47,112.09 165.28,111.9 164.81,111.9 164.47,111.55 164.47,111.09 164.28,110.9 163.81,110.9 163.47,110.55 163.47,110.1 163.19,109.82 163.14,109.82
  IN3 w0.127: v2(138.07,54.85) 137.4,55.52 137.4,60.98 136.59,61.8 136.59,62.17 136.46,62.29 136.12,62.29 135.99,62.42 135.99,62.68 136.12,62.8 136.5,62.8 136.59,62.89 136.59,63.18 136.46,63.31 136.02,63.31 135.9,63.44 135.9,71.14 138.24,73.48 138.24,74.33 139.53,75.63 139.53,81.38 148.2,90.05 148.2,90.41 151.35,93.55 152.05,93.55 162.51,104.01 162.51,109.51 162.81,109.82 163.14,109.82
  BOTTOM w0.14: v2(138.07,54.85) 138.5,55.28 138.5,55.41 139.74,56.65 JDIMM4.158
DDR_B_D47: length 83.1
  TOP w0.102: JCPU1.J10 169.53,113.84 v2(169.06,114.31)
  TOP w0.14: JDIMM3.159 139.44,57.23 138.33,56.12 v2(138.07,56.12)
  IN3 w0.089: 163.52,109.72 163.52,109.81 163.66,109.94 163.66,110.44 163.93,110.71 164.35,110.71 164.66,111.01 164.66,111.44 164.93,111.71 165.35,111.71 165.66,112.01 165.66,112.44 165.93,112.71 166.29,112.71 166.65,113.06 166.65,113.43 167.02,113.8 168.55,113.8 v2(169.06,114.31)
  IN3 w0.127: v2(138.07,56.12) 137.74,56.46 137.74,61.12 136.92,61.93 136.92,63.34 136.57,63.69 136.37,63.69 136.24,63.82 136.24,64.07 136.37,64.2 136.75,64.2 136.88,64.33 136.88,64.58 136.75,64.71 136.37,64.71 136.24,64.83 136.24,65.09 136.37,65.22 136.6,65.22 136.73,65.34 136.73,65.62 136.23,66.12 136.23,71 138.57,73.34 138.57,74.2 138.99,74.61 139.29,74.61 139.61,74.29 139.74,74.29 139.87,74.42 139.87,74.8 139.67,74.99 139.67,75.18 139.87,75.38 139.87,81.24 148.54,89.92 148.54,90.27 151.49,93.22 152.19,93.22 163.52,104.55 163.52,109.72
  BOTTOM w0.14: v2(138.07,56.12) 138.2,56.12 139.14,57.06 JDIMM4.160
DDR_B_D48: length 85.4
  TOP w0.102: v2(161.06,112.31) 161.53,111.84 JCPU1.A8
  TOP w0.14: JDIMM3.163 138.24,57.01 135.97,54.74 v2(135.92,54.74)
  IN3 w0.127: v2(161.06,112.31) 161.06,111.95 160.65,111.54 160.65,111.34 159.83,110.52 159.83,103.36 152.67,96.21 152.49,96.21 152.12,96.58 151.94,96.58 151.76,96.4 151.76,96.22 152.11,95.87 152.11,95.69 151.95,95.53 151.78,95.53 151.45,95.86 151.27,95.86 151.13,95.72 151.13,95.54 151.36,95.31 151.36,95.12 151.23,94.99 150.65,94.99 150.34,94.68 150.09,94.68 149.67,95.1 149.49,95.1 149.29,94.9 149.29,94.72 149.73,94.27 149.73,94.09 149.56,93.92 149.38,93.92 149.01,94.3 148.62,94.3 142.76,88.43 142.76,86.64 138.09,81.98 138.09,76.22 136.8,74.93 136.8,74.56 133.28,71.05 133.28,66.07 134.01,65.34 134.01,61.99 135.1,60.9 135.1,54.55 135.23,54.42 135.6,54.42 v2(135.92,54.74)
  BOTTOM w0.14: v2(135.92,54.74) 135.99,54.74 137.94,56.69 JDIMM4.164
DDR_B_D49: length 85.4
  TOP w0.102: JCPU1.B8 162.53,111.84 v2(162.06,112.31)
  TOP w0.14: v2(135.92,56.01) 136.5,56.01 137.64,57.15 JDIMM3.165
  IN3 w0.127: v2(162.06,112.31) 161.47,111.72 161.47,111.09 161.16,110.78 160.86,110.78 160.16,110.09 160.16,103.22 151.59,94.65 150.79,94.65 149.57,93.44 149.39,93.44 148.9,93.93 148.72,93.93 148.55,93.75 148.55,93.57 149.03,93.08 149.03,92.9 148.85,92.72 148.67,92.72 148.19,93.21 148.01,93.21 147.83,93.03 147.83,92.85 148.33,92.34 148.33,92.16 148.08,91.91 147.9,91.91 147.45,92.37 147.27,92.37 147.07,92.17 147.07,91.99 147.52,91.53 147.52,91.35 147.32,91.15 147.14,91.15 146.68,91.6 146.5,91.6 146.3,91.4 146.3,91.22 146.7,90.83 146.7,90.65 146.49,90.45 146.31,90.45 145.9,90.87 145.67,90.87 143.09,88.29 143.09,86.5 138.43,81.84 138.43,76.08 137.14,74.79 137.14,73.94 134.34,71.14 134.34,62.13 135.45,61.03 135.45,58.65 135.61,58.48 135.99,58.48 136.12,58.36 136.12,58.1 135.99,57.98 135.57,57.98 135.45,57.85 135.45,57.63 135.61,57.47 135.99,57.47 136.12,57.34 136.12,57.09 135.99,56.96 135.53,56.96 135.45,56.88 135.45,56.13 135.57,56.01 v2(135.92,56.01)
  BOTTOM w0.14: v2(135.92,56.01) 136.6,56.01 137.34,56.74 JDIMM4.166
DDR_B_D50: length 85.2
  TOP w0.102: v2(161.06,113.31) 161.53,112.84 JCPU1.A9
  TOP w0.14: v2(132.7,52.24) 133.38,52.24 134.34,51.28 JDIMM3.176
  IN3 w0.089: v2(161.06,113.31) 160.96,113.31 160.12,112.47
  IN3 w0.127: 160.12,112.47 158.43,110.78 158.43,103.78 152.31,97.66 150.43,97.66 141.64,88.88 141.64,87.07 136.94,82.37 136.94,76.71 135.7,75.47 135.7,75.06 132.2,71.56 132.2,65.54 132.9,64.84 132.9,59.66 133.46,59.09 133.46,53.77 133.8,53.43 133.8,53.15 133.68,53.02 133.32,53.02 133.2,52.9 133.2,52.64 133.32,52.52 133.96,52.52 134.09,52.39 134.09,52.13 133.96,52.01 132.83,52.01 132.7,52.13 v2(132.7,52.24)
  BOTTOM w0.14: v2(132.7,52.24) 133.28,52.24 134.04,51.47 JDIMM4.177
DDR_B_D51: length 87.5
  TOP w0.102: v2(162.06,113.31) 162.53,112.84 JCPU1.B9
  TOP w0.14: v2(132.7,53.51) 132.71,53.51 134.94,51.28 JDIMM3.174
  IN3 w0.089: 160.12,112.94 160.89,113.71 161.66,113.71 162.06,113.31 v2(162.06,113.31)
  IN3 w0.127: v2(132.7,53.51) 132.94,53.51 133.13,53.69 133.13,57.98 132.93,58.18 132.93,58.48 133.13,58.68 133.13,58.95 132.56,59.52 132.56,61.98 132.05,62.49 132.05,63.06 132.18,63.18 132.43,63.18 132.56,63.31 132.56,63.56 132.43,63.69 132.18,63.69 132.05,63.82 132.05,64.07 132.18,64.2 132.43,64.2 132.56,64.33 132.56,64.58 132.43,64.71 132.03,64.71 131.23,65.51 131.23,71.07 135.36,75.2 135.36,75.6 136.61,76.85 136.61,82.51 141.31,87.21 141.31,89.02 150.29,98 152.17,98 158.03,103.86 158.03,110.85 160.12,112.94
  BOTTOM w0.14: JDIMM4.175 134.64,51.57 v2(132.7,53.51)
DDR_B_D52: length 88.6
  TOP w0.102: v2(164.06,112.31) 164.53,111.84 JCPU1.D8
  TOP w0.14: JDIMM3.164 137.94,51.44 v2(135.92,53.47)
  IN3 w0.127: v2(135.92,53.47) 136.24,53.79 136.5,53.79 136.63,53.66 136.63,52.01 136.75,51.88 137.01,51.88 137.13,52.01 137.13,54.09 136.93,54.29 136.63,54.29 136.5,54.42 136.5,58.74 136.37,58.87 135.91,58.87 135.78,58.99 135.78,61.17 134.68,62.27 134.68,71.01 137.47,73.8 137.47,74.65 138.76,75.94 138.76,81.7 143.43,86.36 143.43,87.27 145.35,89.2 145.88,89.2 151,94.32 151.73,94.32 160.53,103.11 160.53,109.54 160.83,109.84 161.29,109.84 161.54,110.1 161.54,110.5 161.87,110.83 162.23,110.83 162.58,111.19 162.58,111.6 162.81,111.82 163.57,111.82 v2(164.06,112.31)
  BOTTOM w0.14: JDIMM4.163 138.24,51.29 136.06,53.47 v2(135.92,53.47)
DDR_B_D53: length 87.7
  TOP w0.102: v2(165.06,112.31) 165.53,111.84 JCPU1.E8
  TOP w0.14: JDIMM3.166 137.34,51.1 137.21,51.23 136.76,51.23 v2(135.92,52.07)
  IN3 w0.127: v2(165.06,112.31) 164.72,112.31 164.21,111.8 163.98,111.8 163.47,111.29 163.47,111.11 163.22,110.86 162.81,110.86 162.46,110.5 162.46,110.1 162.15,109.79 161.85,109.79 161.52,109.46 161.52,103.63 151.87,93.98 151.14,93.98 146.02,88.86 145.49,88.86 143.76,87.14 143.76,86.22 139.1,81.56 139.1,75.81 137.81,74.51 137.81,73.66 135.01,70.87 135.01,62.41 136.12,61.3 136.12,59.37 136.24,59.25 136.75,59.25 136.88,59.12 136.88,55.31 137.51,54.67 137.51,51.99 137.63,51.88 137.77,51.88 137.9,51.75 137.9,51.5 137.77,51.37 135.28,51.37 135.15,51.5 135.15,51.94 135.28,52.07 v2(135.92,52.07)
  BOTTOM w0.14: JDIMM4.165 137.64,51.14 136.69,52.09 135.95,52.09 135.92,52.06 v2(135.92,52.07)
DDR_B_D54: length 88.2
  TOP w0.102: JCPU1.D9 164.53,112.84 v2(164.06,113.31)
  TOP w0.14: v2(132.69,56.05) 133.32,56.05 134.04,56.77 JDIMM3.177
  IN3 w0.089: 160.12,113.41 160.61,113.91 163.46,113.91 v2(164.06,113.31)
  IN3 w0.127: 160.12,113.41 157.69,110.99 157.69,104 152.03,98.33 150.15,98.33 140.97,89.16 140.97,87.35 139.41,85.8 139.23,85.8 139.03,86 139.03,86.18 140.47,87.63 140.47,87.81 140.3,87.99 140.12,87.99 138.56,86.42 138.56,84.94 136.27,82.65 136.27,76.99 135.03,75.74 135.03,75.34 130.9,71.21 130.9,65.37 131.72,64.55 131.72,62.35 132.23,61.84 132.23,59.38 132.59,59.02 132.59,56.14 v2(132.69,56.05)
  BOTTOM w0.14: v2(132.69,56.05) 133.27,56.05 134.34,57.12 JDIMM4.176
DDR_B_D55: length 88.7
  TOP w0.102: v2(165.06,113.31) 165.53,112.84 JCPU1.E9
  TOP w0.14: JDIMM3.175 134.64,56.72 132.7,54.78 v2(132.7,54.78)
  IN3 w0.089: v2(165.06,113.31) 165.06,113.31 164.53,113.84 164.53,114.36 164.19,114.71 160.69,114.71 160.12,114.14
  IN3 w0.127: 160.12,114.14 156.59,110.61 156.59,103.37 151.89,98.67 150.01,98.67 138.22,86.88 138.22,85.08 135.94,82.79 135.94,77.13 134.69,75.88 134.69,75.48 130.56,71.35 130.56,65.13 131.38,64.31 131.38,62.21 131.89,61.7 131.89,59.24 132.26,58.88 132.26,55.22 v2(132.7,54.78)
  BOTTOM w0.14: v2(132.7,54.78) 132.8,54.78 134.54,56.53 134.54,56.77 134.94,57.16 JDIMM4.174
DDR_B_D56: length 96.5
  TOP w0.102: v2(165.06,119.31) 165.53,118.84 JCPU1.E15
  TOP w0.14: v2(130.73,56.13) 131.44,56.13 132.24,56.92 JDIMM3.183
  IN3 w0.089: v2(165.06,119.31) 164.64,119.31 164.21,118.89 164.07,118.89 163.66,118.47 163.66,118 163.36,117.71 162.89,117.71 162.65,117.47 162.65,116.19 162.33,115.87 160.72,115.87
  IN3 w0.127: 160.72,115.87 160.29,115.87 155.49,111.07 155.49,103.95 151.31,99.77 149.55,99.77 137.12,87.34 137.12,85.53 134.83,83.25 134.83,77.58 134.6,77.35 134.42,77.35 134.23,77.54 134.05,77.54 133.87,77.36 133.87,77.18 134.05,77 134.05,76.82 133.88,76.65 133.7,76.65 133.54,76.81 133.36,76.81 133.16,76.61 133.16,76.43 133.53,76.06 133.53,75.88 133.34,75.69 133.16,75.69 132.77,76.08 132.59,76.08 132.41,75.9 132.41,75.72 132.8,75.33 132.8,75.15 132.66,75.02 132.48,75.02 132.1,75.4 131.93,75.4 131.79,75.26 131.79,75.08 132.13,74.74 132.13,74.47 128.78,71.12 128.78,66.51 128.93,66.36 129.26,66.36 129.39,66.23 129.39,65.98 129.26,65.85 128.9,65.85 128.78,65.72 128.78,65.47 128.9,65.34 129.26,65.34 129.39,65.22 129.39,64.96 129.26,64.83 128.5,64.83 128.37,64.71 128.37,64.44 128.49,64.33 128.89,64.33 129.01,64.2 129.01,63.8 129.7,63.12 129.7,60.67 130.28,60.08 130.58,60.08 130.71,59.96 130.71,59.73 130.58,59.6 130.39,59.6 130.27,59.47 130.27,59.31 131.11,58.47 131.11,57.37 130.65,56.91 130.65,56.21 v2(130.73,56.13)
  BOTTOM w0.14: v2(130.73,56.13) 131.54,56.13 132.54,57.13 JDIMM4.182
DDR_B_D57: length 97.4
  TOP w0.102: JCPU1.D15 164.53,118.84 v2(164.06,119.31)
  TOP w0.14: JDIMM3.181 132.84,56.98 132.12,56.26 132.12,55.99 v2(130.73,54.6)
  IN3 w0.089: 160.83,116.71 162.03,116.71 162.46,117.14 162.46,117.55 162.82,117.91 163.22,117.91 163.47,118.15 163.47,118.56 164.06,119.15 v2(164.06,119.31)
  IN3 w0.127: 160.83,116.71 160.75,116.63 160.58,116.63 155.15,111.21 155.15,104.09 151.17,100.11 149.42,100.11 134.52,85.21 134.52,85.03 134.76,84.79 134.94,84.79 136.23,86.08 136.41,86.08 136.67,85.82 136.67,85.64 134.5,83.48 134.5,78.47 130.91,74.88 130.91,73.73 127.92,70.74 127.92,64.34 129.36,62.9 129.36,60.53 129.93,59.96 129.93,59.17 130.77,58.33 130.77,57.51 130.31,57.05 130.31,55.02 v2(130.73,54.6)
  BOTTOM w0.14: JDIMM4.180 133.14,57.14 131.4,55.4 131.4,55.3 130.73,54.63 v2(130.73,54.6)
DDR_B_D58: length 98.7
  TOP w0.102: v2(161.06,119.31) 161.53,118.84 JCPU1.A15
  TOP w0.14: JDIMM3.193 129.24,57 129.03,56.79 127.41,56.79 126.87,56.25 126.87,54.99 v2(127.32,54.54)
  IN3 w0.127: v2(127.32,54.54) 126.69,53.91 126.34,53.91 126.21,53.79 126.21,53.53 126.34,53.4 126.72,53.4 126.85,53.28 126.85,52.64 126.72,52.52 125.9,52.52 125.77,52.64 125.77,71.94 126.99,73.15 126.99,74.22 132.23,79.46 132.23,85.98 143.28,97.02 143.28,99.23 145.42,101.38 145.42,105.95 147.99,108.52 149.04,108.52 159.94,119.42 160.58,119.42 160.63,119.37 161,119.37 v2(161.06,119.31)
  BOTTOM w0.14: v2(127.32,54.54) 127.32,54.52 127.32,54.52 v2(127.32,54.54) ; v2(127.32,54.54) 127.29,54.54 126.87,54.96 126.87,56.35 127.36,56.84 128.65,56.84 128.94,57.13 JDIMM4.194
