# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KC_FBMA-L11-201209-221LMA30_2P
  rect 0.838x1.397 smd: 1(0,0) 2(1.65,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_1812-1806
  oval 1.016x3.708 smd: 1(0,0) 2(4.013,0)
LBSS138LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LCN_DAN08-52526-0100_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(26.45,0.6) 54(-2.85,0.6)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LOTES_AUSB0041-P002A_9P
  round 1.295 hole 0.787: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(-2.9,-2.1) 11(9.9,-2.1)
  oval 1.397x3.2 hole 0.787x1.499: 12(-2.9,-7.15) 13(9.9,-7.15)
MAX14885EETLLFT_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
MEC5075-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG121SN1D_L0402_2P
  rect 0.457x0.711 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB470SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18PG181SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLW21SN121SQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM18FN4R7M00D_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
NEC_MPC0740LR42C_2P
  rect 2.692x2.591 smd: 1(0,0) 2(6.2,0)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NTGD4161PT1G_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
OCTEK_SAT-22PDAB_22P
  oval 0.889x2.896 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(13.97,0) 9(15.24,0) 10(16.51,0) 11(17.78,-0.5) 12(19.05,0) 13(20.32,0) 14(21.59,0) 15(22.86,0) 16(24.13,0) 17(25.4,0) 18(26.67,0) 19(27.94,-0.5) 20(29.21,0) 21(30.48,0) 22(31.75,0)
  oval 1.6x2.997 hole 0.991x2.388: 23(-2.835,-1.48) 24(34.585,-1.48)
OCTEK_SLS-13SZAB_13P
  oval 0.787x2.388 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0)
  oval 0.711x2.388 smd: 8(13.83,0) 9(14.83,0) 10(15.83,0) 11(16.83,0) 12(17.83,0) 13(18.83,0)
  oval 1.803x3.251 hole 0.991x2.438: 14(-1.82,0.35) 15(20.58,0.35)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PDTA114EU_SC70-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PS8330BQFN48GTR-A0_QFN48_7X7
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,6.95) 26(5,6.95) 27(4.5,6.95) 28(4,6.95) 29(3.5,6.95) 30(3,6.95) 31(2.5,6.95) 32(2,6.95) 33(1.5,6.95) 34(1,6.95) 35(0.5,6.95) 36(0,6.95)
  oval 1.041x0.254 smd: 13(6.225,0.725) 14(6.225,1.225) 15(6.225,1.725) 16(6.225,2.225) 17(6.225,2.725) 18(6.225,3.225) 19(6.225,3.725) 20(6.225,4.225) 21(6.225,4.725) 22(6.225,5.225) 23(6.225,5.725) 24(6.225,6.225) 37(-0.725,6.225) 38(-0.725,5.725) 39(-0.725,5.225) 40(-0.725,4.725) 41(-0.725,4.225) 42(-0.725,3.725) 43(-0.725,3.225) 44(-0.725,2.725) 45(-0.725,2.225) 46(-0.725,1.725) 47(-0.725,1.225) 48(-0.725,0.725)
  rect 3.708x3.708 smd: 49(2.75,3.475)
PS8331BQFN60GTR-A0_QFN60_5X9
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8339BQFN56GTR2-A0_QFN56_7X7
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 29(5.2,6.95) 30(4.8,6.95) 31(4.4,6.95) 32(4,6.95) 33(3.6,6.95) 34(3.2,6.95) 35(2.8,6.95) 36(2.4,6.95) 37(2,6.95) 38(1.6,6.95) 39(1.2,6.95) 40(0.8,6.95) 41(0.4,6.95) 42(0,6.95)
  oval 1.041x0.203 smd: 15(6.075,0.875) 16(6.075,1.275) 17(6.075,1.675) 18(6.075,2.075) 19(6.075,2.475) 20(6.075,2.875) 21(6.075,3.275) 22(6.075,3.675) 23(6.075,4.075) 24(6.075,4.475) 25(6.075,4.875) 26(6.075,5.275) 27(6.075,5.675) 28(6.075,6.075) 43(-0.875,6.075) 44(-0.875,5.675) 45(-0.875,5.275) 46(-0.875,4.875) 47(-0.875,4.475) 48(-0.875,4.075) 49(-0.875,3.675) 50(-0.875,3.275) 51(-0.875,2.875) 52(-0.875,2.475) 53(-0.875,2.075) 54(-0.875,1.675) 55(-0.875,1.275) 56(-0.875,0.875)
  rect 4.699x3.912 smd: 57(2.6,3.475)
PS8513CTQFN20GTR2-A_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
PS8520CTQFN20GTR2-A_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
PS8713BTQFN24GTR2_TQFN24_4X4
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.975) 14(2,3.975) 15(1.5,3.975) 16(1,3.975) 17(0.5,3.975) 18(0,3.975)
  oval 1.016x0.254 smd: 7(3.238,0.738) 8(3.238,1.238) 9(3.238,1.738) 10(3.238,2.238) 11(3.238,2.738) 12(3.238,3.238) 19(-0.738,3.238) 20(-0.738,2.738) 21(-0.738,2.238) 22(-0.738,1.738) 23(-0.738,1.238) 24(-0.738,0.738)
  rect 2.692x2.692 smd: 25(1.25,1.988)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751S40T1_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
RTD2136S-VE-CG_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 3.962x3.962 smd: 49(2.2,2.975)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130454-H_13P
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  round 1.295 hole 0.991: 9(-9.485,-1.48) 10(-10.63,-2.58) 11(-8.34,-2.58) 12(1.2,-2.58) 13(3.49,-2.58)
  oval 1.372x3.15 hole 0.61x2.388: 14(-11.57,-7.9) 15(4.43,-7.9)
SBR3A40SA-13_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI4164DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835DDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7447DP_SO8_5P
  oval 0.635x1.778 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.962)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SLG55594AVTR_TDFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.651x0.889 smd: 9(0.75,1.1)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SUYIN_070449HR015M221ZR_15P
  round 1.651 hole 1.651 unplated: (-4.05,0.2) (11.93,0.2)
  round 1.016 hole 0.61: 1(0,0) 2(2.289,-1) 3(4.578,0) 4(6.867,-1) 5(9.156,0) 6(-1.526,0) 7(0.763,-1) 8(3.052,0) 9(5.341,-1) 10(7.63,0) 11(-0.763,-1) 12(1.526,0) 13(3.815,-1) 14(6.104,0) 15(8.393,-1)
  oval 3.81x1.753 hole 3.048x0.991: 16(-8.559,-0.6) 18(16.432,-0.6)
  oval 1.753x2.87 hole 0.991x2.108: 17(-7.53,-1.159) 19(17.46,-1.159)
SUYIN_200045GR009M28QZR_9P
  round 1.6 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.6x3.454 hole 0.991x2.845: 10(-3.125,0) 11(19.125,0)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SY8033BDBC_DFN10_3X3
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.7) 7(1.5,2.7) 8(1,2.7) 9(0.5,2.7) 10(0,2.7)
  rect 2.591x1.753 smd: 11(1,1.35)
T-SOL_159-1000302602_10P-T
  round 0.889 hole 0.889 unplated: (2.885,-1.425) (3.075,-14.375)
  oval 0.508x1.245 smd: 1(0,0) 2(-1.4,0) 3(-2.8,0) 4(-4.2,0) 5(-0.7,0) 6(-2.1,0) 7(-3.5,0) 8(-4.9,0) 9(-5.6,0) 10(0.7,0)
  rect 0.889x1.397 smd: 11(3.355,0.075) 18(-6.755,0.075)
  rect 0.381x1.6 smd: 12(5.11,-2.475)
  rect 0.381x1.499 smd: 13(5.11,-9.325) 16(-9.22,-9.325)
  rect 1.092x1.092 smd: 14(4.745,-15.145) 15(-8.855,-15.145)
  rect 0.381x1.245 smd: 17(-9.22,-3.085)
TAI-T_VMPI0703AR-4R7M-Z01_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIWI_EU093-117CRL-TW_11P
  round 1.702 hole 1.702 unplated: (-3.7,-0.63) (10.7,-0.63)
  round 1.168 hole 0.914: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0)
  round 1.016 hole 0.762: 5(7.31,1.25) 6(6.04,1.25) 7(4.77,1.25) 8(3.5,1.25) 9(2.23,1.25) 10(0.96,1.25) 11(-0.31,1.25)
  oval 1.372x2.667 hole 0.61x1.905: 12(-5.7,0.97) 13(-5.7,-6.23) 14(12.7,-6.23) 15(12.7,0.97)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SH125FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDSD0630-H-2R2M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDV0630-3R3M-P3_2P
  rect 2.007x3.505 smd: 1(0,0) 2(6,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2560DRCR-PG1P1_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS2560DRCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS22965DSGR_SON8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TS3DV20812RHHR_VQFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
TYCO_1-2041070-6_16P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 2.489x1.905 smd: 17(2.15,3.3) 18(-9.65,3.3)
TYCO_2-2013289-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(-64.45,-16.1) 206(1.15,-16.1)
TYCO_2-2013290-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
TYCO_2-2013310-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 4.699x6.807 smd: 205(-69,-15.4) 206(5.7,-15.4)
TYCO_2-2041070-0_20P-T
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 2.489x1.905 smd: 21(-11.65,3.3) 22(2.15,3.3)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI217LM-QPN9-A2_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR208.1 RP4.3 U46.A60
1.05V_0.8V_PWROK: PR517.1 RP7.5 U50.4
1.05V_A_PWRGD: PR300.1 PU300.1 U51.B28
1.5V_RUN_PWRGD: PR400.2 PU400.4 U50.1
1.5VSP_FB: PC402.2 PR402.2 PR405.1 PU400.6
1.5VSP_LX: PL401.1 PR401.1 PU400.2 PU400.3
1.5VSP_VIN: PC400.1 PJP400.1 PU400.8 PU400.9 PU400.10
1.35V_B+: PC202.1 PC203.1 PC204.1 PC205.1 PJP200.1 PQ201.5 PR205.1
1.35V_FB: PC211.1 PR204.2 PR207.2 PR211.2 PR218.1 PU200.6
1.35V_SUS_PWRGD: PR209.2 PU200.10 RC46.1 RC103.2 U51.B9
3.3V_RUN_GFX_ON: C362.1 Q87.2 QH3.2 R301.1 U34.3 U35.3 U46.A55
3V_5V_EN: PC120.1 PR111.2 PR112.2 PU101.6 PU101.20
3V_PWROK#: R391.2 U29.12
+0.9V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+0.675V_DDR_VTT: CD17.1 CD18.1 CD19.1 CD20.1 CD37.1 CD38.1 CD39.1 CD40.1 CD59.1 CD60.1 CD61.1 CD62.1 CD81.1 CD82.1 CD83.1 CD84.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 JDIMM3.203 JDIMM3.204 JDIMM4.203 JDIMM4.204 PJP202.1
+0.675V_P: PC207.1 PC208.1 PJP202.2 PU200.2 PU200.20
+1.05V_M: CH28.1 CH29.1 CH30.1 PJP301.1 PJP302.1 Q63.5 Q63.6 Q63.7 Q63.8 RH234.1 RH236.2 RH239.1 UH1.AA18 UH1.L17 UH1.R18 UH1.U18 UH1.U20 UH1.U22 UH1.U24 UH1.V18 UH1.V20 UH1.V22 UH1.V24 UH1.Y18 UH1.Y20 UH1.Y22
+1.05V_MP: PC301.1 PJP301.2 PJP302.2 PL301.2 PR306.1
+1.05V_RUN: C772.1 CH21.1 CH22.1 CH23.1 CH24.1 CH25.1 CH34.1 CH35.1 CH36.1 CH37.1 CH38.1 CH47.1 CH50.1 CH60.1 JXDP2.40 Q63.1 Q63.2 Q63.3 R866.2 R925.1 R931.1 R1179.1 RC4.2 RC17.1 RC27.1 RC29.1 RC32.1 RC35.1 RC69.1 RC99.2 RC105.2 RC126.1 RH206.1 RH241.1 RH243.1 RH244.1 UH1.AA24 UH1.AA26 UH1.AD20 UH1.AD22 UH1.AD24 UH1.AD26 UH1.AD28 UH1.AE18 UH1.AE20 UH1.AE22 UH1.AE24 UH1.AE26 UH1.AG18 UH1.AG20 UH1.AG22 UH1.AG24 UH1.AK18 UH1.AK20 UH1.AK22 UH1.AM18 UH1.AM20 UH1.AM22 UH1.AN34 UH1.AN35 UH1.AP22 UH1.AR22 UH1.AT22 UH1.U30 UH1.U35 UH1.U36 UH1.V28 UH1.V30 UH1.Y26 UH1.Y30
+1.5V_RUN: C724.1 CH26.1 CH31.1 CH32.1 CH33.1 CH52.1 JIO1.76 JIO1.78 LH1.1 PJP401.1 RH51.1 RH57.2 RH96.1 RH98.2 RH99.1 RH100.1 RH163.2 RH165.2 RH188.1 RH192.1 UH1.AF34 UH1.AK26 UH1.AK28 UH1.AN11 UH1.AW40 UH1.BB44 UH1.BE22
+1.05V_RUN_CHG: Q70.1 R925.2
+1.05V_RUN_ENABLE: C773.1 Q63.4 Q304.3 R930.2 R933.2 R1611.1
+1.05V_RUN_VCC: LH2.1 RH241.2
+1.5V_RUNP: PC402.1 PC403.1 PC404.1 PJP401.2 PL401.2 PR402.1
+1.05VSP_B+: PC302.1 PC303.1 PC304.1 PC305.1 PJP300.2 PQ301.5
+1.35V_MEM: CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC161.1 CC162.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC168.1 CC169.1 CC170.1 CC171.1 CC172.1 CD2.1 CD3.1 CD4.1 CD5.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD46.1 CD47.1 CD48.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 JCPU1.AB2 JCPU1.AB5 JCPU1.AB8 JCPU1.AB11 JCPU1.AE2 JCPU1.AE5 JCPU1.AE8 JCPU1.AE11 JCPU1.AH11 JCPU1.K11 JCPU1.N8 JCPU1.N11 JCPU1.T2 JCPU1.T5 JCPU1.T8 JCPU1.T11 JCPU1.W2 JCPU1.W5 JCPU1.W8 JCPU1.W11 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM3.75 JDIMM3.76 JDIMM3.81 JDIMM3.82 JDIMM3.87 JDIMM3.88 JDIMM3.93 JDIMM3.94 JDIMM3.99 JDIMM3.100 JDIMM3.105 JDIMM3.106 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM4.75 JDIMM4.76 JDIMM4.81 JDIMM4.82 JDIMM4.87 JDIMM4.88 JDIMM4.93 JDIMM4.94 JDIMM4.99 JDIMM4.100 JDIMM4.105 JDIMM4.106 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 PJP203.1 PJP204.1 RC16.1 RD5.1 RD44.1 RD47.1 RD50.1
+1.35V_MEN_P: PC201.1 PC211.2 PC214.1 PJP201.1 PJP203.2 PJP204.2 PL201.1 PR204.1 PU200.5
+3.3V_ALW: C90.1 C92.1 C289.1 C720.1 C723.1 C726.1 C727.1 C756.1 C778.1 JAPS1.7 JIO1.2 JKB1.7 JKB1.8 PC733.2 PC1080.2 PC1081.2 PJP29.1 PJP65.1 PJP100.2 PJP101.2 PJP400.2 PR2.1 PR8.2 PR21.1 PR119.2 PR209.1 PR213.1 PR216.1 PR221.1 PR222.1 PR300.2 PR749.1 PR757.1 PR764.1 PR1025.2 PR1083.1 PU704.5 PU1080.5 PU1081.5 Q90.3 R11.1 R14.1 R94.2 R386.1 R396.1 R397.1 R418.1 R420.1 R426.1 R515.1 R755.1 R759.1 R760.1 R763.1 R768.1 R779.1 R800.1 R805.1 R814.1 R817.1 R834.1 R838.1 R841.1 R845.1 R847.1 R848.1 R849.1 R850.1 R858.1 R859.1 R860.1 R861.1 R864.1 R871.1 R872.1 R875.1 R932.1 R937.1 R938.1 R1125.1 R1126.1 R1633.2 R1980.1 R1981.1 R2158.1 RH238.1 RH246.1 RP1.1 RP1.2 RP1.3 RP1.4 RP2.1 RP2.2 RP2.3 RP2.4 RP5.1 RP5.2 RP5.3 RP5.4 U12.5 U16.5 U17.5 U28.4 U28.5 U34.1 U34.2 U36.1 U36.2 U36.6 U36.7 U37.1 U37.2 U40.1 U40.2 U40.6 U40.7 U42.1 U42.2 U43.1 U43.2 U49.1 U49.2 U50.5 U54.5 U55.5 U58.5 U63.1 U63.2
+3.3V_ALW2: CH11.1 PC114.2 PQ1072.3 PR27.1 PR103.1 PR737.1 PR741.1 PR1013.1 PR1022.1 PR1073.1 PR1100.1 PU101.3 R874.2 R909.1 UH2.5
+3.3V_ALW_PCH: CH2.1 CH43.1 CH45.1 CH51.1 JAPS1.1 JXDP2.43 JXDP2.44 PJP91.1 R520.1 R796.1 R1622.2 R1624.2 RC124.1 RH35.1 RH41.1 RH46.1 RH60.1 RH73.1 RH75.1 RH84.1 RH88.1 RH123.2 RH124.2 RH125.2 RH128.2 RH130.1 RH140.2 RH147.2 RH166.1 RH170.1 RH171.1 RH210.2 RH211.2 RH212.2 RH213.2 RH222.2 RH237.1 RH240.1 RH254.2 RPH5.5 RPH5.6 RPH5.7 RPH5.8 RPH6.5 RPH6.6 RPH6.7 RPH6.8 RPH7.5 RPH7.6 RPH7.7 RPH7.8 UH1.A26 UH1.AJ30 UH1.AJ32 UH1.R20 UH1.R22 UH1.R24 UH1.R26 UH1.R28 UH1.U26
+3.3V_ALW_PCH_JTAG: RH46.2 RH48.1 RH50.1 RH52.1
+3.3V_ALW_PCH_PWR: C416.1 PJP91.2 U36.8 U36.9
+3.3V_ALW_U46: C708.1 C709.1 C710.1 C717.1 C718.1 C719.1 PJP29.2 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_U51: C777.1 C780.1 C781.1 C782.1 C1345.1 C1348.1 C1355.1 PJP65.2 U51.A11 U51.A26 U51.A41 U51.A52 U51.B3 U51.B35
+3.3V_LAN: C472.1 C473.1 C474.1 C478.1 C481.1 C483.1 C770.1 C1167.1 C1178.1 JLOM1.9 JLOM1.12 R209.2 R545.1 R546.1 R549.1 R553.1 R554.1 R559.2 RH174.1 RH175.1 U15.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39 U63.7 U63.8
+3.3V_LAN_OUT: C464.1 R209.1 U31.4 U31.5 U31.15 U31.19 U31.29
+3.3V_M: CH59.1 JSPI1.16 PJP90.1 R130.1 R385.1 R388.1 R389.1 R411.2 R837.1 R893.1 RH185.1 UH1.AD12
+3.3V_M_PWR: C513.1 PJP90.2 U40.13 U40.14
+3.3V_MXM: C8.1 C94.1 C95.1 C96.1 C332.1 JMXM1.306 JMXM1.308 PC17.2 PJP92.1 Q5.2 Q295.2 Q295.5 R1.1 R2.1 R3.1 R4.1 R5.1 R6.1 R10.1 R37.1 R38.1 R400.1 R401.1 R1121.1 R1122.1 R1977.1 R1978.1 R1979.1 R2184.2 R2185.2 RH113.1 U14.5 U25.5 U27.5 U59.3 U60.4
+3.3V_MXM_PWR: C400.1 PJP92.2 U34.7 U34.8
+3.3V_PCIE_FLASH: C546.1 C624.1 C633.1 C634.1 C637.2 C638.2 C639.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 U37.13 U37.14
+3.3V_PCIE_NVM: C617.1 C618.1 C619.1 C621.1 C622.1 C623.1 C764.1 JMINI4.2 JMINI4.24 JMINI4.39 JMINI4.41 JMINI4.52 U49.7 U49.8
+3.3V_PCIE_WWAN: C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C762.1 C1176.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 Q77.2 R719.2 U43.7 U43.8
+3.3V_RTC_LDO: PD1.3 PR103.2
+3.3V_RUN: C51.1 C243.1 C244.1 C248.1 C301.1 C310.1 C359.1 C391.1 C392.1 C402.1 C403.1 C404.1 C405.1 C407.1 C408.1 C410.1 C419.1 C420.1 C437.1 C494.1 C495.1 C496.1 C497.1 C499.1 C504.1 C722.1 C748.1 C766.1 C783.1 C1145.1 C1146.1 C1149.1 C1159.1 C1181.1 CC140.1 CD21.1 CD22.1 CD43.1 CD44.1 CD65.1 CD66.1 CD87.1 CD88.1 CH10.1 CH12.1 CH27.1 CH48.1 CH49.1 CH65.1 D91.2 JBT1.9 JCAM1.2 JCAM1.4 JDIMM1.199 JDIMM2.199 JDIMM3.199 JDIMM4.199 JIO1.120 JIO1.122 JIO1.124 JIO1.126 JIO1.128 JLVDS1.16 JSATA1.8 JSATA1.9 JSATA2.8 JSATA2.9 JUSH1.13 L60.2 L61.2 PJP9.1 PJP34.2 PJP77.1 PJP89.1 PR400.1 PR519.2 Q24.3 Q343.3 Q343.6 QH4.2 QH4.5 R39.1 R40.1 R41.1 R42.1 R43.1 R44.1 R46.1 R56.1 R58.1 R64.1 R65.1 R68.1 R70.1 R71.1 R72.1 R76.1 R78.1 R80.1 R83.1 R84.1 R97.2 R98.2 R99.2 R117.2 R118.2 R119.2 R120.2 R124.2 R125.2 R126.2 R128.2 R159.1 R160.1 R339.1 R340.1 R403.1 R405.1 R407.1 R408.1 R409.1 R415.1 R421.1 R501.1 R502.1 R503.1 R504.1 R513.1 R518.1 R722.1 R772.1 R782.2 R799.1 R822.1 R823.2 R824.2 R829.1 R852.2 R853.2 R1118.1 R1123.1 R1124.1 R1133.1 R1134.1 R1165.2 R1197.1 R1530.1 R1539.1 R1635.1 R1636.1 R1986.1 R1990.2 R1992.2 R1994.1 R2151.1 R2152.1 R2154.1 R2157.1 R2159.1 R2190.1 R2191.1 RC19.1 RD8.2 RD26.2 RD27.2 RD36.2 RH34.1 RH36.2 RH37.2 RH40.1 RH77.1 RH83.1 RH86.1 RH90.1 RH93.1 RH120.1 RH145.2 RH148.1 RH168.1 RH200.1 RH208.2 RH214.2 RH215.2 RH224.1 RH225.2 RH228.2 RH229.2 RH242.1 RH245.1 RH328.1 RP3.1 RP3.2 RP3.3 RP3.4 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH8.1 RPH8.2 RPH8.3 RPH8.4 RPH9.1 RPH9.2 RPH9.3 RPH9.4 RPH10.1 RPH10.2 RPH10.3 RPH10.4 U3.5 U9.14 U9.28 U9.41 U9.56 U11.35 U13.35 U19.11 U20.14 U22.1 U22.6 U22.12 U22.25 U22.32 U22.36 U26.10 U26.20 U30.1 U88.1 U88.7 U88.8 U88.14 U629.21 U629.26 U629.35 U629.49 U629.60 UC1.5 UC3.5 UH1.AE14 UH1.AF12 UH1.AG14 UH1.AK30 UH1.AK32 UH1.L24 UH1.M31 UH1.R30 UH1.R32 UH3.5
+3.3V_RUN_PS8513: C25.1 C661.1 C662.1 PJP9.2 U44.6 U44.10 U44.16 U44.20
+3.3V_RUN_PWR: C449.1 PJP89.2 U36.13 U36.14
+3.3V_RUN_TPM: C45.1 C48.1 C550.1 C551.1 C552.1 C553.1 PJP77.2 U39.5 U39.10 U39.19 U39.24
+3.3V_SPI: C746.1 C1216.1 JSPI1.15 R3664.1 R3665.1 R3666.1 R3668.1 RH185.2 U52.8 U53.8
+3.3V_SUS: C55.1 C725.1 JIO1.84 JUSH1.8 JUSH1.9 JUSH1.10 PJP94.1 R585.1 R589.1
+3.3V_SUS_PWR: C475.1 PJP94.2 U40.8 U40.9
+3.3V_VCCPRTCSUS: CH53.1 RH240.2 RH246.2 UH1.K8
+3.3V_VTR: C739.1 C1349.1 R834.2 R837.2 U51.A22
+3.3V_WLAN: C536.1 C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 Q89.2 Q124.2 Q124.5 R705.2 R718.2 R725.2 R726.2 R727.2 R728.2 U42.7 U42.8
+3VALWP: PC101.1 PJP100.1 PJP101.1 PL103.2 PR100.1
+5V_ALW: C715.1 C721.1 JIO1.99 JIO1.101 JIO1.103 JIO1.105 JIO1.107 JIO1.109 JIO1.111 JIO1.113 JIO1.115 JIO1.117 JPB1.2 PC18.1 PC21.1 PC213.1 PC308.1 PC727.1 PC728.1 PJP30.2 PJP31.2 PJP102.2 PJP103.2 PR11.1 PR31.2 PR203.1 PR501.2 PR520.2 PR531.2 PR735.2 PR1012.2 PU1.5 PU2.8 PU200.12 PU300.7 PU703.8 Q75.3 Q79.3 Q86.3 R816.2 R1614.2 R1630.1 U2.5 U33.4 U33.5 U34.4 U35.1 U35.2 U35.4 U36.4 U37.4 U37.6 U37.7 U40.4 U42.4 U43.4 U49.4 U57.1 U57.2 U57.4 U63.4
+5V_ALW2: PC118.1 PU101.13
+5V_ALW_ESATA: C675.1 C676.1 PJP31.1 U48.2 U48.3
+5V_ALW_FUSE: C669.1 C670.1 PJP30.1 U45.2 U45.3
+5V_ESATA_PWR: C667.1 C668.1 JESA1.1 U48.8 U48.9
+5V_HDD: C5.1 C395.1 C406.1 C409.1 C415.1 C498.1 JSATA1.14 JSATA1.15 JSATA1.16 JSATA2.14 JSATA2.15 JSATA2.16 PJP3.1 R506.1
+5V_MOD: C428.1 C429.1 C767.1 JODD1.9 JODD1.10 U57.7 U57.8
+5V_MXM: C7.1 C328.1 JMXM1.37 JMXM1.39 JMXM1.41 JMXM1.43 JMXM1.45 PJP93.1
+5V_MXM_PWR: C356.1 PJP93.2 U35.7 U35.8
+5V_RUN: C54.1 C311.1 C329.1 C330.1 C364.1 C370.1 C758.1 C763.1 C1182.1 JCAM1.6 JCAM1.8 JFAN1.4 JFAN2.4 JIO1.129 JIO1.131 JIO1.133 JKB1.9 JKB1.10 JUSH1.14 PJP3.2 PJP82.1 Q80.3 R721.1 R1532.1 R1537.1 R2153.1 R2192.1 R2193.1 RP6.1 RP6.2 RP6.3 RP6.4 U5.1 U6.1 U19.21 U19.29
+5V_RUN_PWR: C514.1 PJP82.2 U37.8 U37.9
+5V_USB_PWR1: C324.1 C793.1 JUSB1.1 U45.8
+5V_USB_PWR2: C323.1 C794.1 JUSB2.1 U45.9
+5VALWP: PC102.1 PJP102.1 PJP103.1 PL102.2 PR101.1 PU101.14
+AVCC33: C106.1 C107.1 C108.1 L61.1 U23.5
+DVCC33: C113.1 C114.1 C115.1 C116.1 C117.1 L60.1 U23.18 U23.22
+VCC_4021: C277.1 C1179.1 R388.2 R393.2 U29.1
+VCC_CORE: JCPU1.AA26 JCPU1.AA28 JCPU1.AA30 JCPU1.AA32 JCPU1.AA34 JCPU1.AB25 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC26 JCPU1.AC28 JCPU1.AC30 JCPU1.AC32 JCPU1.AC34 JCPU1.AD25 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AE26 JCPU1.AE28 JCPU1.AE30 JCPU1.AE32 JCPU1.AE34 JCPU1.AF25 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG28 JCPU1.AG30 JCPU1.AG32 JCPU1.AG34 JCPU1.AH25 JCPU1.AH26 JCPU1.AH27 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH31 JCPU1.AH32 JCPU1.AH33 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ25 JCPU1.AJ26 JCPU1.AJ27 JCPU1.AJ28 JCPU1.AJ29 JCPU1.AJ30 JCPU1.AJ31 JCPU1.AJ32 JCPU1.AJ33 JCPU1.AJ34 JCPU1.AJ35 JCPU1.F25 JCPU1.G25 JCPU1.H25 JCPU1.J25 JCPU1.K25 JCPU1.K26 JCPU1.L25 JCPU1.M25 JCPU1.N25 JCPU1.P25 JCPU1.R25 JCPU1.T25 JCPU1.U25 JCPU1.U26 JCPU1.V25 JCPU1.V26 JCPU1.W26 JCPU1.W27 JCPU1.Y25 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC935.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PL500.1 PL501.1 PL502.1 PR512.2 PR544.1 PR555.1 RC66.1
+VCCADAC: CH18.1 CH19.1 CH20.1 LH1.2 UH1.P45
+VCCIO2PCH: CC137.1 CH81.1 CH82.1 CH83.1 RC105.1 RC106.2 UH1.AJ12 UH1.AJ14
+VCCIO2PCH_R: JCPU1.A23 RC106.1
+VCCIO_OUT: CC65.1 CC66.1 JCPU1.AN35 JXDP1.11 PR500.2 PR503.2 PR504.2 R399.1 RC4.1 RC44.1 RC60.1 RC63.1 RC65.2 RC128.1
+VCCST: CC78.1 CC79.1 JCPU1.AK31 RC99.1
