# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_ODT7: length 76.4
  TOP w0.102: JCPU1.P2 v2(174.06,105.31) ; v2(148.76,53.56) 148.76,52.17 149.04,51.89 149.04,51.34 149.18,51.19 149.38,51.19 149.53,51.34 149.53,51.45 149.67,51.59 149.87,51.59 150.01,51.45 150.01,51.14 150.11,51.03 150.36,51.03 150.45,51.12 150.45,51.29 150.53,51.37 150.86,51.37 151.14,51.09 JDIMM3.120
  IN3 w0.089: 171.78,101.77 171.78,101.95 173.68,103.86 173.68,104.5 174.06,104.87 v2(174.06,105.31)
  IN3 w0.152: v2(148.76,53.56) 148.76,52.97 148.64,52.85 148.43,52.85 148.3,52.98 148.3,58.74 147.95,59.08 147.95,64.12 148.59,64.76 148.59,71.57 150.7,73.68 150.7,73.88 150.44,74.13 150.44,74.36 150.57,74.49 150.77,74.49 151,74.26 151.28,74.26 151.7,74.68 151.7,74.91 151.56,75.04 150.57,75.04 150.42,75.2 150.42,76.46 150.55,76.59 151.46,76.59 151.64,76.77 151.64,77.46 152.17,77.99 152.17,78.52 153.4,79.75 153.4,80.59 152.89,81.1 152.89,81.95 153.85,82.91 155.4,82.91 164.99,92.5 164.99,93.82 171.78,100.6 171.78,101.77
MASK_BASE_LEDS#: length 623.9
  TOP w0.102: U58.4 32.04,87.17 31.52,86.65 31.52,85.93 Q74.2 31.71,85.28 29.78,83.35 27.76,83.35 v2(27.43,83.02) ; v2(131.69,158.47) 131.52,158.64 v1(131.52,163.04) 131.52,165.88 Q78.2 ; Q84.2 286.6,87.57 286.94,87.22 287.64,87.22 289.46,89.04 292.2,89.04 v2(292.33,89.17) ; JIO1.106 21.7,71.7 22,72 22,72.68 21.64,73.04 21.64,73.67 22.26,74.3 Q93.2 22.51,74.63 22.91,74.23 v2(23.34,74.23)
  IN1 w0.109: v2(292.33,89.17) 292.09,88.93 292.09,83.09 292.23,82.95 292.23,76.23 294.58,73.88 294.58,62.92 281.41,49.75 267.96,49.75 254.67,36.46 253.11,36.46 251.08,34.43 246.61,34.43 244.66,32.48 234.53,32.48 233.96,33.05 223.19,33.05 219.64,36.59 200.85,36.59 192.55,28.29 178.44,28.29 177.48,27.33 156.64,27.33 155.47,28.51 147.98,28.51 147.79,28.32 139.24,28.32 137.3,30.26 125.39,30.26 123.58,28.46 119.79,28.46 110.29,18.95 99.73,18.95 92.39,26.29 70.33,26.29 66.89,29.73 66.89,30.45 49.55,47.79 49.55,62.31 49.49,62.37 49.49,62.39 49.22,62.65 49.22,64.4 47.38,66.24 45.81,66.24 44.26,67.79 44.26,68.63 42.85,70.04 41.65,70.04 39.41,72.28 36.5,72.28 35.73,71.51 28.99,71.51 28.44,70.96 27.39,70.96 26.95,71.39 26.95,71.81 26.97,71.82 26.97,72.51 25.39,74.08 23.49,74.08 v2(23.34,74.23) 23.05,74.23 20.8,76.48 16.11,76.48 13.9,78.69 13.9,81.86 11.95,83.81 11.95,90.3 10.66,91.59 10.66,93.86 8.21,96.3 8.21,101.53 9.27,102.59 10.46,102.59 21.1,113.23 33.07,113.23 35.91,116.07 36.32,116.07 38.12,117.86 38.12,122.2 35.64,124.68 35.64,124.68 35,125.32 35,127.26 35.99,128.25 35.99,129.5 40.84,134.35 40.84,138.93 44.12,142.2 45.64,142.2 46.15,142.71 46.15,143.14 45.97,143.32 45.97,143.8 46.43,144.26 48.4,144.26 49.84,145.7 55.35,145.7 56.11,146.46 65.28,146.46 65.96,147.15 66.57,147.15 67.79,148.37 70.16,148.37 70.87,149.09 72.56,149.09 73.38,149.91 73.38,151.28 75.04,152.95 89.41,152.95 91.39,154.93 93.47,154.93 96.1,152.3 98.47,152.3 99.45,151.33 106.99,151.33 107.42,151.76 117.13,151.76 119.35,153.99 120.5,153.99 121.26,154.75 129.59,154.75 131.69,156.85 v2(131.69,158.47)
  IN2 w0.127: v2(292.25,107.66) 291.26,106.67 291.26,103.39 290.9,103.04 290.9,92.32 292.33,90.89 v2(292.33,89.17)
  BOTTOM w0.102: v2(23.34,74.23) 24,74.89 24,78.88 25.77,80.65 25.77,81.36 v2(27.43,83.02) ; v2(292.25,107.66) 292.2,107.71 291.16,107.71 290.45,107 290.45,106.59 290.8,106.24 Q318.2
MASK_SATA_LED#: length 260.9
  TOP w0.102: v2(30.9,85.13) 30.75,85.28 Q74.5
  IN3 w0.127: v2(30.9,85.13) 31.23,84.8 31.23,82.73 33.25,80.71 35.08,80.71 38.07,77.72 38.07,75.69 39.28,74.49 39.28,73.09 40.83,71.54 42.3,71.54 43.37,70.47 43.37,64.86 44.01,64.22 44.01,62.74 46.02,60.72 46.02,58.38 54.67,49.73 57.85,49.73 59.6,47.98 63.72,47.98 64.15,47.55 66.2,47.55 67.93,45.82 69.83,45.82 70.26,45.39 72.08,45.39 72.74,44.73 75.87,44.73 76.3,44.3 79.58,44.3 80.02,44.73 99.79,44.73 102.25,42.28 121.47,42.28 123.02,40.73 144.87,40.73 147.86,37.73 166.47,37.73 167.9,39.17 170.19,39.17 171.88,40.86 177.33,40.86 178.04,41.57 187.69,41.57 188.2,42.08 191.92,42.08 201.42,51.58 204.27,51.58 204.89,52.2 207.28,52.2 224.03,68.95 224.03,69.08 225.83,70.88 226.21,70.88 227.18,71.84 229.26,71.84 230.4,72.99 232.36,72.99 233.91,74.54 237.77,74.54 238.66,73.65 238.66,72.25 240.71,70.19 240.71,69.86 v2(241.57,69)
  BOTTOM w0.102: U46.B9 242.5,69.41 242.47,69.43 242,69.43 v2(241.57,69) ; v2(30.9,85.13) 30.9,84.51 v1(30.96,84.46)
MB_DP_CA_DET: length 101.4
  TOP w0.102: v2(279.96,75.53) 279.2,74.77 279.2,66.71 280.41,65.49 285.24,65.49 288.24,62.5 v2(288.26,62.5)
  IN2 w0.127: JDP1.13 291.24,141.7 291.24,128.37 288.39,125.52 288.39,113.25 286.79,111.65 286.79,97.38 282.62,93.21 282.62,87.39 278.92,83.68 278.92,79.87 279.96,78.83 v2(279.96,75.53)
  BOTTOM w0.102: v2(279.96,75.53) 279.55,75.53 R62.2 279.61,76.04 v1(280.39,76.04) U22.10 ; v2(288.26,62.5) 288.47,62.5 289.15,61.81 Q339.2 C1341.1
MB_DP_HPD: length 73.8
  IN2 w0.127: JDP1.18 295.45,141.08 295.45,139.69 291.46,135.7 291.46,128.27 288.62,125.43 288.62,113.16 287.07,111.61 287.07,97.33 282.85,93.12 282.85,87.29 279.14,83.59 279.14,79.97 280.19,78.92 280.19,77.18 v2(280.82,76.54)
  BOTTOM w0.102: U22.11 v2(280.82,76.54)
MB_DP_RP_AUX: length 80.3
  IN3 w0.127: v2(283.22,84.11) 283.39,83.94 283.59,83.94 283.95,84.3 283.95,92.21 287.71,95.98 287.71,111.3 288.29,111.87 288.29,134.99 292.64,139.34 292.64,142.52 292.99,142.87 293.4,142.87 JDP1.15
  BOTTOM w0.102: v2(283.22,84.11) 283.4,83.93 288.42,83.93 289.83,82.53 289.83,80.76 289.95,80.64 289.95,80.47 R59.2 289.96,79.79 v3(289.96,78.91) 289.96,78.18 290.34,77.79 290.34,76.13 289.75,75.54 U22.28
MB_DP_RP_AUX#: length 80.3
  IN3 w0.127: v2(283.22,83.53) 283.39,83.7 283.69,83.7 284.19,84.2 284.19,92.11 287.96,95.87 287.96,111.19 288.54,111.77 288.54,134.89 292.89,139.23 292.89,142.41 293.09,142.62 293.41,142.62 JDP1.17
  BOTTOM w0.102: U22.27 289.15,76.04 289.25,75.94 289.25,75.86 289.36,75.76 289.66,75.76 290.13,76.22 290.13,77.7 289.74,78.09 289.74,78.63 289.73,78.64 289.73,79.17 289.74,79.18 289.74,79.68 289.61,79.81 289.46,79.81 R56.2 289.57,80.12 289.73,80.28 289.73,80.55 289.61,80.67 289.61,82.44 288.33,83.72 283.41,83.72 v2(283.22,83.53)
MB_DP_RP_C_N0: length 2.8
  BOTTOM w0.102: C304.2 287.58,79.79 287.58,79.52 287.54,79.48 287.52,79.48 287.15,79.1 287.15,79.08 287.07,79 287.07,78.45 286.92,78.31 U22.22
MB_DP_RP_C_N1: length 2.6
  BOTTOM w0.102: C308.2 285.68,79.79 285.68,79.55 285.57,79.44 v3(285.57,79.07) 285.57,78.45 285.42,78.31 U22.19
MB_DP_RP_C_N2: length 2.7
  BOTTOM w0.102: U22.16 283.92,78.31 284.07,78.45 284.07,78.54 283.77,78.84 v3(283.77,79.15) 283.77,79.79 C309.2
MB_DP_RP_C_N3: length 2.8
  BOTTOM w0.102: U22.13 282.42,78.28 282.57,78.42 282.57,78.66 v3(282.2,79.03) 281.87,79.36 281.87,79.79 C302.2
MB_DP_RP_C_P0: length 2.8
  BOTTOM w0.102: C307.2 287.8,79.79 287.8,79.43 v3(287.5,79.13) 287.28,78.91 287.28,78.45 287.42,78.31 U22.23
MB_DP_RP_C_P1: length 2.6
  BOTTOM w0.102: U22.20 285.92,78.31 285.78,78.45 285.78,78.79 285.79,78.8 285.79,79.36 285.89,79.46 285.89,79.79 C295.2
MB_DP_RP_C_P2: length 2.7
  BOTTOM w0.102: C306.2 283.99,79.79 283.99,79.43 284,79.41 284,78.91 284.28,78.63 284.28,78.45 284.42,78.31 U22.17
MB_DP_RP_C_P3: length 2.9
  BOTTOM w0.102: C303.2 282.08,79.79 282.08,79.45 282.15,79.38 282.17,79.38 282.55,79 282.55,78.98 282.78,78.75 282.78,78.44 282.92,78.3 U22.14
MB_DP_RP_N0: length 80.8
  IN3 w0.127: v2(288.52,82.54) 288.28,82.54 287.91,82.9 287.91,85.94 290.55,88.58 290.55,103.01 291.22,103.68 291.22,112.4 290.82,112.8 290.82,128.33 297.39,134.9 297.39,148.64 294.84,151.19 293.31,151.19 292.78,150.66 292.78,149.87 293.18,149.47 293.56,149.47 JDP1.3
  BOTTOM w0.102: C304.1 287.5,81.29 287.5,81.73 288.08,82.31 288.29,82.31 v2(288.52,82.54)
MB_DP_RP_N1: length 74.1
  IN3 w0.127: v2(285.47,82.02) 285.54,82.02 285.68,82.16 285.68,85.67 289.51,89.5 289.51,102 289.25,102.27 289.25,108.16 290.21,109.13 290.21,111.99 289.81,112.39 289.81,133.56 296.39,140.14 296.39,147.41 295.49,148.31 295.19,148.31 295.03,148.15 294.87,148.15 294.78,148.06 JDP1.6
  BOTTOM w0.102: C308.1 285.68,81.38 285.68,81.81 v2(285.47,82.02)
MB_DP_RP_N2: length 77.7
  IN3 w0.127: v2(283.46,82.04) 283.54,82.12 283.69,82.12 283.82,81.99 283.82,81.57 284,81.39 284,81.25 283.87,81.12 281.5,81.12 280.87,81.75 280.87,85.99 282.78,87.9 282.78,92.89 285.04,95.15 285.04,98.72 287.18,100.86 287.18,111.66 287.78,112.25 287.78,135.21 291.02,138.46 291.02,145.01 291.31,145.3 291.48,145.3 291.76,145.58 291.76,145.75 292.03,146.02 292.2,146.02 292.48,146.3 292.48,146.47 292.95,146.94 293.25,146.94 293.53,146.65 293.71,146.65 293.78,146.58 JDP1.9
  BOTTOM w0.102: v2(283.46,82.04) 283.54,82.04 283.77,81.81 283.77,81.38 C309.1
MB_DP_RP_N3: length 73
  IN3 w0.127: JDP1.12 294.78,145.04 294.89,145.15 295.03,145.15 295.24,145.36 295.45,145.36 295.63,145.18 295.63,140.45 289.05,133.88 289.05,112.08 289.46,111.67 289.46,109.59 288.47,108.6 288.47,93.54 284.86,89.93 284.86,83.54 284.29,82.97 282.29,82.97 281.85,82.53 281.85,82.22 v2(281.66,82.03)
  BOTTOM w0.102: C302.1 281.87,81.38 281.87,81.82 v2(281.66,82.03)
MB_DP_RP_P0: length 80.8
  IN3 w0.127: JDP1.1 293.78,149.95 293.68,149.84 293.53,149.84 293.41,149.72 293.28,149.72 293.03,149.97 293.03,150.56 293.41,150.95 294.74,150.95 297.14,148.54 297.14,135 290.57,128.43 290.57,112.7 290.97,112.3 290.97,103.79 290.3,103.12 290.3,88.69 287.66,86.05 287.66,82.8 288.34,82.12 288.48,82.12 288.6,82 288.6,81.86 v2(288.52,81.78)
  BOTTOM w0.102: v2(288.52,81.78) 288.52,81.93 288.35,82.09 288.17,82.09 287.72,81.64 287.72,81.19 287.86,81.04 C307.1
MB_DP_RP_P1: length 74.1
  IN3 w0.127: v2(286.08,82.02) 285.93,82.17 285.93,85.56 289.76,89.4 289.76,102.1 289.49,102.37 289.49,108.06 290.46,109.02 290.46,112.09 290.06,112.5 290.06,133.46 296.64,140.04 296.64,147.51 295.59,148.56 294.97,148.56 JDP1.4
  BOTTOM w0.102: v2(286.08,82.02) 285.89,81.83 285.89,81.38 C295.1
MB_DP_RP_P2: length 77.8
  IN3 w0.127: JDP1.7 293.72,147.19 292.85,147.19 290.77,145.11 290.77,138.56 287.53,135.32 287.53,112.36 286.93,111.77 286.93,100.97 284.79,98.82 284.79,95.26 282.53,93 282.53,88 280.62,86.09 280.62,81.65 281.4,80.87 283.97,80.87 284.25,81.14 v2(284.25,82.04)
  BOTTOM w0.102: C306.1 283.99,81.38 283.99,81.78 v2(284.25,82.04)
MB_DP_RP_P3: length 73.1
  IN3 w0.127: JDP1.10 294.92,145.61 295.55,145.61 295.88,145.29 295.88,140.35 289.3,133.77 289.3,112.18 289.71,111.77 289.71,109.49 288.72,108.5 288.72,93.44 285.11,89.83 285.11,83.43 284.39,82.72 282.4,82.72 282.1,82.42 282.1,82.22 v2(282.29,82.03)
  BOTTOM w0.102: v2(282.29,82.03) 282.08,81.82 282.08,81.38 C303.1
MB_DP_RST#: length 5.2
  BOTTOM w0.102: U22.35 289.62,72.04 v1(290.69,70.98) 291.11,70.56 C88.1 291.18,69.58 R415.2
MCARD_MISC_PWREN: length 230.2
  IN3 w0.127: v2(235.38,72.73) 235.51,72.61 235.51,72.15 235.51,69.91 235.23,69.63 233.96,69.63 233.48,69.15 229.59,69.15 228.27,67.83 224.69,67.83 208.1,51.24 208.1,50.76 203.96,46.62 197.76,46.62 192.3,41.16 188.58,41.16 187.31,39.89 174.27,39.89 172.63,38.25 168.28,38.25 166.85,36.82 147.49,36.82 144.49,39.82 122.53,39.82 120.98,41.36 101.87,41.36 100.06,43.17 76.14,43.17 75.49,43.82 70.54,43.82 69.45,44.91 67.55,44.91 66.31,46.14 v2(64.16,46.14)
  BOTTOM w0.102: v2(235.38,72.73) 235.24,72.87 235.06,72.87 234.77,73.17 234.77,73.71 234.73,73.75 U46.B53 ; U37.3 53.6,16.17 R733.1 53.06,16.65 53.06,24.88 57.53,29.35 57.53,31.92 63.24,37.63 63.24,41.47 64.16,42.38 v1(64.16,44.56) v2(64.16,46.14)
MCARD_PCIE_SATA#: length 292.6
  IN1 w0.109: v2(56.49,73.27) 56.67,73.09 56.67,71.95 56.06,71.34 56.06,69.66 54.94,68.54 54.94,66.05 56.59,64.4 56.59,53.91 57.3,53.2 57.3,49.14 61.57,44.87 61.57,44.03 62.56,43.04 63.24,43.04 69.85,36.44 80.87,36.44 81.48,37.05 84.41,37.05 84.66,37.29 87.21,37.29 88.24,36.26 101.88,36.26 102.94,37.33 111.91,37.33 113.03,36.21 115.82,36.21 117.96,34.07 155.45,34.07 157.07,32.45 170.41,32.45 171.91,33.95 179.32,33.95 180.03,34.66 193.01,34.66 198.29,39.93 202.02,39.93 203.3,41.21 221.97,41.21 v2(222.07,41.11)
  IN4 w0.109: v2(56.49,73.27) 55.1,74.65 55.1,79.11 v2(54.19,80.02)
  BOTTOM w0.102: v2(222.07,41.11) 222.07,41.34 v1(218.24,45.17) 215.54,47.87 215.54,55.95 216.79,57.19 216.79,64.33 220.95,68.49 220.95,70.73 227.94,77.71 229.66,77.71 231.89,79.95 235.13,79.95 235.25,80.07 235.48,80.07 235.79,80.38 235.79,80.71 236.75,81.68 239.24,81.68 239.62,81.29 243.61,81.29 244.55,80.35 244.55,79.24 R761.1 ; v2(54.19,80.02) 53.39,80.82 RH16.1 ; UH1.AN2 68.14,71.92 67.59,71.92 66.83,72.68 65.95,72.68 65.8,72.84 64.31,72.84 62.66,74.49 RH226.1 61.77,73.98 60.37,73.98 RH224.2 59.51,73.88 58.55,73.88 57.76,73.09 56.67,73.09 v2(56.49,73.27)
MCARD_PCIE_SATA#_R: length 7
  IN3 w0.127: v2(243.1,75.5) 243.1,74.89 242.64,74.44 242.64,72.62 v2(241.99,71.96)
  BOTTOM w0.102: R761.2 243.1,76.87 v1(243.1,76.35) v2(243.1,75.5) ; v2(241.99,71.96) 242.43,72.41 U46.B3
MCARD_WWAN_PWREN: length 76.2
  IN1 w0.109: v2(234.31,69.13) 234.31,69.11 234.72,68.7 236.18,68.7 237.64,70.17 240.84,70.17 241.36,69.64 242.42,69.64 244.19,71.41 244.63,71.41 245.12,70.93 246.02,70.93 246.4,70.55 249.55,70.55 249.96,70.14 252.93,70.14 253.24,70.45 267.56,70.45 v2(267.82,70.7)
  IN3 w0.127: v2(267.82,70.7) 267.82,70.32 270.39,67.74 270.39,40.56 272.53,38.43 272.53,37.21 v2(272.49,37.17)
  BOTTOM w0.102: v2(234.31,69.13) 234.31,69.03 234.18,68.91 U46.B42 ; v1(271.37,36.44) 271.54,36.44 272.27,37.17 v2(272.49,37.17) 272.49,36.92 R720.1 272.9,36.52 U43.3
ME_FWP: length 215
  IN1 w0.109: v2(257.1,54.89) 256.07,54.89 255.42,54.25 250.51,54.25 250.04,54.71 247.81,54.71 247.67,54.85 242.37,54.85 241.76,54.25 233.95,54.25 233.64,54.56 216.47,54.56 214.53,52.62 204.83,52.62 204.13,51.91 201.02,51.91 192.84,43.73 186.1,43.73 185.49,43.12 166.28,43.12 165.56,42.39 123.07,42.39 120.64,44.82 115.66,44.82 112.01,48.47 110.36,48.47 110.12,48.22 99.12,48.22 98.68,48.66 90.62,48.66 89.56,49.72 85.14,49.72 84.28,50.58 82.23,50.58 v2(81.63,51.18)
  BOTTOM w0.102: U46.A8 244.06,69.66 244.14,69.74 244.14,69.94 244.35,70.14 244.76,70.14 244.94,70.32 245.72,70.32 246.15,69.89 R793.1 246.61,70.12 247.95,70.12 248.49,70.65 250.39,70.65 252.13,68.91 252.13,63.2 254.3,61.02 254.3,59.5 254.1,59.3 254.1,57.66 256.87,54.89 v2(257.1,54.89) ; v2(81.63,51.18) 81.63,50.48 v1(81.44,50.29) RH45.1
ME_RESET#: length 3.7
  BOTTOM w0.102: RH93.2 67.38,84.27 67.38,84.27 UC3.2 ; RH93.2 RH70.1 ; RH93.2 v1(68.1,83.19)
ME_SUS_PWR_ACK: length 204.8
  TOP w0.102: RH75.2 59.87,59.8 60.74,60.68 v2(60.74,60.83) 60.93,61.02 RH258.1
  IN1 w0.109: v2(60.74,60.83) 59.65,59.74 59.65,56.1 60.58,55.18 60.58,51.19 65.56,46.22 65.56,44.97 67.82,42.71 73.66,42.71 74.09,43.15 75.18,43.15 77.41,40.91 94.77,40.91 95.51,41.65 98.15,41.65 98.83,40.96 102.91,40.96 103.18,40.69 112.78,40.69 113.64,39.83 119.59,39.83 122.55,36.87 174.95,36.87 176.12,38.03 179.2,38.03 181.83,35.4 190.42,35.4 191.77,36.74 193.1,36.74 200.46,44.1 203.32,44.1 204.65,45.43 220.51,45.43 221.55,46.47 229.46,46.47 229.94,46.95 233.1,46.95 233.53,46.51 236.18,46.51 v2(236.75,45.94)
  BOTTOM w0.102: v1(236.36,45.36) 236.75,45.76 v2(236.75,45.94) 236.77,45.92 U51.A8
ME_SUS_PWR_ACK_R: length 8.9
  TOP w0.102: RH91.1 61.39,60.14 RH258.2 63.78,61.02 64.86,62.11 v2(65.06,62.11)
  BOTTOM w0.076: 66.76,62.27 66.86,62.17 67.94,62.17 68.12,62.34 68.4,62.34 68.63,62.12 69.1,62.12 UH1.J4
  BOTTOM w0.102: 66.76,62.27 v1(65.7,62.27) 65.22,62.27 v2(65.06,62.11)
MEC_XTAL1: length 6.9
  BOTTOM w0.203: U51.A61 240.8,40.05 v1(240.37,39.62) 239.14,38.39 239.14,36.79 C743.1 239.29,35.6 239.9,34.99 Y6.1
MEC_XTAL2: length 3.6
  BOTTOM w0.203: R1068.2 237.39,37.72 238.3,36.81 C741.1 238.3,35.68 Y6.2
MEC_XTAL2_R: length 3.6
  BOTTOM w0.203: R1068.1 238.3,38.11 v1(239.17,38.98) 240.3,40.11 U51.A62
MEM_SMBCLK: length 57.7
  IN3 w0.102: 69.06,63.61 69.09,63.61 69.1,63.6 69.66,63.6 69.72,63.67 70.38,63.67 70.59,63.87 70.59,64.3 70.92,64.63 71.63,64.63 71.73,64.73 v2(71.73,65.02)
  IN3 w0.127: v2(54.15,64.43) 54.28,64.3 54.4,64.3 55.14,65.04 56.92,65.04 57.5,64.45 58.83,64.45 59.51,63.77 61.74,63.77 62.05,64.08 68.42,64.08 68.88,63.61 69.06,63.61
  IN4 w0.109: v2(37.64,84.27) 37.65,84.28 37.65,84.96 37.52,85.1 37.19,85.1 36.98,84.9 36.98,83.96 37.67,83.27 39.22,83.27 40.32,82.17 40.32,79.83 44.55,75.6 44.55,74.63 45.98,73.2 50.41,73.2 51.96,71.65 52.6,71.65 53.72,70.53 53.72,64.43 53.87,64.28 54,64.28 v2(54.15,64.43)
  BOTTOM w0.102: RPH5.3 54.99,62.79 54.88,62.9 54.48,62.9 53.75,63.64 53.75,64.02 v2(54.15,64.43) ; QH4.6 38.37,84.27 v2(37.64,84.27) ; v2(71.73,65.02) 71.73,64.71 UH1.R10
MEM_SMBDATA: length 58
  IN3 w0.102: 69.06,63.36 69.09,63.36 69.1,63.37 69.75,63.37 69.82,63.44 70.48,63.44 70.81,63.77 70.81,64.21 71.01,64.4 71.87,64.4 72.31,64.84 v2(72.31,65.01)
  IN3 w0.127: v2(54.15,63.82) 54.38,64.05 54.51,64.05 55.24,64.78 56.81,64.78 57.4,64.2 58.72,64.2 59.41,63.51 61.85,63.51 62.16,63.82 68.31,63.82 68.78,63.36 69.06,63.36
  IN4 w0.109: v2(54.15,63.82) 53.93,64.04 53.77,64.04 53.48,64.33 53.48,70.43 52.5,71.41 51.87,71.41 50.32,72.96 45.89,72.96 44.31,74.53 44.31,75.51 40.09,79.73 40.09,82.07 39.12,83.04 37.57,83.04 36.74,83.86 36.74,84.99 37.36,85.61 v2(37.36,86.32)
  BOTTOM w0.102: v2(54.15,63.82) 54.13,63.79 54.13,63.58 54.57,63.13 54.89,63.13 55.04,63.29 RPH5.4 ; v2(37.36,86.32) 36.62,85.58 QH4.3 ; v2(72.31,65.01) 72.31,65.32 UH1.U11
MIIC_SCL0: length 33.1
  TOP w0.102: v2(150.85,158.99) R1990.1 R1991.2
  IN1 w0.109: v2(150.85,158.99) 150.85,158.27 149.42,156.85 140.28,156.85 135.29,151.87 129.73,151.87 v2(128.83,152.77)
  BOTTOM w0.102: v2(128.83,152.77) 128.83,152.49 v1(128.55,152.22) 128.01,151.68 128.01,151.02 127.48,150.48 127.48,150.23 126.13,148.87 U23.48
MIIC_SDA0: length 33.9
  TOP w0.102: v2(151.74,158.99) R1992.1 R1993.2
  IN1 w0.109: v2(151.74,158.99) 151.74,158.86 149.51,156.64 140.36,156.64 135.37,151.65 127.56,151.65 v2(127.15,152.06)
  BOTTOM w0.102: v2(127.15,152.06) 126.97,151.88 126.97,150.99 126.47,150.48 126.47,149.62 125.73,148.88 U23.47
MINI1CLK_REQ#: length 256.7
  TOP w0.102: v2(67.25,67.73) 67.22,67.7 63.68,67.7 62.85,66.87 60.5,66.87 RH123.1
  IN1 w0.109: v2(274.55,55.06) 261.54,55.06 260.96,54.48 256.02,54.48 255.57,54.04 250.42,54.04 249.95,54.5 247.69,54.5 247.55,54.64 242.45,54.64 241.85,54.04 233.86,54.04 233.55,54.35 216.79,54.35 214.83,52.39 204.9,52.39 204.21,51.7 201.14,51.7 192.89,43.45 186.12,43.45 185.58,42.91 166.37,42.91 165.64,42.18 122.98,42.18 120.6,44.56 115.62,44.56 111.93,48.26 110.45,48.26 110.21,48.01 99.03,48.01 98.59,48.45 92.4,48.45 90.76,46.8 85.75,46.8 83.44,49.11 79.1,49.11 77.72,50.5 77.72,50.9 75.61,53.01 75.61,53.79 74.83,54.57 74.83,55.08 74.57,55.33 74.57,57.98 77.18,60.58 77.18,63.2 76.22,64.15 76.22,66.64 75.72,67.15 73.24,67.15 72.52,67.87 69.65,67.87 69.29,68.22 68.37,68.22 67.87,67.73 v2(67.25,67.73)
  BOTTOM w0.102: v2(67.25,67.73) 67.63,67.35 UH1.AB1 ; v2(274.55,55.06) v1(274.55,59.47) 274.55,60.97 272.92,62.6 JMINI1.7
MINI2CLK_REQ#: length 170.5
  TOP w0.102: RH124.1 62.51,68.87 v1(64.65,68.87) 68.99,68.87 v2(69.2,69.08)
  IN4 w0.102: v2(69.2,69.08) 69.77,69.08 69.92,68.92 73.02,68.92 73.48,69.38 78.79,69.38 80.06,70.65 80.47,70.65 82.68,72.86 84.94,72.86
  IN4 w0.109: v2(111.4,165.27) 111.23,165.09 104.19,165.09 103.62,164.52 99.35,164.52 98.85,165.02 96.18,165.02 95.95,165.26 94.55,165.26 93.55,166.26 90.65,166.26 90.63,166.23 86.33,166.23 82.42,162.32 82.42,161.1 81.28,159.96 81.28,158.33 77.25,154.3 77.25,145.4 78.15,144.5 78.15,142.61 78.64,142.13 78.64,139.89 77.77,139.03 77.77,137.76 76.99,136.97 75.91,136.97 74.31,135.37 74.31,133.92 75.72,132.51 78.82,132.51 79.88,131.46 80.8,131.46 85.28,126.98 89.52,126.98 90.83,125.67 90.83,124.42 91.33,123.92 91.33,122.01 92.12,121.21 92.12,110.65 88.91,107.43 88.91,103.85 88.06,103.01 88.06,81.57 86.54,80.04 86.54,78.12 86.14,77.72 86.14,76.62 86.86,75.9 86.86,74.78 84.94,72.86
  BOTTOM w0.102: v2(69.2,69.08) 69.15,69.03 UH1.AE4 ; v2(111.4,165.27) 112.44,166.31 112.44,166.38 113.09,167.03 JMINI2.7
MINI3CLK_REQ#: length 84.7
  TOP w0.089: 67.03,64.78 v2(67.23,64.58)
  TOP w0.102: 67.03,64.78 66.85,64.96 RH254.1
  IN1 w0.109: v2(89.76,47.63) 89.15,47.01 85.84,47.01 83.53,49.32 79.2,49.32 78.03,50.49 78.03,51.77 75.63,54.17 75.52,54.17 75.04,54.66 75.04,55.17 74.79,55.42 74.79,57.88 77.39,60.49 77.39,63.28 76.44,64.23 76.44,66.72 75.93,67.23 75.93,68.96 75.51,69.38 73.48,69.38 73.18,69.08 73.18,68.59 72.67,68.08 69.74,68.08 69.38,68.44 68.28,68.44 68.15,68.31 66.87,68.31 65.66,67.09 65.66,65.87 66.89,64.64 67.17,64.64 v2(67.23,64.58)
  BOTTOM w0.076: v2(67.23,64.58) 67.26,64.61 67.97,64.61 68.27,64.91 UH1.T3
  BOTTOM w0.102: JMINI3.7 88.14,21.41 89.53,22.8 91.21,22.8 92.48,24.07 92.48,34.1 v1(90.69,35.89) 89.76,36.82 v2(89.76,47.63)
MOD_MD: length 9.1
  TOP w0.102: JODD1.11 25.35,24.8 v2(25.88,24.27) ; Q81.1 30.06,22.09 29.8,21.83 v1(29.72,21.83) 29.28,21.83 28.93,22.19 R520.2 28.29,21.83 v2(28.29,21.55)
  BOTTOM w0.102: v2(28.29,21.55) 26.5,23.34 26.11,23.34 25.78,23.67 25.78,24.17 v2(25.88,24.27)
MODC_EN: length 280.9
  TOP w0.102: U57.3 31.59,33.08 R514.1 v2(31.6,33.81) 31.52,33.88 v1(31.52,34.67) ; v2(30.62,25.43) 30.71,25.34 Q81.5
  IN1 w0.109: v2(50.65,24.96) 43.92,18.23 36.4,18.23 32.74,21.88 32.74,22.82 30.62,24.94 v2(30.62,25.43)
  IN3 w0.127: v2(31.6,33.81) 31.6,31.42 33.65,29.36 33.65,26.66 32.42,25.43 v2(30.62,25.43) ; v2(56.55,36.04) 57.27,36.76 76.01,36.76 81.42,42.16 98.56,42.16 99.64,41.09 100.32,41.09 100.98,40.42 120.06,40.42 121.64,38.85 144.16,38.85 147.16,35.85 155.88,35.85 156.77,34.96 166.71,34.96 168.18,36.44 172.99,36.44 174.52,37.96 180.66,37.96 181.42,38.72 187.75,38.72 189.05,40.02 193.44,40.02 193.84,40.42 202.98,40.42 205.42,42.87 206.73,42.87 210.6,46.74 210.6,48.05 214.03,51.47 220.39,51.47 221.06,52.14 223.18,52.14 225.73,54.7 225.73,57.71 228.56,60.54 234.82,60.54 235.02,60.74 244.64,60.74 245.92,62.03 245.92,63.03 246.63,63.74 246.63,68.69 245.87,69.46 245.39,69.46 245.03,69.1 243.84,69.1 242.4,70.54 241.83,70.54 241.58,70.29 v2(241.58,70.07)
  BOTTOM w0.102: v2(56.55,36.04) 56.55,35.41 57.25,34.71 57.25,29.36 52.85,24.96 v2(50.65,24.96) ; v2(241.58,70.07) 241.58,70.2 241.86,70.48 242.45,70.48 242.53,70.41 U46.B7
MODC_EN#: length 3.7
  TOP w0.102: v1(33.5,22.28) 32.9,22.87 R515.2 31.37,22.87 Q81.3 31.36,22.58 31.24,22.47 30.89,22.47 30.71,22.64 Q81.2
MODE: length 2.7
  TOP w0.102: R63.2 R58.2 30.2,148.99 U9.53
MSATA_PCIE_PIN51: length 375.3
  IN3 w0.127: v2(238.15,76.24) 237.67,76.72 236.02,76.72 235.53,76.24 234.49,76.24 233.75,76.98 229.77,76.98 225.93,73.14 224.99,73.14 221.13,69.28 221.13,67.53 206.72,53.11 201.66,53.11 192.35,43.8 185.96,43.8 184.64,42.48 177.66,42.48 176.95,41.77 170.78,41.77 169.32,40.31 168.9,40.31 168.53,39.94 168.03,39.94 166.28,38.19 148.05,38.19 145.06,41.19 123.28,41.19 121.73,42.74 102.43,42.74 99.98,45.19 79.36,45.19 79.12,45.43 76.87,45.43 76.63,45.19 72.93,45.19 72.27,45.85 70.45,45.85 70.02,46.28 68.13,46.28 66.41,48.01 64.42,48.01 63.76,48.67 61.81,48.67 59.98,50.5 54.55,50.5 46.48,58.57 46.48,60.91 44.46,62.93 44.46,64.41 43.83,65.05 43.83,70.65 42.48,72 41.02,72 39.74,73.28 39.74,74.68 38.53,75.88 38.53,77.91 35.27,81.17 33.76,81.17 31.69,83.24 31.69,89.93 32.1,90.34 32.1,96.75 30.22,98.63 30.22,101.52 17.41,114.33 17.41,117.06 12.18,122.29 12.18,124.82 8.61,128.38 8.13,128.38 2.67,133.85 2.67,139.54 1.54,140.67 1.54,145.84 3.52,147.82 3.52,154.17 4.18,154.83 4.18,156.59 11.33,163.74 23.68,163.74 24.16,163.26 29.89,163.26 v2(31.42,161.74)
  BOTTOM w0.102: JMINI4.51 32.84,160.31 v1(32.24,160.91) v2(31.42,161.74) ; v2(238.15,76.24) 238.48,75.91 U46.A57
MSATA_PRX_DTX_N4: length 2.4
  BOTTOM w0.102: JMINI4.25 22.44,158.7 22.15,158.99 22.15,159.16 22.22,159.23 22.22,159.53 C448.2
MSATA_PRX_DTX_N4_C: length 127.3
  IN3 w0.127: v2(22.43,162.04) 22.33,162.04 22.26,161.97 22.26,161.87 22.09,161.7 22.09,159.77 20.98,158.66 20.47,158.66 18.34,156.53 18.24,156.53 16.43,154.72 13.84,154.72 13.28,154.17 13.28,148.87 11.78,147.37 11.78,145.71 11.56,145.48 11.56,143.47 12.27,142.76 12.32,142.76 13.13,141.95 13.13,138.67 19.12,132.68 19.12,130.64 22.04,127.73 22.04,123.18 35.33,109.89 37.64,109.89 40.71,106.83 40.71,106.27 56.06,90.92 63.14,90.92 64.37,89.7 64.91,89.7 65.08,89.87 65.2,89.87 65.28,89.95 v2(65.28,90.03)
  BOTTOM w0.076: UH1.BD13 73.04,76.48 73.1,76.42 73.25,76.42 73.37,76.54 73.37,76.69 73.1,76.96 73.1,77.57 73.01,77.67 73.01,77.78 73.03,77.8 73.03,77.82
  BOTTOM w0.102: v2(22.43,162.04) 22.24,161.86 22.24,161.13 C448.1 ; v2(65.28,90.03) 65.44,89.87 67.45,89.87 70.89,86.42 70.89,82.71 72.78,80.83 72.78,79.49 73.03,79.24 73.03,77.82
MSATA_PRX_DTX_P4: length 2.4
  BOTTOM w0.102: C447.2 22.01,159.56 22.01,159.32 21.93,159.25 21.93,158.99 21.64,158.7 JMINI4.23
MSATA_PRX_DTX_P4_C: length 127.4
  IN3 w0.127: v2(21.84,162.04) 21.84,159.88 20.88,158.91 20.37,158.91 18.23,156.78 18.13,156.78 16.33,154.97 13.74,154.97 13.03,154.27 13.03,148.97 11.54,147.47 11.54,145.81 11.31,145.58 11.31,143.37 12.16,142.51 12.21,142.51 12.88,141.85 12.88,138.57 18.88,132.57 18.88,130.54 21.79,127.62 21.79,123.08 35.23,109.64 37.54,109.64 40.46,106.72 40.46,106.16 55.95,90.67 63.04,90.67 64.26,89.45 v2(65.25,89.45)
  BOTTOM w0.076: UH1.BB13 73.06,76.1 72.76,76.49 72.76,76.74 72.94,76.92 72.94,77.5 72.84,77.6 72.84,77.78 72.82,77.8 72.82,77.82
  BOTTOM w0.102: v2(21.84,162.04) 22.03,161.86 22.03,161.13 C447.1 ; 72.82,77.82 72.82,79.15 72.56,79.4 72.56,80.74 70.68,82.62 70.68,86.33 67.36,89.65 65.45,89.65 v2(65.25,89.45)
MSATA_PTX_DRX_N4: length 2.4
  BOTTOM w0.102: JMINI4.31 24.84,158.71 25.11,158.98 25.11,159.36 25.2,159.45 25.2,159.55 C445.2
MSATA_PTX_DRX_N4_C: length 136.7
  IN3 w0.089: 71.84,76.38 71.85,76.37 71.9,76.37 72.14,76.14 72.59,76.14 72.82,75.91 72.82,74.03 73.05,73.8 73.2,73.8 v2(73.4,73.6)
  IN3 w0.127: v2(26.77,162.62) 23.57,162.62 23.26,162.93 20.29,162.93 18.38,161.02 18.34,161.02 12.13,154.81 12.13,150.36 9.15,147.39 9.15,141.72 11.53,139.34 11.53,137.09 16.69,131.93 16.69,129.88 20.81,125.77 20.81,122.79 33.78,109.82 33.78,109.11 35.07,107.82 35.56,107.82 39,104.37 40.96,104.37 55.57,89.76 62.7,89.76 68.12,84.34 68.12,81.42 69.83,79.71 69.83,78.4 71.84,76.38
  BOTTOM w0.089: UH1.AV15 73.82,73.94 73.48,73.6 v2(73.4,73.6)
  BOTTOM w0.102: C445.1 25.11,161.04 25.11,161.39 v3(25.59,161.87) 26.12,162.41 26.55,162.41 v2(26.77,162.62)
MSATA_PTX_DRX_P4: length 2.4
  BOTTOM w0.102: JMINI4.33 25.64,158.7 25.32,159.02 25.32,159.27 25.41,159.36 25.41,159.54 C446.2
MSATA_PTX_DRX_P4_C: length 136.7
  IN3 w0.089: v2(73.4,74.18) 73.4,74.04 73.34,73.98 73.12,73.98 73,74.1 73,75.98 72.67,76.31 72.21,76.31 72.03,76.5 72.03,76.55 72.02,76.56
  IN3 w0.127: v2(26.77,161.86) 26.85,161.94 26.85,162.12 26.76,162.2 26.6,162.2 26.43,162.38 23.46,162.38 23.16,162.68 20.39,162.68 18.49,160.77 18.44,160.77 12.38,154.71 12.38,150.26 9.4,147.28 9.4,141.82 11.78,139.44 11.78,137.19 16.94,132.03 16.94,129.99 21.06,125.87 21.06,122.9 34.03,109.92 34.03,109.21 35.17,108.06 35.66,108.06 39.11,104.62 41.06,104.62 55.68,90.01 62.81,90.01 68.37,84.44 68.37,82.66 68.48,82.56 68.48,82.12 68.37,82.02 68.37,81.52 69.29,80.61 69.44,80.61 69.74,80.31 69.74,80.16 70.08,79.82 70.08,78.5 72.02,76.56
  BOTTOM w0.102: v2(73.4,74.18) 73.76,74.54 UH1.AW15 ; v2(26.77,161.86) 26.77,161.99 26.57,162.19 26.21,162.19 25.94,161.92 25.94,161.9 25.56,161.53 25.54,161.53 25.32,161.3 25.32,160.95 25.47,160.8 C446.1
MSCLK: length 281.8
  TOP w0.102: v2(209.4,70.75) 209.4,69.86 211.3,67.96 211.3,63.68 218.58,56.4 224.35,56.4 231.64,49.11 232.54,49.11 234.03,47.61 234.24,47.61 234.87,46.98 236.16,46.98 236.21,47.03 236.22,47.03 236.55,47.36 238.71,47.36 238.81,47.46 240.33,47.46 240.55,47.69 241.48,47.69 242.55,48.76 244.12,48.76 245.18,47.69 245.31,47.69 246.18,46.83 v2(246.33,46.83)
  IN3 w0.127: v2(274.42,30.24) 274.42,35.29 273.43,36.28 271.42,36.28 270.69,37.02 262.39,37.02 259.31,40.11 259.31,43.32 254.18,48.45 251.48,48.45 250.54,47.51 249.02,47.51 247.83,46.32 246.84,46.32 v2(246.33,46.83)
  IN4 w0.109: v2(124.31,165.93) 124.69,165.55 126.95,165.55 129.87,162.62 129.87,160.35 128.22,158.7 127.19,158.7 126.44,157.95 126.44,155.84 123.48,152.88 123.48,151.73 121.49,149.73 121.49,139.89 122.97,138.41 122.97,135.12 125.55,132.54 125.55,131.35 126.82,130.09 126.82,127.87 127.45,127.23 127.45,117.61 124.16,114.31 121.41,114.31 120.06,112.97 120.06,106.81 122.56,104.31 133.1,104.31 133.17,104.24 134.94,104.24 145.23,93.96 185.92,93.96 209.12,70.75 v2(209.4,70.75)
  BOTTOM w0.102: U51.B43 247.39,46.17 247.27,46.29 246.86,46.29 v2(246.33,46.83) ; JMINI2.19 121.09,167.31 121.89,166.51 123.72,166.51 v2(124.31,165.93) ; JDEG2.5 275.1,33.09 274.62,32.62 274.62,32.09 274.27,31.73 274.27,31 R847.2 274.12,30.54 v2(274.42,30.24)
MSDATA: length 276.7
  TOP w0.102: v2(209.98,67.98) 209.98,64.09 218.28,55.79 223.46,55.79 227.47,51.78 228.08,51.78 233.72,46.14 235.17,46.14 235.8,45.5 237.45,45.5 237.71,45.77 240.33,45.77 240.98,45.12 241.24,45.12 241.9,44.46 245.39,44.46 245.77,44.08 245.77,43.73 246.28,43.22 248,43.22 248.44,43.65 249.56,43.65 250.85,44.94 250.85,45.96 250.37,46.44 v2(250.14,46.44)
  IN3 w0.127: v2(250.14,46.44) 251.81,48.12 254.07,48.12 259.05,43.14 259.05,40.04 262.32,36.77 270.03,36.77 271.7,35.09 272.79,35.09 273.1,34.79 273.1,30.42 272.77,30.09 272.11,30.09 v2(271.6,29.58)
  IN4 w0.109: v2(209.98,67.98) 209.96,67.98 188.14,89.8 173.53,89.8 170.66,92.67 144.25,92.67 133.96,102.96 132.66,102.96 132.58,103.05 122.04,103.05 118.8,106.29 118.8,114.57 121.75,117.52 124.9,117.52 126.11,118.74 126.11,126.72 122.45,130.38 122.45,133.69 121.06,135.08 121.06,137.02 120.23,137.85 120.23,150.86 120.06,151.03 v2(120.06,153.3)
  BOTTOM w0.102: JMINI2.14 115.89,157.71 R706.2 116.05,156.86 116.05,154.55 116.71,153.89 118.06,153.89 119.05,152.9 119.66,152.9 v2(120.06,153.3) ; v2(271.6,29.58) 272.08,30.06 273.38,30.06 273.81,29.63 R850.2 274.29,29.53 274.87,30.1 274.87,30.56 274.65,30.78 274.65,31.81 275.43,32.59 JDEG2.4 ; U51.A40 248.92,46.42 248.97,46.37 249.4,46.37 v1(249.96,46.93) R869.2 250.49,46.44 v2(250.14,46.44)
MUX_AUX: length 57.6
  TOP w0.102: U9.52 29.8,150.3 29.97,150.13 29.97,149.49 29.87,149.39 29.67,149.39 29.56,149.49 29.56,149.92 29.46,150.03 29.28,150.03 28.78,149.52 28.78,148.27 v2(28.68,148.17) 28.48,148.36 28.48,149.55 28.91,149.98 28.91,150.15 29,150.24 U9.50 ; Q335.1 19.77,148.54 v2(20.01,148.3)
  IN1 w0.117: v2(28.68,148.17) 28.58,148.17 28.5,148.09 28.5,147.05 29.01,146.54 29.18,146.54 29.43,146.29 29.43,146.12 29.68,145.87 29.85,145.87 30.1,145.63 30.1,145.45 31.44,144.11 31.44,135.04 29.08,132.67 29.08,121.37 30.07,120.38 30.07,117.67 31.27,116.47 31.68,116.47 31.98,116.76 v2(31.98,116.78)
  IN4 w0.117: v2(28.68,148.17) 28.5,147.99 28.5,146.95 28.07,146.52 24.89,146.52 22.66,148.76 21.56,148.76 21.12,149.2 20.91,149.2 v2(20.01,148.3)
  BOTTOM w0.102: U629.32 32.94,116.68 32.84,116.58 32.17,116.58 v2(31.98,116.78)
MUX_AUX#: length 54.7
  TOP w0.102: Q335.4 21.07,151.31 21.18,151.42 21.48,151.42 21.71,151.19 v2(21.71,151.13) ; U9.51 29.4,151.15 29.11,151.44 28.9,151.44 28.6,151.15 U9.49 28.6,150.27 28.69,150.18 28.69,150.07 28.27,149.64 28.27,148.35 v2(28.09,148.17)
  IN1 w0.117: v2(28.09,148.17) 28.26,148 28.26,146.96 31.21,144.01 31.21,135.13 28.85,132.77 28.85,121.28 29.84,120.29 29.84,117.57 31.17,116.23 31.92,116.23 v2(31.98,116.17)
  IN4 w0.117: v2(28.09,148.17) 28.26,148 28.26,147.05 27.97,146.76 24.99,146.76 22.76,148.99 21.66,148.99 21.15,149.51 21.15,150.57 v2(21.71,151.13)
  BOTTOM w0.102: U629.31 32.94,116.28 32.86,116.36 32.17,116.36 v2(31.98,116.17)
MUX_CA_DET: length 91.1
  TOP w0.102: U9.11 v2(31.34,155.64) ; v2(31.09,159.53) 31.57,160.01 R493.2
  IN3 w0.127: v2(31.34,155.64) 31.34,159.27 v2(31.09,159.53) 30.99,159.63 30.5,159.63 30.1,159.22 30.1,159.17 28.93,158 20.71,158 17.12,154.41 17.12,152.31 17.68,151.75 17.68,141.77 27.05,132.4 27.05,123.51 27.28,123.28 v2(27.51,123.28) 29.95,120.84 29.95,117.59 34.31,113.22 37.79,113.22 41.88,109.13 43.08,109.13 v2(44.93,107.28)
  BOTTOM w0.102: U629.48 32.66,123.08 32.36,123.38 29.92,123.38 29.82,123.28 v1(28.71,123.28) v2(27.51,123.28) ; Q347.2 v2(44.93,107.28)
MUX_D0: length 37.4
  TOP w0.102: C505.1 36.73,152.06 37.01,152.06 v2(37.31,151.75)
  IN1 w0.117: v2(32.03,122.39) 32.03,122.34 31.86,122.17 31.51,122.17 30.76,122.92 30.76,123.27 30.86,123.37 30.86,123.77 30.76,123.87 30.76,124.22 30.86,124.32 30.86,124.73 30.76,124.83 30.76,130.9 34.19,134.33 34.19,134.61 36.65,137.07 36.65,151.93 36.91,152.18 37.39,152.18 37.49,152.08 37.49,151.93 v2(37.31,151.75)
  BOTTOM w0.102: v2(32.03,122.39) 32.22,122.19 32.88,122.19 32.97,122.28 U629.46
MUX_D0#: length 37.5
  TOP w0.102: v2(37.31,152.64) 36.94,152.27 36.69,152.27 C506.1
  IN1 w0.117: v2(37.31,152.64) 37.09,152.42 36.81,152.42 36.41,152.02 36.41,137.17 33.95,134.71 33.95,134.43 30.52,131 30.52,122.83 31.41,121.93 31.88,121.93 v2(32.03,121.78)
  BOTTOM w0.102: U629.45 33.42,121.89 32.97,121.89 32.88,121.98 32.22,121.98 v2(32.03,121.78)
MUX_D0#_C: length 3.6
  TOP w0.102: C506.2 35.1,152.24 34.8,152.24 v3(34.5,152.53) 34.28,152.75 33.04,152.75 32.95,152.84 U9.4
MUX_D0_C: length 3.6
  TOP w0.102: C505.2 35.14,152.02 34.71,152.02 34.54,152.18 34.52,152.18 34.17,152.53 33.04,152.53 32.95,152.44 U9.3
MUX_D1: length 41.3
  TOP w0.102: v2(37.21,153.45) 36.88,153.78 36.68,153.78 C507.1
  IN1 w0.117: v2(32,121.2) 31.63,120.82 31.24,120.82 30.85,121.21 30.85,121.3 30.85,121.3 30.85,121.36 30.57,121.64 30.51,121.64 30.51,121.63 30.43,121.63 29.89,122.17 29.89,122.47 30,122.57 30,122.97 29.89,123.07 29.89,131.78 32.98,134.86 32.98,135.53 35.52,138.07 35.52,152.95 36.45,153.89 37.11,153.89 37.31,153.68 37.31,153.56 v2(37.21,153.45)
  BOTTOM w0.102: v2(32,121.2) 32.2,121 32.86,121 32.94,121.08 U629.43
MUX_D1#: length 41.4
  TOP w0.102: v2(37.21,154.29) 36.92,154 36.74,154 C508.1
  IN1 w0.117: v2(32,120.59) 31.14,120.59 29.66,122.07 29.66,131.88 32.74,134.96 32.74,135.62 35.28,138.16 35.28,153.05 36.35,154.12 37.04,154.12 v2(37.21,154.29)
  BOTTOM w0.102: v2(32,120.59) 32.2,120.78 32.84,120.78 32.94,120.68 U629.42
MUX_D1#_C: length 3.9
  TOP w0.102: U9.7 32.79,154.04 33.2,154.45 33.22,154.45 33.52,154.75 34.41,154.75 35.1,154.06 35.22,154.06 35.46,154.29 C508.2
MUX_D1_C: length 4
  TOP w0.102: U9.6 32.7,153.64 33.29,154.24 33.31,154.24 33.61,154.53 34.3,154.53 v3(34.47,154.37) 34.99,153.84 35.09,153.84 C507.2
MUX_D2: length 43.6
  TOP w0.102: C509.1 36.71,155.59 37.08,155.59 37.25,155.42 37.63,155.42 37.92,155.13 v2(37.92,155.11)
  IN1 w0.117: v2(32,119.98) 32,119.93 32.18,119.75 32.66,119.75 33.11,120.2 33.11,120.65 33.02,120.75 33.02,121.15 33.11,121.24 33.11,121.59 33.02,121.69 33.02,122.09 33.11,122.18 33.11,129.37 35.03,131.28 35.03,134.46 38.35,137.78 38.35,155.46 38.25,155.56 37.87,155.56 37.74,155.44 37.74,155.28 v2(37.92,155.11)
  BOTTOM w0.102: v2(32,119.98) 32.2,119.78 32.82,119.78 32.92,119.88 U629.40
MUX_D2#: length 43.6
  TOP w0.102: C510.1 36.71,155.81 37.17,155.81 37.34,155.64 37.57,155.64 v2(37.92,155.99)
  IN1 w0.117: v2(32,119.37) 32.15,119.51 32.76,119.51 33.35,120.1 33.35,129.27 35.26,131.19 35.26,134.36 38.58,137.68 38.58,155.56 38.35,155.8 38.12,155.8 v2(37.92,155.99)
  BOTTOM w0.102: v2(32,119.37) 32.2,119.56 32.83,119.56 32.92,119.48 U629.39
MUX_D2#_C: length 3.6
  TOP w0.102: C510.2 35.11,155.8 34.29,155.8 34.28,155.82 33.74,155.82 33.73,155.8 33.59,155.8 32.93,155.15 32.82,155.15 32.72,155.24 U9.10
MUX_D2_C: length 3.6
  TOP w0.102: U9.9 32.71,154.84 32.8,154.93 33.02,154.93 33.68,155.59 v3(34.01,155.59) 35.13,155.59 C509.2
MUX_D3: length 47.8
  TOP w0.102: C511.1 36.71,157.37 37.17,157.37 37.32,157.53 37.65,157.53 v2(37.97,157.21)
  IN1 w0.117: v2(37.97,157.21) 37.79,157.39 37.79,157.57 37.87,157.65 38.4,157.65 39.11,156.94 39.11,137.19 35.81,133.9 35.81,130.83 34.26,129.27 34.26,124.88 33.98,124.6 33.98,121.31 33.88,121.21 33.88,120.8 33.98,120.7 33.98,120.35 33.88,120.25 33.88,119.85 33.98,119.75 33.98,119.39 33.13,118.54 32.25,118.54 v2(32,118.78)
  BOTTOM w0.102: U629.37 32.95,118.68 32.86,118.59 32.2,118.59 v2(32,118.78)
MUX_D3#: length 47.8
  TOP w0.102: C512.1 36.71,157.59 37.08,157.59 37.23,157.75 37.64,157.75 v2(37.97,158.08)
  IN1 w0.117: v2(32,118.17) 32.13,118.3 33.23,118.3 34.22,119.29 34.22,124.51 34.49,124.78 34.49,129.17 36.05,130.73 36.05,133.8 39.34,137.09 39.34,157.04 38.5,157.88 38.17,157.88 v2(37.97,158.08)
  BOTTOM w0.102: U629.36 32.95,118.28 32.86,118.37 32.2,118.37 v2(32,118.17)
MUX_D3#_C: length 3.9
  TOP w0.102: C512.2 35.11,157.58 v3(34.49,157.58) 34.26,157.58 33.42,156.74 33.03,156.35 32.86,156.35 32.77,156.44 U9.13
MUX_D3_C: length 3.9
  TOP w0.102: U9.12 32.77,156.04 32.86,156.13 33.12,156.13 33.58,156.59 34.34,157.35 34.77,157.35 34.78,157.37 35.13,157.37 C511.2
MUX_HPD: length 56.3
  TOP w0.102: U9.5 v2(31.34,153.24) ; v2(32.56,121.48) 32.56,121.21 v1(33.02,120.75)
  IN3 w0.127: v2(32.56,121.48) 32.56,122.49 27.99,127.06 27.99,131.78 17.91,141.87 17.91,148.88 18.82,149.8 18.9,149.8 20.01,150.91 20.01,151.85 22.5,154.34 22.5,156.43 22.93,156.86 27.3,156.86 28.4,155.77 28.4,155.54 30.69,153.24 v2(31.34,153.24)
  BOTTOM w0.102: U629.44 v2(32.56,121.48)
MUX_PC0: length 8.8
  IN3 w0.127: v2(32.54,115.86) 32.54,115.89 33.02,116.37 33.02,118.6 v2(32.54,119.08)
  BOTTOM w0.102: R98.1 R115.1 v1(31.22,114.78) 31.22,115.2 31.62,115.61 32.28,115.61 v2(32.54,115.86) ; U629.38 v2(32.54,119.08)
MUX_PC1: length 4.9
  BOTTOM w0.102: U629.55 35.71,125.02 35.94,125.24 35.94,125.57 35.48,126.02 35.18,126.02 v1(34.93,126.27) 33.88,127.32 R116.1 R99.1
MUX_PI0: length 4.4
  BOTTOM w0.102: R124.1 34.82,128.31 R123.1 34.82,127.04 36.14,125.72 36.14,125.16 36.11,125.13 U629.56
MXM_ALERT#: length 7.8
  TOP w0.102: JMXM1.58 46.44,144.3 47.11,143.63 v2(47.11,143.55)
  BOTTOM w0.102: Q5.3 44.74,140.54 R4.2 44.5,142.45 v1(46.43,142.45) 47.11,143.14 v2(47.11,143.55)
MXM_BIA_PWM: length 84.3
  TOP w0.102: v2(43.13,142.81) 44.12,141.82 44.12,141.33 47.69,137.76 JMXM1.63
  IN1 w0.109: v2(99.16,162.98) 98.63,163.51 98.3,163.51 97.9,163.12 97.9,162.93 95.42,160.45 95.42,156.44 94.58,155.6 88.79,155.6 86.61,153.42 74.92,153.42 73.11,151.61 70.52,151.61 69.94,151.03 69.94,149.48 69.25,148.79 67.62,148.79 66.4,147.57 65.79,147.57 65.1,146.88 55.93,146.88 55.17,146.12 49.66,146.12 48.22,144.68 44.78,144.68 44.01,143.92 44.01,143.29 43.53,142.81 v2(43.13,142.81)
  BOTTOM w0.102: v2(99.16,162.98) 99.49,162.65 100.33,162.65 100.76,163.08 102.11,163.08 103,163.97 103.5,163.97 103.81,164.28 103.81,165.27 103.99,165.44 U3.2 ; v2(43.13,142.81) 43.42,142.81 v1(43.62,142.61)
MXM_CLK_REQ#: length 3
  TOP w0.102: R1978.2 79.44,147.53 v1(79.44,146.76) JMXM1.182
MXM_CRT_BLU: length 61.6
  TOP w0.102: v2(84.94,141.11) 84.94,142.63 84.05,143.52 84.05,143.98 83.94,144.09 JMXM1.200
  IN4 w0.109: v2(94.31,102.12) 94.4,102.22 94.4,103.51 95.05,104.15 95.05,107.71 95.43,108.1 95.43,113.84 97.5,115.91 97.5,118.43 97.02,118.91 97.02,119.75 96.9,119.87 96.9,121.37 97.02,121.49 97.02,129.84 91.16,135.69 82.12,135.69 80.36,137.45 80.36,138.63 81.38,139.64 84.28,139.64 84.99,140.36 84.99,141.06 84.94,141.11 v2(84.94,141.11)
  BOTTOM w0.102: U19.9 94.31,102.12 v2(94.31,102.12)
MXM_CRT_DDC_CLK: length 62.5
  TOP w0.102: R5.2 81.76,146.44 80.94,145.62 JMXM1.188 80.94,143.6 80.82,143.48 80.82,139.85 81.89,138.79 v2(81.89,138.32)
  IN4 w0.109: v2(81.89,138.32) 81.89,138.03 82.73,137.18 91.78,137.18 99.16,129.8 99.16,127.6 99.27,127.49 99.27,122.54 98.78,122.06 98.78,119.49 99.67,118.61 99.67,115.81 99.49,115.63 99.33,115.63 97.31,113.61 97.31,108.29 97.61,107.99 97.61,103.94 97.04,103.37 96.73,103.37 95.91,102.55 v2(95.91,102.2)
  BOTTOM w0.102: v2(95.91,102.2) U19.5
MXM_CRT_DDC_DAT: length 61.7
  TOP w0.102: v2(81.25,138.32) 80.21,139.36 80.21,143.45 80.41,143.65 80.41,144.87 JMXM1.186 80.44,146.52 v1(80.75,146.83) R3.2
  IN4 w0.109: v2(81.25,138.32) 81.25,137.79 82.48,136.56 91.52,136.56 98.53,129.56 98.53,127.36 98.65,127.24 98.65,122.8 98.02,122.16 98.02,121.27 97.77,121.03 97.77,120.27 97.99,120.05 97.99,119.17 98.45,118.71 98.45,115.63 96.32,113.5 96.32,103.89 95.27,102.84 95.27,102.25 v2(95.32,102.2)
  BOTTOM w0.102: U19.6 95.51,102.38 v2(95.32,102.2)
MXM_CRT_GRN: length 63.2
  TOP w0.102: JMXM1.198 83.44,142.38 84.28,141.54 v2(84.28,141.11)
  IN4 w0.109: v2(84.28,141.11) 84.28,140.62 83.92,140.26 81.13,140.26 79.75,138.88 79.75,137.19 81.86,135.08 90.9,135.08 95.91,130.07 95.91,124.63 96.4,124.14 96.4,121.81 96.26,121.68 96.26,119.63 96.4,119.5 96.4,118.66 96.89,118.17 96.89,116.17 94.82,114.1 94.82,108.62 93.65,107.46 93.65,101.94 94.05,101.54 v2(94.33,101.54)
  BOTTOM w0.102: v2(94.33,101.54) 94.36,101.54 94.71,101.89 U19.8
MXM_CRT_HSYNC: length 60.3
  TOP w0.102: JMXM1.192 81.94,143.85 81.84,143.75 81.84,140.83 83.11,139.56 v2(83.11,138.29)
  IN4 w0.109: v2(83.11,138.29) 83.59,138.77 91.97,138.77 92.48,138.27 92.48,138.01 101.09,129.4 101.09,122.47 100.72,122.1 100.72,113.06 101.27,112.51 101.27,109.87 98.64,107.23 98.64,103.15 97.51,102.02 v2(97.13,102.02)
  BOTTOM w0.102: U19.3 96.71,102.59 97.13,102.17 v2(97.13,102.02)
MXM_CRT_RED: length 63.8
  TOP w0.102: JMXM1.196 82.94,144.16 82.82,144.04 82.82,142.14 83.54,141.42 v2(83.54,141.14)
  IN4 w0.109: v2(94.36,100.7) 93.83,100.7 92.81,101.71 92.81,107.49 93.83,108.51 93.83,113.98 96.27,116.42 96.27,117.92 95.78,118.4 95.78,119.24 95.63,119.39 95.63,121.98 95.78,122.14 95.78,123.76 95.15,124.4 94.77,124.4 93.37,125.79 93.37,126.15 91.67,127.85 91.67,130.34 87.55,134.46 81.61,134.46 79.13,136.93 79.13,139.14 80.87,140.88 83.28,140.88 v2(83.54,141.14)
  BOTTOM w0.102: v2(94.36,100.7) 94.94,101.28 94.94,102.48 95.11,102.64 U19.7
MXM_CRT_VSYNC: length 59.2
  TOP w0.102: v2(82.52,138.29) 82.52,139.28 81.43,140.37 81.43,143.79 81.44,143.8 JMXM1.190
  IN4 w0.109: v2(96.49,102.22) 96.54,102.27 96.54,102.31 96.98,102.75 97.29,102.75 98.23,103.69 98.23,109.96 97.92,110.27 97.92,113.36 99.58,115.02 99.75,115.02 100.31,115.58 100.31,122.28 100.68,122.65 100.68,126.61 100.18,127.11 100.18,129.72 92.1,137.8 82.99,137.8 82.52,138.27 v2(82.52,138.29)
  BOTTOM w0.102: U19.4 96.31,102.41 v2(96.49,102.22)
MXM_CURI2C_CLK: length 1.8
  TOP w0.102: U60.5 13.54,143.23 13.75,143.44 13.85,143.44 14.08,143.21 14.22,143.21 14.62,142.81 R2182.2
MXM_CURI2C_DATA: length 1.7
  TOP w0.102: U60.6 13.57,143.88 13.78,143.67 13.95,143.67 14.18,143.44 14.37,143.44 R2183.2
MXM_DP_HDMI_HPD: length 185.1
  TOP w0.102: v2(123.89,129.57) D8.1 D18.1 D7.1 ; v2(241.53,72.96) 241.5,72.94 240.87,72.94 240.61,73.19 240.61,75.58 240.16,76.04 240.16,76.62 240.31,76.77 240.31,77.89 239.44,78.75 239.44,81.14 238.43,82.16 225.92,82.16 224.68,83.4 224.14,83.4 222.61,84.93 218.96,84.93 217.97,83.93 209.35,83.93 207.72,85.56 207.24,85.56 v2(207.16,85.64)
  IN1 w0.109: v2(241.53,72.96) 241.56,73 241.56,73.53 241.83,73.8 244.55,73.8 244.83,73.52 247.67,73.52 v2(247.98,73.22)
  BOTTOM w0.102: v2(207.16,85.64) 198.48,85.64 194.34,89.78 191.41,89.78 187.81,93.38 180.85,93.38 178.64,95.59 155.61,95.59 153.61,97.6 150.28,97.6 149.21,96.53 141.48,96.53 133.12,104.89 v1(132.24,104.89) 131.11,104.89 128.89,107.11 122.83,107.11 118.73,111.22 118.73,113.69 122.33,117.29 124.74,117.29 125.73,118.28 125.73,126.58 123.89,128.42 v2(123.89,129.57) ; R17.2 247.06,72.3 v2(247.98,73.22) ; U46.B4 242.63,71.91 242.26,71.54 241.76,71.54 241.45,71.84 241.45,72.89 v2(241.53,72.96)
MXM_DPB_AUX: length 86.4
  TOP w0.102: v2(56.69,112.74) 56.64,112.79 56.29,112.79 56.06,112.56 56.06,111.95 56.22,111.79 U20.12 ; JMXM1.300 108.94,144.29 108.76,144.11 108.76,143.86 108.56,143.66 108.56,142.18 112.09,138.65 112.09,135.37 107.75,131.03 107.75,129.5 108.74,128.51 108.86,128.51 108.94,128.59 v2(108.94,128.92)
  IN1 w0.102: v2(56.69,112.74) 56.84,112.89 56.84,113.37 57.63,114.15 60.69,114.15 64.91,118.37 64.91,121.79 71.83,128.72 84.1,128.72 84.68,129.3 107.37,129.3 107.96,128.72 108.74,128.72 v2(108.94,128.92)
  BOTTOM w0.102: v2(56.69,112.74) 56.88,112.55 56.88,111.79 C387.2
MXM_DPB_AUX#: length 86.5
  TOP w0.102: v2(108.94,128.08) 108.74,128.28 108.64,128.28 107.52,129.41 107.52,131.12 111.86,135.46 111.86,138.55 108.33,142.08 108.33,143.75 108.53,143.96 108.53,144.12 108.44,144.21 JMXM1.298 ; U20.9 58.17,112.33 57.76,112.74 v2(57.28,112.74)
  IN1 w0.102: v2(108.94,128.08) 108.94,128.28 108.74,128.49 107.86,128.49 107.28,129.07 106.76,129.07 106.69,128.99 106.33,128.99 106.26,129.07 105.95,129.07 105.87,128.99 105.52,128.99 105.44,129.07 84.78,129.07 84.19,128.49 71.92,128.49 65.14,121.7 65.14,118.27 60.79,113.92 57.73,113.92 57.07,113.27 57.07,112.89 57.22,112.74 v2(57.28,112.74)
  BOTTOM w0.102: v2(57.28,112.74) 57.11,112.57 57.11,111.79 C388.2
MXM_DPB_HPD: length 38.9
  TOP w0.102: v2(118.54,132.42) 119.62,132.42 D18.2 120.37,133.43
  BOTTOM w0.102: v2(118.54,132.42) 118.41,132.55 v1(117.12,132.55) 115.6,132.55 113.57,134.58 94.18,134.58 92.58,132.98 92.58,131.59 R2160.1 C696.1 91.16,130.44 91.36,130.24 91.36,127.83 91.24,127.7 JDOCK1.40
MXM_DPB_HPD_GATE: length 18.6
  TOP w0.102: JMXM1.302 109.44,144.22 109.7,143.96 110.26,143.96 110.44,143.78 116.9,143.78 120.47,140.2 v1(120.47,139.34) 120.47,137.3 121,136.77 R758.1 121.02,136.62 U14.4
MXM_DPB_N0: length 29
  TOP w0.102: JMXM1.274 102.44,144.18 102.54,144.08 102.54,143.78 102.75,143.56 102.75,142.85 103.12,142.48 v2(103.68,142.48)
  BOTTOM w0.102: v2(103.68,142.48) 103.68,142.59 103.48,142.79 103.25,142.79 103.17,142.71 103.17,141.26 99.53,137.62 v3(89.34,137.62) 88.06,137.62 86.65,136.21 84.96,136.21 84.71,135.96 84.71,135.83 84.47,135.59 84.34,135.59 84.13,135.37 84.13,135.25 83.89,135.01 83.76,135.01 83.46,134.7 83.46,134.21 C438.2
MXM_DPB_N1: length 28.2
  TOP w0.102: v2(105,142.43) 104.98,142.46 104.44,142.46 104.18,142.72 104.18,143.79 104.06,143.9 104.06,144.16 103.94,144.28 JMXM1.280
  BOTTOM w0.102: v2(105,142.43) 105,142.58 104.81,142.77 104.53,142.77 104.41,142.65 104.41,141.5 99.81,136.91 94.16,136.91 94.14,136.89 93.61,136.89 93.6,136.91 88.47,136.91 87.74,136.18 87.74,136.01 87.5,135.77 87.33,135.77 87.12,135.56 87.12,135.39 86.88,135.15 86.71,135.15 86.41,134.85 85.58,134.85 85.36,134.63 85.36,134.21 C440.2
MXM_DPB_N2: length 27.6
  TOP w0.102: v2(106.5,142.41) 105.94,142.41 105.6,142.75 105.6,144.02 105.44,144.18 JMXM1.286
  BOTTOM w0.102: C442.2 87.27,134.21 87.27,134.4 87.59,134.72 87.72,134.72 87.96,134.96 87.96,135.09 88.17,135.31 88.33,135.31 88.54,135.52 88.54,135.67 89.02,136.15 v3(98.64,136.15) 100.04,136.15 103.9,140.01 104.3,140.01 105.81,141.52 105.81,142.46 106.12,142.76 106.35,142.76 106.5,142.61 v2(106.5,142.41)
MXM_DPB_N3: length 27.1
  TOP w0.102: JMXM1.292 106.94,144.18 107.03,144.08 107.03,142.68 107.2,142.51 v2(107.85,142.51)
  BOTTOM w0.102: C444.2 89.43,133.87 89.08,134.23 89.08,134.56 89.84,135.32 90.33,135.32 90.41,135.24 90.76,135.24 90.84,135.32 91.15,135.32 91.22,135.24 91.58,135.24 91.65,135.32 92.23,135.32 92.24,135.31 92.77,135.31 92.78,135.32 100.23,135.32 104.18,139.27 104.89,139.27 105.03,139.41 107.21,141.59 107.21,142.56 107.45,142.8 107.61,142.8 107.85,142.56 v2(107.85,142.51)
MXM_DPB_P0: length 29
  TOP w0.102: v2(103.68,143.14) 103.68,143.06 103.31,142.7 103.21,142.7 102.97,142.94 102.97,143.65 102.75,143.87 102.75,144.04 102.94,144.23 JMXM1.276
  BOTTOM w0.102: C431.2 83.24,134.21 83.24,134.79 84.87,136.42 86.56,136.42 87.97,137.83 89.06,137.83 89.08,137.85 89.61,137.85 89.62,137.83 99.44,137.83 102.96,141.35 102.96,142.8 103.16,143 103.54,143 v2(103.68,143.14)
MXM_DPB_P1: length 28.1
  TOP w0.102: JMXM1.282 104.44,144.31 104.28,144.15 104.28,143.99 104.39,143.88 104.39,142.81 104.53,142.67 104.66,142.67 105,143.01 v2(105,143.14)
  BOTTOM w0.102: C439.2 85.15,134.21 85.15,134.72 85.43,135 85.43,135 85.49,135.07 86.32,135.07 88.38,137.12 v3(93.88,137.12) 99.72,137.12 104.19,141.59 104.19,142.74 104.44,142.99 104.85,142.99 v2(105,143.14)
MXM_DPB_P2: length 27.5
  TOP w0.102: v2(106.5,143.14) 106.5,142.99 106.13,142.62 106.03,142.62 105.81,142.84 105.81,144.03 105.94,144.16 JMXM1.288
  BOTTOM w0.102: C441.2 87.05,134.21 87.05,134.49 88.93,136.37 98.36,136.37 98.37,136.38 98.91,136.38 98.92,136.37 99.96,136.37 103.81,140.22 104.21,140.22 105.6,141.61 105.6,142.55 106.03,142.98 106.34,142.98 v2(106.5,143.14)
MXM_DPB_P3: length 27
  TOP w0.102: v2(107.85,143.14) 107.85,143.09 107.47,142.71 107.29,142.71 107.24,142.76 107.24,144.08 107.44,144.28 JMXM1.294
  BOTTOM w0.102: v2(107.85,143.14) 107.72,143.02 107.36,143.02 107.01,142.66 107.01,141.69 104.94,139.62 104.8,139.48 104.09,139.48 100.14,135.53 v3(92.51,135.53) 89.75,135.53 88.87,134.66 88.87,134.13 C443.2
MXM_DPC_AUX: length 92.3
  TOP w0.102: v2(41.78,110.55) 41.97,110.74 41.97,110.85 41.83,110.99 39.74,110.99 39.65,110.9 35.06,110.9 34.59,111.37 34.59,111.68 v2(34.39,111.87) 34.59,112.07 34.59,112.4 35.62,113.44 36.03,113.44 37.01,114.42 37.01,114.54 v2(36.83,114.72) ; JMXM1.255 97.19,135.96 97.05,135.82 97.05,135.32 92.93,131.2 48.99,131.2 48.21,130.42 48.21,117.56 48.58,117.2 48.69,117.2 48.78,117.29 48.92,117.29 49.02,117.39 49.02,117.51 v2(48.94,117.59)
  BOTTOM w0.102: v2(34.39,111.87) 34.57,112.05 34.57,112.2 C532.1 ; R129.2 41.94,110.18 41.94,110.4 v2(41.78,110.55) 41.91,110.68 41.91,111.07 48.35,117.51 48.87,117.51 v2(48.94,117.59) ; v2(36.83,114.72) 36.98,114.88 36.98,115.05 36.91,115.12 U629.23
MXM_DPC_AUX#: length 92.3
  TOP w0.102: JMXM1.253 96.69,135.96 96.84,135.81 96.84,135.41 95.53,134.1 92.84,131.41 48.9,131.41 47.99,130.51 47.99,117.47 48.49,116.98 48.84,116.98 v2(48.94,116.88) ; v2(42.37,110.55) 42.18,110.74 42.18,110.94 41.92,111.2 39.65,111.2 39.56,111.11 35.15,111.11 34.8,111.46 34.8,111.68 v2(35,111.87) 34.8,112.07 34.8,112.31 35.71,113.22 36.12,113.22 37.23,114.33 37.23,114.54 v2(37.41,114.72)
  BOTTOM w0.102: U629.22 37.31,115.11 37.25,115.04 37.25,114.88 v2(37.41,114.72) ; C531.1 34.84,112.19 34.84,112.04 v2(35,111.87) ; v2(48.94,116.88) 48.94,117.11 48.87,117.18 48.78,117.18 48.66,117.3 48.44,117.3 42.12,110.98 42.12,110.8 v2(42.37,110.55) 42.21,110.4 42.21,110.18 R132.2
MXM_DPC_AUX#_C: length 2.5
  BOTTOM w0.102: C531.2 34.81,113.77 34.81,113.89 34.81,114.01 35.2,114.41 35.2,114.97 35.31,115.08 U629.27
MXM_DPC_AUX_C: length 2.5
  BOTTOM w0.102: C532.2 34.59,113.75 34.59,114.12 v3(34.8,114.33) 34.99,114.52 34.99,115.01 34.91,115.08 U629.28
