# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_S4#: length 396.5
  TOP w0.102: v2(94.89,46.09) 94.89,41.06 96.01,39.94 96.01,38.34 96.82,37.53 97.69,37.53 RD42.1 102.94,32.27 105.97,32.27 109.73,28.51 v2(110.81,28.51) ; v2(120,24.49) 121.18,23.31 138.4,23.31 140.31,25.21 149.45,25.21 151.23,23.43 152.37,23.43 153.26,22.54 153.26,20.87 154.15,19.98 154.15,17.56 v2(154.79,16.93)
  IN3 w0.127: v2(120,24.49) 116.65,24.49 114.29,26.85 114.29,27.66 114.05,27.9 111.42,27.9 v2(110.81,28.51) ; v2(15.07,122.11) 15.07,120.04 17.87,117.25 17.87,114.52 30.68,101.71 30.68,98.82 32.56,96.94 32.56,90.15 32.15,89.74 32.15,83.43 33.95,81.62 35.46,81.62 41.82,75.26 41.82,73.43 44.33,70.92 44.33,66.42 44.94,65.81 44.94,63.1 46.94,61.1 46.94,58.76 54.74,50.95 60.17,50.95 61.03,50.09 63.17,50.09 63.97,50.89 64.64,50.89 65.38,50.15 65.38,50.03 v2(66.22,49.19) 68.67,46.74 70.21,46.74 70.61,46.33 75.79,46.33 76.23,45.89 80.29,45.89 80.89,46.48 84.37,46.48 84.95,45.9 94.7,45.9 v2(94.89,46.09) 95.38,46.57 97.46,46.57 98.17,45.86 99.96,45.86 101.91,43.9 107.71,43.9 108.42,43.19 121.97,43.19 123.52,41.64 145.25,41.64 148.24,38.65 165.05,38.65 166.85,40.45 168.39,40.45 168.71,40.77 169.13,40.77 170.59,42.23 176.76,42.23 177.47,42.94 184.45,42.94 185.83,44.32 192.22,44.32 201.47,53.57 206.46,53.57 220.57,67.68 220.57,69.56 224.69,73.67 225.78,73.67 229.54,77.43 236.08,77.43 236.34,77.18 238.12,77.18 238.45,76.85 239.24,76.85 239.52,76.57 240.56,76.57 v2(240.64,76.49)
  BOTTOM w0.089: 69.96,58.56 70.18,58.78 UH1.C6
  BOTTOM w0.102: v2(240.64,76.49) 240.48,76.33 U46.A61 ; v2(154.79,16.93) 154.53,17.18 PR206.1 ; 69.96,58.56 69.96,58.29 69.49,57.82 69.49,57.43 69,56.93 67.56,56.93 67.32,56.69 67.32,55.35 T118.1 67.92,54.75 67.92,50.89 v2(66.22,49.19) ; JAPS1.5 14.74,122.44 v2(15.07,122.11)
SIO_SLP_S5#: length 291.2
  TOP w0.102: T146.1 17.51,121.45 v2(17.32,121.64)
  IN1 w0.109: v2(70.53,65.96) 71,65.49 73.11,65.49 73.31,65.3 73.31,64.14 73.56,63.89 74.34,63.89 74.83,63.41 74.83,60.16 72.95,58.28 72.95,55.77 73.98,54.73 73.98,54.22 74.69,53.51 74.69,52.34 75.74,51.29 75.74,50.51 76.45,49.8 77.22,49.8 78.75,48.27 83.09,48.27 85.4,45.96 91.12,45.96 92.75,47.59 98.21,47.59 98.63,47.17 106.94,47.17 107.29,46.82 112.27,46.82 115.47,43.63 120.64,43.63 122.72,41.54 171.52,41.54 171.52,41.55 173.14,41.55 173.87,42.27 185.65,42.27 185.83,42.1 185.83,42.1 185.88,42.05 192.53,42.05 199.99,49.51 214.35,49.51 217.68,52.85 223.21,52.85 224.51,54.14 233.46,54.14 234.29,53.3 237.11,53.3 v2(237.31,53.1)
  IN3 w0.127: v2(17.32,121.64) 17.32,120.94 21.77,116.49 21.77,115.26 38.76,98.27 38.76,91.91 41.35,89.32 41.35,88.75 43.19,86.91 43.19,84.15 49.55,77.79 52.08,77.79 53.88,79.59 55.27,79.59 55.83,80.15 60.04,80.15 60.35,80.46 60.88,80.46 64.52,76.82 66.85,76.82 67.25,76.43 67.25,74.85 67.64,74.46 67.64,68.21 68.68,67.17 68.91,67.17 69.59,66.49 70.23,66.49 70.53,66.18 v2(70.53,65.96)
  BOTTOM w0.102: U51.A18 239.8,51.96 239.6,52.16 238.25,52.16 v2(237.31,53.1) ; UH1.Y7 70.34,66.15 v2(70.53,65.96) ; v2(17.32,121.64) 17.31,121.63 14.96,121.63 14.64,121.94 JAPS1.4
SIO_SLP_SUS#: length 223.6
  IN3 w0.127: v2(241.58,71.12) 241.58,71.37 241.76,71.54 242.56,71.54 243.18,72.15 243.18,74.54 243.56,74.92 243.56,76.29 242.37,77.48 239.62,77.48 239.39,77.71 229.42,77.71 227.59,75.88 226.57,75.88 220.34,69.66 220.34,67.83 206.31,53.8 201.38,53.8 192.13,44.55 185.74,44.55 184.35,43.17 177.38,43.17 176.67,42.46 170.49,42.46 169.03,41 168.61,41 168.29,40.68 166.76,40.68 164.95,38.88 148.34,38.88 145.34,41.87 123.67,41.87 122.12,43.42 110.21,43.42 108.71,44.92 101.22,44.92 99.98,46.17 98.35,46.17 97.69,46.83 94.87,46.83 94.72,46.67 91.67,46.67 90.26,48.08 80.55,48.08 80.27,47.8 76.43,47.8 76,48.24 69.4,48.24 65.12,52.52 v2(64.87,52.52)
  BOTTOM w0.102: v2(241.58,71.12) 241.58,70.95 241.84,70.7 242.41,70.7 242.62,70.91 U46.B6 ; v2(64.87,52.52) 65.02,52.67 67.41,52.67 67.72,52.97 67.72,53.4 65.89,55.23 T145.1 65.89,59.88 66.6,60.59 67.28,60.59 67.62,60.93 UH1.F1
SIO_SLP_WLAN#: length 411
  TOP w0.102: v2(129.95,153.26) 130.79,154.11 130.79,157.61 129.88,158.52 127.72,158.52 124.42,161.82 123.79,161.82 122.48,163.13 122.48,168.11 121.23,169.36 120.88,169.36 119.86,170.37 118.73,170.37 116.95,168.59 116.95,162.24 116.58,161.87 v2(116.36,161.87) 115.46,162.78 v1(114.72,162.78) 109.5,162.78 109.35,162.93 106.23,162.93 105.31,163.86 105.31,164.38 R815.1
  IN3 w0.127: v2(248.65,77.97) 249.32,77.97 251.59,75.7 v2(251.59,67.88)
  IN4 w0.089: v2(68.5,60.33) 69.03,60.86 69.79,60.86 70.1,60.54 70.1,60.44 70.26,60.29 70.86,60.29
  IN4 w0.109: v2(129.95,153.26) 129.95,152.39 128.3,150.75 127.32,150.75 124.38,147.81 124.38,142.76 125.83,141.31 125.83,140.7 124.52,139.38 124.52,134.17 125.97,132.71 125.97,131.52 127.24,130.26 127.24,128.04 127.87,127.41 127.87,117.43 124.33,113.89 121.58,113.89 120.48,112.79 120.48,106.99 122.74,104.73 133.28,104.73 133.34,104.66 135.12,104.66 145.41,94.38 186.1,94.38 205.7,74.78 207.33,74.78 209.83,72.28 215.24,72.28 217.02,70.5 217.02,69.99 219.5,67.5 226.55,67.5 227.48,68.44 227.48,69.1 227.94,69.56 229.01,69.56 233.93,74.49 242.77,74.49 245.77,77.48 248.17,77.48 v2(248.65,77.97) ; v2(116.36,161.87) 116.36,140.2 114.83,138.67 114.83,136.1 112.72,133.98 112.72,116.81 110.61,114.7 110.61,107.33 110.08,106.8 110.08,105.02 108.6,103.54 108.6,102.16 107.54,101.11 105.84,101.11 105.13,100.39 105.13,99.15 103.74,97.76 100.88,97.76 90.71,87.59 90.71,80.09 92,78.8 92,77.84 90.71,76.55 90.71,68.66 89.66,67.6 88.85,67.6 86.71,65.47 81.35,65.47 80.87,64.99 80.87,64.22 80.39,63.74 77.8,63.74 76.91,62.85 76.91,60.64 76.4,60.14 74.55,60.14 73.89,59.47 71.86,59.47 71.04,60.29 70.86,60.29
  BOTTOM w0.089: UH1.D2 68.47,59.85
  BOTTOM w0.102: 68.47,59.85 68.47,60.32 68.51,60.36 68.51,60.34 v2(68.5,60.33) ; v2(251.59,67.88) 251.36,67.65 247.99,67.65 247.31,66.97 245.95,66.97 245.64,66.66 U46.A14
SL_BAT_PRES#: length 2.5
  BOTTOM w0.254: PU1001.21 260.47,35.06 259.82,35.71 PR1023.1
SLICE_BAT_ON: length 97.6
  TOP w0.102: v2(234.24,62.34) 234.24,62.24 233.7,61.71 231.95,61.71 v2(231.42,62.24) 230.45,61.28 227.15,61.28 226.11,62.32 225.12,62.32 224.43,63.01 223.7,63.01 v2(223.26,62.57) ; v2(236.5,28.46) 236.5,30 228.95,37.55 228.95,39.69 229.28,40.02 229.28,45.71 228.52,46.47 227.33,46.47 225.35,48.45 v2(225.16,48.45)
  BOTTOM w0.102: R765.1 230.81,61.63 v2(231.42,62.24) 231.42,62.42 230.78,63.06 RP8.3 ; v2(234.24,62.34) 234.24,62.62 234.98,63.36 U46.A31 ; v2(223.26,62.57) 223.26,61.51 223.62,61.15 PU1080.2 225.02,61.15 225.25,60.92 225.25,55.33 226.39,54.19 226.39,50.21 v1(226.11,49.93) 225.16,48.98 v2(225.16,48.45) PQ1082.2 ; v2(236.5,28.46) 238.25,26.71 247.19,26.71 253.14,32.65 253.14,34.1 254.84,35.8 254.84,38.14 255.7,39 259.85,39 260.28,38.57 262.91,38.57 PR1016.2
SLICE_BAT_PRES#: length 319.4
  TOP w0.102: v2(234.3,65.47) 234.04,65.47 233.55,65.95 229.13,65.95 228.73,65.55 224.66,65.55 223.95,66.26 221.26,66.26 215.16,72.35 211.94,72.35 210.51,73.78 210.51,77.03 211.35,77.86 211.35,80.02 208.84,82.54 208.84,83.81 208.56,84.09 208.13,84.09 v2(207.75,83.71) ; v2(238.17,39.99) 237.08,38.9 237.08,38.14 235.99,37.05 235.99,33.43 236.9,32.51 236.9,24.36 234.32,21.78 229.36,21.78 228.19,22.95 225.73,22.95 224.2,21.43 219.68,21.43 219.55,21.3 218.23,21.3 217.8,20.87 217.8,20.87 214.96,18.03 214.96,15.08 211.12,11.24 201.52,11.24 200.63,10.35 200.63,9.14 PR33.1
  IN1 w0.109: v2(224.05,62.52) 225.67,64.14 230.48,64.14 231.84,62.78 232.31,62.78 v2(232.51,62.57)
  IN3 w0.127: v2(232.51,62.57) 233.3,63.36 233.3,64.47 v2(234.3,65.47) ; v2(238.17,39.99) 238.28,39.89 241.22,39.89 241.64,39.47 243.14,39.47 245.1,37.52 245.1,35.37 245.77,34.7 247.14,34.7 250.46,31.38 v2(252.73,31.38)
  IN4 w0.109: v2(238.17,39.99) 235.98,39.99 235.14,40.84 229.66,40.84 226.16,44.34 v2(224.53,44.34)
  BOTTOM w0.102: v2(224.05,62.52) 224.06,62.51 PU1080.1 224.88,61.8 225.53,61.15 225.53,55.46 226.59,54.39 226.59,49.94 225.6,48.95 225.6,46.9 224.53,45.83 v1(224.53,45.19) v2(224.53,44.34) ; U46.B33 234.73,65.04 v2(234.3,65.47) ; JDOCK1.143 119.28,118.74 119.28,119.6 119.18,119.7 118.85,119.7 118.74,119.59 JDOCK1.141 118.74,117.22 117.07,115.54 117.07,111.72 122.8,105.99 126.51,105.99 129.59,102.92 129.59,101.98 136.87,94.7 178.37,94.7 180.51,92.57 187.46,92.57 191.27,88.76 193.91,88.76 198.61,84.06 207.39,84.06 v2(207.75,83.71) ; PR1023.2 259.82,37.73 259.18,38.37 258.32,38.37 257.85,37.9 256.68,37.9 255.42,36.64 255.42,35.7 253.57,33.85 253.57,32.22 v2(252.73,31.38) 247.97,26.62 247.97,19.32 248.55,18.73 249.62,18.73 250.09,18.26 250.94,18.26 251.92,17.28 PD1100.1 ; R2158.2 231.98,61.48 232.51,62.01 v2(232.51,62.57)
SLICE_BST_CHG_EN: length 160.2
  TOP w0.102: PR1098.1 173.33,29.86 180.95,29.86 v2(181.25,30.16) ; v2(205.41,44.44) 205.41,43.68 206.78,42.3 206.78,40.6 210.18,37.2 212.04,37.2 214.15,35.09 v2(214.15,34.66) ; v2(229.49,62.22) 231.04,63.77 234.21,63.77 234.97,64.53 236.9,64.53 237.72,65.35 237.72,66.21 238.05,66.54 238.37,66.54 238.7,66.87 239.76,66.87 239.87,66.76 240.7,66.76 240.95,66.51 241.91,66.51 242.16,66.26 v2(242.16,66.05)
  IN1 w0.109: v2(214.15,34.66) 212.93,35.88 201.03,35.88 199.76,34.6 v2(199.76,34.24)
  IN3 w0.127: v2(214.15,34.66) 214.55,35.07 219.39,35.07 220.13,35.8 232.71,35.8 232.9,35.99 233.91,35.99 234.25,35.65 234.25,35.08 236.65,32.68 245.55,32.68 v2(247.71,30.52) 249.21,29.02 v2(249.21,26.98) ; v2(229.49,62.22) 229.26,62.22 228.89,61.85 228.05,61.85 224.08,57.88 224.08,54.92 222.59,53.44 220.44,53.44 219.85,52.85 212.69,52.85 205.41,45.56 v2(205.41,44.44) ; v2(181.25,30.16) 181.66,30.57 187.78,30.57 189.71,28.64 192.7,28.64 198.3,34.24 v2(199.76,34.24)
  BOTTOM w0.102: PQ1071.5 250.57,21.82 250.8,22.05 v1(250.8,22.77) 250.8,25.39 v2(249.21,26.98) ; U46.B16 242.33,65.91 242.19,66.05 v2(242.16,66.05) ; v2(247.71,30.52) 247.92,30.72 PR1033.2 ; R765.2 229.89,61.81 v2(229.49,62.22)
SLP_ME_CSW_DEV#: length 229.7
  TOP w0.102: v2(71.74,68.54) 71.26,69.03 v1(70.24,69.03) 69.78,69.03 69.4,68.64 66.31,68.64 66.17,68.5 63.16,68.5 RH222.1 62.28,67.7 61.85,68.14 60.12,68.14 RH223.1
  IN1 w0.109: v2(71.74,68.54) 71.31,68.97 69.77,68.97 69.44,68.65 68.19,68.65 68.06,68.52 66.77,68.52 65.45,67.2 65.45,65.75 67.86,63.34 67.86,61.6 67.21,60.95 67.21,59.02 67.79,58.43 67.79,58.03 67.16,57.39 67.16,55.22 67.88,54.51 67.88,51.8 70.41,49.26 70.41,48.68 70.83,48.26 74.36,48.26 74.85,47.77 77.03,47.77 78.11,46.69 81.34,46.69 83.12,44.9 92.98,44.9 94.61,46.53 97.77,46.53 98.2,46.11 106.5,46.11 106.85,45.77 111.13,45.77 114.44,42.46 120.32,42.46 122.28,40.49 171.95,40.49 171.96,40.49 173.33,40.49 173.33,40.49 173.57,40.49 174.3,41.22 183.05,41.22 184.12,40.15 187.33,40.15 187.76,40.58 192.84,40.58 200.36,48.1 v2(201.11,48.1)
  IN3 w0.127: v2(201.11,48.1) 201.97,48.96 202.4,48.96 205.41,51.97 207.37,51.97 224.2,68.8 226.18,68.8 227.6,70.22 228.43,70.22 230.59,72.38 232.15,72.38 233.93,74.16 236.37,74.16 237.18,73.34 v2(237.18,73.33)
  BOTTOM w0.102: UH1.AD11 72.13,68.15 v2(71.74,68.54) ; v2(237.18,73.33) 237.23,73.37 U46.B58
SM_RCOMP0: length 7.4
  TOP w0.305: v2(195.06,106.31) 194.59,106.78 JCPU1.AP3
  BOTTOM w0.381: v2(195.06,106.31) 195.1,106.31 195.62,105.79 195.62,104.67 195.81,104.48 v1(195.81,103.35) 195.81,101.56 196.44,100.93 RC42.1
SM_RCOMP1: length 7.4
  TOP w0.305: v2(196.06,106.3) 195.59,106.77 JCPU1.AR3
  BOTTOM w0.381: RC55.1 v1(197.46,101.21) 196.83,101.83 196.83,105.53 v2(196.06,106.3)
SM_RCOMP2: length 6.3
  TOP w0.305: JCPU1.AP2 194.59,105.78 v2(195.06,105.31)
  BOTTOM w0.381: v2(195.06,105.31) 194.72,104.96 v1(194.72,101.56) 194.72,100.78 195.27,100.22 RC49.1
SML1_SMBCLK: length 221.9
  IN3 w0.102: 68.46,62.88 68.49,62.88 68.5,62.87 69.84,62.87 v2(70.03,63.06)
  IN3 w0.127: v2(54.71,61.81) 54.53,61.99 54.45,61.99 54.15,62.29 54.15,62.98 55.04,63.87 58.42,63.87 59.05,63.23 62.36,63.23 62.64,63.51 67.44,63.51 68.07,62.88 68.46,62.88
  IN4 w0.109: v2(239.12,44.57) 238.01,44.57 237.4,43.97 235.84,43.97 235.08,44.74 235.08,45.56 234.34,46.29 233.53,46.29 232.61,47.21 229.73,47.21 229.31,47.63 209.35,47.63 208.4,48.58 199.65,48.58 195.57,44.5 185.25,44.5 184.43,43.68 177,43.68 176.4,44.28 172.06,44.28 171.39,44.95 163.55,44.95 162.89,44.28 141.96,44.28 141.3,43.63 122.22,43.63 121.49,44.35 112.03,44.35 109.71,46.68 93.11,46.68 92.68,46.24 86.27,46.24 84.44,48.07 65.78,48.07 64.47,49.38 62.61,49.38 58.51,53.48 58.51,54.8 57.55,55.77 57.55,59.81 55.37,61.99 54.88,61.99 v2(54.71,61.81)
  BOTTOM w0.089: v2(70.03,63.06) 69.75,62.78 UH1.K6
  BOTTOM w0.102: RPH5.1 55.25,61.79 55.08,61.96 54.86,61.96 v2(54.71,61.81) ; v2(239.12,44.57) 239.03,44.67 U51.B6
SML1_SMBDATA: length 221.1
  IN3 w0.102: v2(72.41,63.11) 71.92,63.11 71.45,62.64 68.5,62.64 68.49,62.63 68.46,62.63
  IN3 w0.127: 68.46,62.63 67.96,62.63 67.33,63.26 62.74,63.26 62.46,62.98 58.95,62.98 58.31,63.61 55.14,63.61 54.41,62.88 54.41,62.4 54.56,62.24 v2(54.71,62.4)
  IN4 w0.109: v2(54.71,62.4) 54.88,62.22 55.47,62.22 57.78,59.91 57.78,55.87 58.75,54.9 58.75,53.58 62.71,49.62 64.57,49.62 65.88,48.31 84.54,48.31 86.37,46.48 92.58,46.48 93.02,46.91 109.81,46.91 112.13,44.59 121.59,44.59 122.32,43.86 141.2,43.86 141.86,44.51 162.79,44.51 163.46,45.18 171.49,45.18 172.16,44.51 176.5,44.51 177.1,43.91 184.33,43.91 185.15,44.73 195.47,44.73 199.55,48.81 208.5,48.81 209.45,47.87 229.41,47.87 229.83,47.45 232.7,47.45 233.62,46.53 234.44,46.53 235.31,45.65 235.31,44.84 235.94,44.21 236.72,44.21 v2(236.89,44.38)
  BOTTOM w0.102: RPH5.2 55.19,62.29 55.09,62.19 54.92,62.19 v2(54.71,62.4) ; U51.A5 236.92,44.42 v2(236.89,44.38) ; UH1.N11 72.13,63.39 72.41,63.11 v2(72.41,63.11)
SNB_CPU_P1: length 3.6
  TOP w0.102: PR554.1 v1(163.44,157.49)
  TOP w0.508: PR554.1 166.14,157.49 166.6,157.04 PC545.2
SNB_CPU_P2: length 1.7
  BOTTOM w0.102: v1(192.68,158.65) 192.28,158.24 PR542.1
SNB_CPU_P3: length 3.2
  BOTTOM w0.102: PC507.2 v1(198.78,156.97)
  BOTTOM w0.508: PR515.1 PC507.2
SNUB_1.5VSP:
  vias: v1(98.37,24.97)
SNUB_1.35V:
  vias: v1(137.39,18.33)
SNUB_3V: length 1.4
  TOP w0.102: PC116.1 v1(39.84,50.53)
SNUB_5V: length 1.3
  TOP w0.102: PC119.1 v1(30.25,30.04)
SNUB_CHG: length 1.7
  BOTTOM w0.102: 217.11,21.34 v1(218.86,21.34)
SOFT_START_GC: length 275.6
  TOP w0.381: PR20.2 26.72,62.42 v2(26.19,62.95)
  IN2 w0.254: v2(26.19,62.95) 26.19,65.24 25.98,65.44 25.98,67.04 27.94,69 34.8,69 35.9,67.89 37.2,67.89 37.84,67.25 38.71,67.25 41.5,64.45 42.54,64.45 48.16,58.84 48.16,49.46 47.24,48.55 47.24,47.06 54.53,39.76 77.01,39.76 78.21,40.96 92.94,40.96 97.36,36.54 104.06,36.54 104.52,37 117.36,37 119.49,34.86 175.22,34.86 176.4,33.68 178.39,33.68 179.79,32.28 186.36,32.28 186.99,31.65 194.59,31.65 198.7,35.76 205.67,35.76 206.14,36.23 219.46,36.23 222.2,33.49 232.31,33.49 234.02,31.78 235.77,31.78 239.37,28.18 251.18,28.18 251.74,27.62 258.22,27.62 258.88,28.28 262,28.28 v2(262.97,27.32)
  BOTTOM w0.102: v4(26.4,63.5) 26.19,63.28 v2(26.19,62.95)
  BOTTOM w0.254: PU1001.2 v2(262.97,27.32)
SP_TPM_LPC_EN: length 31.3
  TOP w0.102: v2(236.17,80.15) 236.22,80.15 236.9,79.46 236.9,78.49 236.63,78.21 236.63,73.79 v2(236.17,73.33) 236.17,73.32 236.7,72.79 236.7,72.58 237.03,72.25 238.35,72.25 238.61,72.5 238.61,73.44 238.9,73.74 239.28,73.74 239.52,73.5 239.52,73.21 239.72,73.01 239.72,71.42 240.45,70.7 242.55,70.7 243.18,70.07 243.18,69.02 243.86,68.34 243.86,67.02 244.42,66.46 247.29,66.46 248.39,65.37 v2(248.39,65.32)
  BOTTOM w0.102: v2(236.17,80.15) 236.7,79.62 R772.2 ; v1(248.02,66.15) 248.39,65.79 v2(248.39,65.32) 247.93,64.86 247.83,64.86 R2188.1 ; U46.B56 236.23,73.39 v2(236.17,73.33)
SP_TPM_LPC_EN_R: length 7.5
  BOTTOM w0.102: R2195.2 247.48,66.65 v1(249.39,66.65) 250.31,65.73 U39.28 249.13,65.25 R2188.2 R2194.2
SPI_CLK32: length 13.4
  BOTTOM w0.102: R897.1 RE2.1 101.88,58.48 102.51,59.12 104.44,59.12 105.28,59.96 108.08,59.96 108.2,60.08 108.2,60.41 108.08,60.54 104.85,60.54 104.06,59.75 U53.6
SPI_CLK64: length 15
  BOTTOM w0.102: U52.6 104.42,66.87 104.6,66.69 108.53,66.69 108.66,66.56 108.66,66.27 108.53,66.14 102.86,66.14 102.14,65.43 v4(101.93,65.43) 101.05,65.43 RE1.1 R899.1
SPI_DIN32: length 13.2
  BOTTOM w0.102: R895.2 113.64,61.58 v1(112.7,61.58) 107.89,61.58 107.64,61.83 107.64,62.7 107.52,62.83 107.11,62.83 106.98,62.7 106.98,61.71 107.67,61.02 U53.2
SPI_DIN64: length 13.4
  BOTTOM w0.102: U52.2 107.44,68.14 107.31,68.01 107.31,67.53 107.44,67.4 112.19,67.4 112.37,67.58 112.37,68.47 112.5,68.59 v4(112.7,68.59) 112.9,68.59 113.03,68.47 113.03,67.55 113.16,67.42 113.69,67.42 113.82,67.55 R8.2
SPI_DO32: length 13.1
  BOTTOM w0.102: R900.1 102.34,56.71 v1(102.64,57.01) 103.1,57.47 106.04,57.47 106.2,57.62 106.2,58.71 106.42,58.94 107.72,58.94 107.85,59.07 107.85,59.32 107.72,59.45 105.46,59.45 105.33,59.32 105.33,58.61 105.21,58.48 U53.5
SPI_DO64: length 13.2
  BOTTOM w0.102: R901.1 102.88,63.95 v4(103.01,64.08) 103.82,64.88 104.8,64.88 104.95,65.04 108.71,65.04 108.84,65.16 108.84,65.47 108.71,65.6 U52.5
SPI_PCH_CLK: length 40.5
  TOP w0.102: v2(99.54,60.26) 99.62,60.19 99.62,59.75 99.49,59.63 99.11,59.63 98.98,59.75 98.98,60.62 99.11,60.74 99.41,60.74 99.54,60.87 99.54,61.08 99.42,61.2 99.11,61.2 98.98,61.33 v1(98.98,65.41) 98.98,65.7 98.86,65.82 98.42,65.82 98.3,65.95 98.3,66.28 98.42,66.41 98.96,66.41 99.08,66.54 99.08,66.79 98.96,66.92 98.4,66.92 98.3,67.02 98.3,70.9 98.42,71.03 98.78,71.03 98.91,70.9 98.91,67.55 99.03,67.42 99.46,67.42 v2(99.54,67.5)
  IN3 w0.127: v2(99.54,60.26) 99.46,60.34 99.08,60.34 98.96,60.21 98.96,59.44 99.08,59.31 99.83,59.31 102.82,56.33 103.83,56.33 v2(104.29,56.78)
  BOTTOM w0.102: R899.2 100.43,66.61 v2(99.54,67.5) ; JSPI1.7 108.53,52.62 108.2,52.95 108.2,53.99 RH181.1 108.51,54.67 106.4,56.78 v2(104.29,56.78) ; R897.2 100.43,59.37 v2(99.54,60.26)
SPI_PCH_CS0#: length 23.2
  IN3 w0.127: v2(115.34,69.43) 114.55,68.64 114.55,65.32 110.84,61.61 110.84,59.02 109.07,57.24 v2(106.75,54.93)
  BOTTOM w0.102: v2(115.34,69.43) 115.31,69.41 R7.1 ; v2(106.75,54.93) 106.73,54.9 RH182.1 106.73,53.02 107.53,52.22 JSPI1.9
SPI_PCH_CS0#_R: length 13.4
  BOTTOM w0.102: U52.1 112.34,69.41 112.6,69.66 112.6,70.5 112.44,70.65 112.11,70.65 111.99,70.78 111.99,71.31 112.11,71.44 v4(113.04,71.44) 115.98,71.44 116.1,71.31 116.1,70.9 115.98,70.78 115.47,70.78 115.37,70.68 115.37,70.14 115.24,70.02 114.83,70.02 114.71,70.14 114.71,70.65 114.58,70.78 113.99,70.78 113.82,70.6 R7.2
SPI_PCH_CS1#: length 15.5
  IN3 w0.127: v2(114.73,62.93) 115.29,62.93 115.92,62.29 115.92,60.77 113.77,58.61 113.77,55 v2(113.84,54.93)
  BOTTOM w0.102: v2(113.84,54.93) RH177.1 v1(112.88,53.33) 111.53,51.98 JSPI1.1 ; R936.1 v2(114.73,62.93)
SPI_PCH_CS1#_R: length 13.1
  BOTTOM w0.102: R936.2 112.41,62.29 111.9,61.79 107.97,61.79 107.85,61.91 107.85,63.97 107.97,64.1 108.38,64.1 108.51,63.97 v1(108.51,63.86) 108.51,62.42 108.63,62.29 U53.1
SPI_PCH_DIN: length 40.9
  TOP w0.102: v2(115.37,62.09) 115.75,62.47 115.75,63.42 115.64,63.52 113.33,63.52 113.21,63.65 113.21,63.9 113.33,64.03 115.64,64.03 115.75,64.13 115.75,64.43 115.64,64.54 113.23,64.54 113.1,64.66 113.1,64.92 113.23,65.04 115.64,65.04 115.75,65.15 115.75,65.45 115.64,65.55 v1(114.45,65.55) 113.23,65.55 113.1,65.68 113.1,65.93 113.23,66.06 115.64,66.06 115.75,66.16 115.75,66.31 115.9,66.46 115.9,67.68 v2(115.42,68.16)
  IN3 w0.127: v2(110.29,54.93) 111.3,55.94 111.3,57.67 112.39,58.76 112.39,58.94 111.95,59.38 111.95,59.56 112.22,59.83 112.39,59.83 112.84,59.39 113.02,59.39 113.29,59.66 113.29,59.84 112.87,60.25 112.87,60.43 113.14,60.7 113.32,60.7 113.74,60.29 113.92,60.29 114.18,60.55 114.18,60.73 113.81,61.11 113.81,61.29 114.07,61.56 114.25,61.56 114.63,61.18 114.81,61.18 115.37,61.74 v2(115.37,62.09)
  BOTTOM w0.102: v2(115.37,62.09) 115.37,62.04 R895.1 ; JSPI1.5 109.53,53.54 RH179.1 v2(110.29,54.93) ; v2(115.42,68.16) 115.39,68.14 R8.1
SPI_PCH_DO: length 41.3
  TOP w0.102: v2(100.07,57.52) 100.07,58.15 99.95,58.28 98.47,58.28 98.35,58.15 98.35,57.82 98.45,57.72 98.78,57.72 98.91,57.6 98.91,57.37 98.78,57.24 98.47,57.24 98.35,57.11 98.35,56.83 98.47,56.71 99.19,56.71 99.29,56.81 99.29,57.06 99.41,57.19 99.72,57.19 99.85,57.06 99.85,56.76 99.97,56.63 100.48,56.63 100.61,56.76 v1(100.61,57.24) 100.61,58.59 100.48,58.71 98.42,58.71 98.3,58.84 98.3,64.56 v2(98.07,64.79)
  IN3 w0.127: v2(100.07,57.52) 100.81,57.52 103.83,54.5 111.63,54.5 v2(112.06,54.93)
  BOTTOM w0.102: R900.2 100.07,57.37 v2(100.07,57.52) ; JSPI1.3 110.53,52.76 RH178.1 v2(112.06,54.93) ; v2(98.07,64.79) 98.44,64.79 98.59,64.94 98.59,65.04 98.72,65.16 99.17,65.16 99.3,65.04 99.3,64.12 99.48,63.95 R901.2
SPI_PCH_DO2: length 41.5
  TOP w0.102: v2(115.39,59.63) 113.78,59.63 109.95,55.79 109.13,55.79 109.03,55.89 109.03,56.1 108.9,56.22 108.65,56.22 108.52,56.1 108.52,55.89 108.42,55.79 108.11,55.79 108.01,55.89 108.01,56.07 107.88,56.2 107.63,56.2 107.5,56.07 107.5,55.89 107.4,55.79 105.81,55.79 v2(104.95,54.93)
  BOTTOM w0.102: v2(104.95,54.93) RH183.1 104.95,53.67 106.53,52.09 JSPI1.11 ; R9.1 114.73,64.71 v1(113.84,63.82) 113.61,63.59 110.62,63.59 110.46,63.74 110.46,64.86 110.34,64.99 109.85,64.99 109.73,64.86 109.73,63.72 109.6,63.59 109.35,63.59 109.22,63.46 109.22,63.08 109.35,62.95 113.66,62.95 114.35,63.64 115.11,63.64 115.24,63.77 115.24,64.58 115.37,64.71 115.77,64.71 115.9,64.58 115.9,60.78 115.39,60.27 v2(115.39,59.63) R3667.1
SPI_PCH_DO2_32: length 13.9
  BOTTOM w0.102: U53.3 112.11,59.75 112.24,59.63 112.24,59.43 112.34,59.32 112.75,59.32 112.88,59.2 112.88,58.94 112.75,58.82 112.34,58.82 112.24,58.72 112.24,58.41 112.34,58.31 112.8,58.31 112.93,58.18 112.93,57.93 112.8,57.8 112.34,57.8 112.24,57.7 112.24,57.39 112.34,57.29 v1(112.72,57.29) 113.03,57.29 113.13,57.19 113.13,56.89 113.03,56.78 112.34,56.78 112.24,56.68 112.24,56.48 112.37,56.35 113.69,56.35 113.82,56.48 RH186.1 R3667.2 R3665.2
SPI_PCH_DO2_64: length 13.4
  BOTTOM w0.102: R9.2 RH180.1 R3664.2 113.41,66.87 113.28,66.74 113.28,64.02 113.16,63.89 111.09,63.89 110.96,64.02 110.96,64.43 111.09,64.55 112.41,64.55 112.61,64.76 v4(112.61,65.95) 112.61,66.74 112.48,66.87 U52.3
SPI_PCH_DO3: length 41.1
  TOP w0.102: v2(100.13,67.5) 99.39,68.24 99.39,71.29 99.58,71.48 99.58,71.65 99.19,72.05 98.58,72.05 97.81,71.29 97.81,65.67 98.5,64.99 98.5,59.45 98.86,59.09 100,59.09 100.2,59.3 v1(100.2,59.59) 100.2,60.19 v2(100.13,60.26)
  IN3 w0.127: v2(100.13,60.26) 100.2,60.26 100.58,59.88 100.76,59.88 101.75,60.87 101.93,60.87 102.2,60.6 102.2,60.42 101.21,59.44 101.21,59.26 101.48,58.99 101.66,58.99 102.71,60.04 102.89,60.04 103.16,59.77 103.16,59.59 102.11,58.54 102.11,58.36 103.17,57.29 v2(103.17,56.88)
  BOTTOM w0.102: JSPI1.13 105.53,51.94 RH184.1 v2(103.17,56.88) ; R3669.2 v2(100.13,67.5) ; R3670.2 v2(100.13,60.26)
SPI_PCH_DO3_32: length 13.1
  BOTTOM w0.102: R3670.1 R3666.2 102.49,61.15 103,61.66 105.66,61.66 105.79,61.79 105.79,63.74 105.92,63.87 106.3,63.87 v1(106.42,63.74) 106.42,61.58 105.87,61.02 U53.7
SPI_PCH_DO3_64: length 13.1
  BOTTOM w0.102: U52.7 105.51,68.14 105.99,68.62 105.99,71.34 105.87,71.46 v4(105.62,71.46) 105.41,71.46 105.28,71.34 105.28,69.2 104.9,68.82 103.1,68.82 102.67,68.39 R3668.2 R3669.1
SPI_WP#_SEL: length 172.1
  IN3 w0.127: v2(127.07,85) 127.07,84.77 125.68,83.38 118.31,83.38 113.64,78.7 113.64,73.83 v2(115.42,72.05)
  IN4 w0.109: v2(127.07,85) 127.54,84.54 174.3,84.54 182.83,76.01 192.89,76.01 200.39,68.51 203.56,68.51 205.63,66.44 207.71,66.44 211.13,63.02 219.92,63.02 220.1,63.2 225.41,63.2 225.67,62.94 228.1,62.94 229.2,64.04 231.26,64.04 232.23,65.01 242.29,65.01 244.75,67.48 v2(244.91,67.48)
  BOTTOM w0.102: RH186.2 115.29,58.74 115.82,59.27 115.82,60.42 116.13,60.72 116.13,65.02 115.86,65.29 115.42,65.29 RH180.2 115.42,65.98 116.89,67.45 116.89,70.7 117.3,71.11 117.3,71.74 116.99,72.05 v1(116.17,72.05) v2(115.42,72.05) ; U46.A12 244.73,67.66 v2(244.91,67.48)
SPKR: length 85.8
  TOP w0.076: v2(71.37,71.49) 70.9,71.96 69.65,71.96 69.53,72.09 68.81,72.09 68.49,72.41 68.49,72.82 68.14,73.17 68,73.17
  TOP w0.102: v2(16.78,93.87) 16.75,93.9 JIO1.31 ; v2(64.13,90.74) 63.22,90.74 59.41,86.93 59.41,84.73 59.92,84.22 59.92,77.13 60.55,76.49 61.75,76.49 62.15,76.9 RH34.2 62.89,76.42 64.36,76.42 65.89,74.89 65.89,74.38 67.1,73.17 68,73.17
  IN4 w0.102: v2(64.13,90.74) 61.64,93.23 55.02,93.23 54.05,94.2 43.67,94.2 43.14,93.67 39.57,93.67 37.99,92.08 32.14,92.08 31.58,91.53 26.85,91.53 26.37,91.05 24.33,91.05 22.05,93.33 18.26,93.33 18.17,93.41 17.24,93.41 v2(16.78,93.87)
  BOTTOM w0.102: v2(71.37,71.49) 71.54,71.32 UH1.AL10
SRTCRST#: length 7.1
  TOP w0.102: RH42.2 67.76,55.05 CH6.2 68.76,54.82 ME1.2 69.61,55.33 69.92,55.64 69.92,56.27 70.74,57.09 v2(70.92,57.09)
  BOTTOM w0.076: UH1.B9 71.53,58.83 71.53,57.7 v2(70.92,57.09)
STSTART_DCBLOCK_GC: length 183.9
  TOP w0.254: PR1002.1 132.03,107.88 v1(131.46,107.3) 131.34,107.19 v2(131.34,106.01) ; v2(257.53,32.18) 257.22,32.48 257.22,36.44 256.64,37.02 256.64,37.78 256.87,38.01 256.87,40.85 254.38,43.34 254.38,45.05 254.48,45.16 254.48,46.75 254.81,47.08 254.81,50.53 253.9,51.45 253.9,55.77 251.36,58.31 251.36,65.85 250.34,66.87 250.34,70.17 247.29,73.22 247.29,73.89 245.31,75.87 245.31,78.11 242.74,80.68 242,80.68 239.67,83.02 227.4,83.02 224.64,85.79 218.76,85.79 217.96,84.99 210.29,84.99 209.07,86.22 v2(207.14,86.22)
  BOTTOM w0.254: v2(207.14,86.22) 198.29,86.22 194.45,90.06 191.53,90.06 187.92,93.66 180.96,93.66 178.75,95.87 155.73,95.87 153.67,97.93 150.06,97.93 149.17,97.04 141.45,97.04 132.49,106.01 v2(131.34,106.01) ; PU1001.16 v2(257.53,32.18)
SUS_ON: length 223.2
  TOP w0.102: R806.1 97.13,37.91 96.75,38.29 v2(96.75,38.44) ; v2(239.89,77.03) 239.89,76.9 238.17,75.18 238.17,73.36 v2(238.2,73.33)
  IN3 w0.127: v2(96.75,38.44) 96.75,38.27 99.16,35.85 110.87,35.85 111.53,36.51 116.58,36.51 118.15,34.95 122.5,34.95 123.35,35.8 142.67,35.8 145.77,32.7 154.93,32.7 156.58,31.05 v2(157.71,31.05) 158.15,30.61 174.62,30.61 175.49,31.48 177.21,31.48 179.38,33.66 190.31,33.66 191.84,35.19 194.49,35.19 196.8,37.5 208.5,37.5 218.17,47.18 226.13,47.18 233.18,54.23 243.24,54.23 248.49,59.47 248.49,59.86 248.79,60.16 249.23,60.16 249.68,60.6 249.68,61.81 250.32,62.45 250.32,75.16 248.03,77.45 247.78,77.45 245.07,80.15 v2(244.02,80.15)
  BOTTOM w0.102: v2(238.2,73.33) 238.17,73.33 238.23,73.38 238.23,74 ; v2(244.02,80.15) 243.8,79.93 v4(243.39,79.93) 243.08,80.25 240.02,80.25 239.57,79.8 239.57,78.27 239.89,77.95 RP4.4 v2(239.89,77.03) ; v2(157.71,31.05) 157.71,30.28 155.19,27.76 155.19,25.07 155.01,24.9 155.01,24.17 156.17,23.01 156.17,20.55 155.93,20.31 155.93,18.28 PR240.2
SUS_ON_R: length 5.3
  TOP w0.102: RD42.2 99.11,36.82 v1(100.24,35.69)
  TOP w0.203: U40.5 100.29,38.84 100.1,38.65 99.49,38.65 99.34,38.8 R1621.2 R806.2 RD42.2
SUS_STAT#/LPCPD#: length 226.4
  TOP w0.076: v2(69.94,65.02) 69.74,65.22 68.22,65.22
  TOP w0.102: 68.22,65.22 68.1,65.09 68.1,64.61 67.64,64.15 63.3,64.15 62.9,63.74 60.58,63.74 RH73.2
  IN1 w0.109: v2(247.02,54.1) 246.69,54.42 242.53,54.42 241.94,53.83 241.11,53.83 240.59,53.3 240.59,52.82 240.38,52.61 236.86,52.61 236.47,53 233.96,53 233.07,53.89 228.65,53.89 227.28,52.52 217.65,52.52 214.43,49.3 200.12,49.3 192.66,41.83 185.8,41.83 185.75,41.89 185.74,41.89 185.56,42.06 173.95,42.06 173.23,41.34 171.61,41.34 171.6,41.33 122.63,41.33 120.56,43.41 114.98,43.41 111.78,46.61 107.2,46.61 106.85,46.96 98.54,46.96 98.12,47.38 92.84,47.38 91.21,45.75 85.31,45.75 83,48.05 78.67,48.05 77.13,49.59 76.36,49.59 75.53,50.42 75.53,51.2 74.48,52.25 74.48,53.43 73.77,54.14 73.77,54.65 72.74,55.68 72.74,58.46 73.99,59.71 73.99,60.31 73.89,60.41 73.89,63.51 73.71,63.68 73.47,63.68 73.03,64.12 73.02,64.12 72.67,64.48 70.48,64.48 69.94,65.02 v2(69.94,65.02)
  BOTTOM w0.102: v2(247.02,54.1) 247.22,54.3 247.22,55.86 246.51,56.58 246.51,57.18 245.44,58.24 245.44,62.32 v1(245.97,62.85) 246.68,63.56 R2194.1 ; UH1.U7 70.34,65.43 69.94,65.02 v2(69.94,65.02)
SUSACK#: length 271.8
  TOP w0.102: v2(55.65,53.35) 55.5,53.35 55.07,53.79 v1(55.07,55.6) 55.07,55.89 57.56,58.38 60.17,58.38 61.03,59.25 RH101.1 ; v2(240.36,80.86) 240.41,80.81 240.71,80.81 242.09,79.44 243.01,79.44 244.63,77.82 244.63,75.55 246.53,73.65 246.53,71.46 249.71,68.29 249.71,66.6 250.72,65.59 250.72,58.02 251.87,56.88 251.87,55.38 253.26,53.98 253.26,49.98 252.8,49.52 252.8,48.7 253.61,47.89 253.61,44.05 253.06,43.5 252.07,43.5 v2(250.67,42.1)
  IN4 w0.109: v2(55.65,53.35) 56.46,52.54 57.61,52.54 62.09,48.05 63.97,48.05 65.3,46.72 71.94,46.72 72.54,46.11 74.68,46.11 75.06,46.5 79.11,46.5 80.01,45.6 82.72,45.6 83.88,44.43 103.81,44.43 105.69,42.55 120.39,42.55 122.01,40.94 171.1,40.94 172.22,42.06 177.14,42.06 177.49,42.41 188.02,42.41 188.84,43.22 196.44,43.22 199.76,46.54 208.38,46.54 209.67,45.25 220.92,45.25 221,45.33 227.55,45.33 228.38,46.16 232.17,46.16 232.85,45.48 232.85,44.45 233.44,43.86 234.14,43.86 235.85,42.15 237.88,42.15 238.74,41.29 245.74,41.29 246.28,41.82 247.06,41.82 248.11,42.86 249.91,42.86 v2(250.67,42.1)
  BOTTOM w0.102: v2(240.36,80.86) 240.05,80.86 239.17,79.97 239.17,77.1 238.98,76.91 U46.A58
SUSACK#_R: length 10.6
  TOP w0.102: RH101.2 RH91.2 62.63,60.49 63.6,60.49 64.77,61.66 65.42,61.66 65.9,62.14 67.56,62.14 67.82,62.4 67.82,62.83 v1(68.1,63.11) 68.83,63.84 69.31,63.84 v2(69.51,64.04)
  BOTTOM w0.102: v2(69.51,64.04) 69.75,64.28 UH1.R6
SUSCLK: length 1.2
  TOP w0.102: T68.1 69.75,65.77 v2(69.93,65.96)
  BOTTOM w0.102: v2(69.93,65.96) 69.93,66.29 UH1.Y6
SW1: length 9.9
  BOTTOM w0.381: PL102.1 31.98,30.59 31.98,33.07 32.69,33.78 PC111.2 33.92,34.23 34.68,34.99 35.27,34.99 35.9,35.62
  vias: v1(30.4,26.45) v2(30.71,27.69) v2(30.71,27.05) v2(30.96,26.52) v2(30.97,25.92) v2(31.34,27.69) v2(31.34,27.05) v2(31.93,27.69) v2(31.93,27.05) v2(32.51,27.69) v2(32.51,27.05) v2(33.09,27.69) v2(33.09,27.05)
SW2: length 3.4
  IN1 w1.016: 35.41,41.97 35.41,43.24 34.64,44.01 33.63,44.01
  vias: v1(30.97,43.88) v3(31.14,44.82) v3(31.88,44.16) v3(32.31,44.92) v3(32.51,44.16) v3(32.59,45.71) v3(33.02,45.17) v3(33.5,47.44) v3(33.5,46.67) v3(33.55,45.89) v3(33.73,45.2) v3(35.33,40.7) v3(35.99,40.7)
SW_1.35V:
  vias: v1(130.31,26.12) v3(129.77,20.89) v3(129.77,20.26) v3(129.77,19.62) v3(129.77,18.99) v3(129.77,18.35) v3(130.38,21.63) v3(130.4,20.26) v3(130.4,19.62) v3(130.4,18.99) v3(130.4,18.35) v3(130.4,17.72) v3(130.53,20.89) v3(131.01,21.63) v3(131.04,20.26) v3(131.04,19.62) v3(131.04,18.99) v3(131.04,18.35) v3(131.04,17.72) v3(131.04,17.08) v3(131.16,20.89) v3(147.29,20.38) v3(147.93,20.38)
SW_+1.05VSP: length 0.8
  TOP w0.254: PC306.1 v2(39.17,62.39)
  vias: v1(42.89,59.09) v3(39.47,59.88) v3(39.47,59.25) v3(39.47,58.61) v3(39.47,57.98) v3(40.11,59.88) v3(40.11,59.25) v3(40.11,58.61) v3(40.11,57.98)
SW_LAN_TX0+: length 100.2
  TOP w0.089: v2(114.15,105.5) 114.02,105.38 114.02,105.14 114.1,105.07 U32.24
  IN3 w0.114: v2(56.87,142.74) 56.74,142.61 56.74,142.25 56.23,141.75 55.67,141.75 52.75,138.83 52.75,136.64 52.09,135.98 52.09,135.36 52.93,134.52 99.62,134.52 105.08,129.06 105.08,118.71 106.95,116.84 106.95,111 109.53,108.41 110.07,108.41 111.12,107.35 112.12,107.35 113.28,106.19 113.71,106.19 114.04,105.85 114.04,105.6 v2(114.15,105.5)
  BOTTOM w0.089: T156.1 57.89,146.77 57.45,146.33 57.45,144.34 56.78,143.66 56.78,142.82 v2(56.87,142.74)
SW_LAN_TX0-: length 100.3
  TOP w0.089: v2(113.56,105.5) 113.68,105.38 113.68,105.16 113.6,105.08 U32.25
  IN3 w0.114: v2(56.26,142.74) 56.37,142.62 56.37,142.41 56.08,142.11 55.52,142.11 52.39,138.98 52.39,136.79 51.73,136.13 51.73,135.2 52.78,134.15 99.47,134.15 104.71,128.91 104.71,118.56 106.58,116.69 106.58,110.84 109.38,108.04 109.91,108.04 110.97,106.98 111.97,106.98 113.13,105.82 113.56,105.82 113.68,105.7 113.68,105.61 v2(113.56,105.5)
  BOTTOM w0.089: T156.2 56.62,146.77 57.11,146.27 57.11,144.48 56.44,143.81 56.44,142.91 v2(56.26,142.74)
SW_LAN_TX1+: length 97.9
  TOP w0.089: v2(112.14,105.52) 112.02,105.4 112.02,105.15 112.1,105.07 U32.28
  IN3 w0.114: v2(112.14,105.52) 112.06,105.6 112.06,105.88 111.68,106.27 110.67,106.27 109.62,107.32 109.1,107.32 104.46,111.96 104.46,117.79 103.77,118.47 103.77,119.95 102.53,121.2 102.53,126.28 101.46,127.34 101.46,128.79 96.81,133.44 51.59,133.44 49.73,135.29 49.73,136.94 50.35,137.56 50.35,140.2 52.34,142.18 52.34,143.1 v2(52.5,143.27)
  BOTTOM w0.089: T156.5 52.81,146.77 52.34,146.3 52.34,143.43 v2(52.5,143.27)
SW_LAN_TX1-: length 97.8
  TOP w0.089: v2(111.56,105.52) 111.67,105.41 111.67,105.14 111.6,105.07 U32.29
  IN3 w0.114: v2(111.56,105.52) 111.69,105.66 111.69,105.73 111.52,105.9 110.52,105.9 109.47,106.95 108.95,106.95 104.09,111.81 104.09,117.64 103.4,118.32 103.4,119.8 102.16,121.04 102.16,126.12 101.09,127.19 101.09,128.64 96.66,133.07 51.44,133.07 49.36,135.14 49.36,137.09 49.99,137.71 49.99,140.35 51.97,142.33 51.97,143.14 v2(51.84,143.27)
  BOTTOM w0.089: v2(51.84,143.27) 51.99,143.42 51.99,146.31 51.54,146.77 T156.6
SW_LAN_TX2+: length 96.2
  TOP w0.089: v2(109.65,105.5) 109.53,105.38 109.53,105.14 109.6,105.07 U32.33
  IN3 w0.114: v2(109.65,105.5) 109.56,105.59 109.56,105.86 109.17,106.24 108.65,106.24 103.1,111.79 103.1,117.62 102.69,118.03 102.69,119.43 101.07,121.06 101.07,123.41 101.12,123.46 101.12,125.93 99.22,127.83 99.22,129.07 95.94,132.35 51.1,132.35 48.21,135.24 48.21,139.84 49.81,141.44 49.81,143.14 v2(49.93,143.27)
  BOTTOM w0.089: v2(49.93,143.27) 49.8,143.4 49.8,146.3 50.27,146.77 T156.7
SW_LAN_TX2-: length 96.2
  TOP w0.089: U32.34 109.1,105.07 109.18,105.15 109.18,105.38 v2(109.07,105.5)
  IN3 w0.114: v2(49.33,143.27) 49.44,143.15 49.44,141.59 47.84,139.99 47.84,135.09 50.95,131.98 95.79,131.98 98.86,128.92 98.86,127.67 100.75,125.78 100.75,123.61 100.7,123.56 100.7,120.9 102.32,119.28 102.32,117.87 102.73,117.47 102.73,111.64 108.5,105.87 109.02,105.87 109.19,105.7 109.19,105.62 v2(109.07,105.5)
  BOTTOM w0.089: v2(49.33,143.27) 49.46,143.4 49.46,146.3 49,146.77 T156.8
SW_LAN_TX3+: length 95.7
  TOP w0.089: U32.37 107.6,105.05 107.52,105.12 107.52,105.38 v2(107.64,105.5)
  IN3 w0.114: v2(107.64,105.5) 107.53,105.61 107.53,105.83 101.98,111.38 101.98,114.02 101.12,114.88 101.12,118.68 99.07,120.73 99.07,126.1 97.4,127.78 97.4,128.99 95.12,131.27 50.56,131.27 46.48,135.34 46.48,141.3 45.19,142.6 45.19,143.29 v2(45.34,143.45)
  BOTTOM w0.089: v2(45.34,143.45) 45.17,143.61 45.17,144.28 44.72,144.73 44.72,146.3 45.19,146.77 T156.11
SW_LAN_TX3-: length 95.7
  TOP w0.089: U32.38 107.1,105.05 107.18,105.12 107.18,105.38 v2(107.06,105.5)
  IN3 w0.114: v2(107.06,105.5) 107.16,105.6 107.16,105.68 101.61,111.23 101.61,113.87 100.75,114.73 100.75,118.53 98.7,120.57 98.7,125.95 97.03,127.62 97.03,128.84 94.97,130.9 50.4,130.9 46.11,135.19 46.11,141.15 44.82,142.44 44.82,143.28 v2(44.65,143.45)
  BOTTOM w0.089: v2(44.65,143.45) 44.83,143.62 44.83,144.13 44.38,144.58 44.38,146.3 43.92,146.77 T156.12
SW_LVDS_A0+: length 5.8
  TOP w0.102: v2(89.22,154.58) 89.22,154.37 89.11,154.27 88.93,154.27 88.51,154.69 88.51,155.24 88.57,155.31 88.69,155.31 88.74,155.35 JLVDS1.21
  BOTTOM w0.102: U11.9 89.28,152.57 88.5,153.34 88.5,154.03 88.84,154.37 89.1,154.37 89.1,154.37 89.22,154.48 v2(89.22,154.58)
SW_LVDS_A0-: length 5.9
  TOP w0.102: JLVDS1.22 88.24,154.58 88.82,154 89.09,154 v2(89.22,153.87)
  BOTTOM w0.102: v2(89.22,153.87) 89.22,153.95 89.08,154.09 88.94,154.09 88.77,153.92 88.77,153.45 89.3,152.92 89.76,152.92 U11.10
SW_LVDS_A1+: length 11.3
  TOP w0.102: JLVDS1.23 87.74,157.13 87.63,157.24 87.47,157.24 87.17,157.54 87.17,158.05 87.35,158.23 87.5,158.23 87.58,158.15 v2(87.58,157.86)
  BOTTOM w0.102: U11.7 88.68,151.43 88.55,151.56 88.31,151.56 87.76,152.11 87.76,155.19 88,155.44 v3(88,155.73) 88,158.06 87.95,158.1 87.82,158.1 v2(87.58,157.86)
SW_LVDS_A1-: length 11.4
  TOP w0.102: v2(87.59,158.65) 87.43,158.5 87.24,158.5 86.9,158.16 86.9,157.43 87.24,157.09 JLVDS1.24
  BOTTOM w0.102: U11.8 88.72,151.93 88.62,151.83 88.42,151.83 88.02,152.22 88.02,155.08 88.26,155.33 88.26,158.17 88.06,158.37 87.7,158.37 87.59,158.49 v2(87.59,158.65)
SW_LVDS_A2+: length 10.3
  TOP w0.102: JLVDS1.25 86.74,154.29 86.49,154.04 86.2,154.04 v2(86.07,153.91)
  BOTTOM w0.102: v2(86.07,153.91) 86.26,154.1 86.6,154.1 87.01,153.7 87.01,150.22 88.18,149.05 88.57,149.05 88.68,148.93 U11.2
SW_LVDS_A2-: length 10.2
  TOP w0.102: v2(86.07,154.59) 86.07,154.38 86.14,154.31 86.37,154.31 86.47,154.4 86.47,155.42 86.41,155.48 86.29,155.48 86.24,155.53 JLVDS1.26
  BOTTOM w0.102: v2(86.07,154.59) 86.29,154.37 86.71,154.37 87.27,153.81 v3(87.27,152.45) 87.27,150.33 88.29,149.32 88.57,149.32 88.68,149.43 U11.3
SW_LVDS_ACLK+: length 17.8
  TOP w0.102: v2(85.42,157.79) 85.42,158.05 85.32,158.15 85.08,158.15 85.01,158.08 85.01,157.13 85.06,157.08 85.16,157.08 85.24,157 JLVDS1.28
  BOTTOM w0.102: v2(85.42,157.79) 85.42,158.04 85.5,158.12 85.71,158.12 85.84,157.99 85.84,157.57 85.44,157.18 85.44,155.72 85.24,155.51 C1183.1 85.22,155.23 85.22,153.68 86.26,152.64 86.26,149.72 v3(86.86,149.12) 88.42,147.56 89.73,147.56 89.86,147.69 90.02,147.69 U11.36
SW_LVDS_ACLK-: length 17.8
  TOP w0.102: v2(85.42,158.55) 85.29,158.42 84.97,158.42 84.74,158.19 JLVDS1.29
  BOTTOM w0.102: U11.1 89.43,148.43 89.71,148.15 89.71,147.92 89.62,147.83 88.53,147.83 86.52,149.84 86.52,152.75 85.48,153.79 85.48,154.79 C1184.1 85.71,156.01 85.71,157.07 86.1,157.46 86.1,158.1 85.83,158.38 85.58,158.38 v2(85.42,158.55)
SW_LVDS_B0+: length 7.7
  TOP w0.102: v2(83.31,153.86) 83.51,154.06 83.67,154.06 83.98,154.37 83.98,155.02 83.74,155.26 JLVDS1.31
  BOTTOM w0.102: v2(83.31,153.86) 83.31,154.17 83.43,154.28 83.74,154.28 84.44,153.58 84.44,153.26 85.16,152.55 85.16,151.89 84.95,151.68 84.67,151.68 84.52,151.82 U13.9
SW_LVDS_B0-: length 7.6
  TOP w0.102: JLVDS1.32 83.24,155.51 83.29,155.46 83.42,155.46 83.47,155.41 83.47,155.15 83.72,154.91 83.72,154.48 83.56,154.33 83.39,154.33 83.31,154.41 v2(83.31,154.67)
  BOTTOM w0.102: U13.10 85.24,151.34 85.24,151.59 85.43,151.78 85.43,152.66 84.71,153.37 84.71,153.69 83.85,154.55 83.43,154.55 v2(83.31,154.67)
SW_LVDS_B1+: length 7
  TOP w0.102: v2(81.95,154.17) 82.49,154.17 82.74,154.42 JLVDS1.33
  BOTTOM w0.102: v2(81.95,154.17) 81.95,154.26 82.05,154.36 82.19,154.36 82.32,154.49 82.43,154.49 82.55,154.37 82.55,153.4 82.84,153.11 83.56,153.11 83.75,152.91 83.75,152.79 83.68,152.72 83.59,152.72 83.52,152.65 U13.7
SW_LVDS_B1-: length 6.9
  TOP w0.102: v2(81.95,154.76) 82.27,154.44 82.38,154.44 82.47,154.53 82.47,155.4 82.43,155.44 82.28,155.44 82.24,155.48 JLVDS1.34
  BOTTOM w0.102: U13.8 84.02,152.77 84.02,152.78 84.02,153.02 83.67,153.38 82.95,153.38 82.82,153.51 82.82,154.48 82.54,154.76 v2(81.95,154.76)
SW_LVDS_B2+: length 6.4
  TOP w0.102: v2(80.46,154.06) 81.12,154.06 81.44,154.38 81.44,154.98 81.74,155.28 JLVDS1.35
  BOTTOM w0.102: U13.2 81.02,152.72 81.07,152.76 81.21,152.76 81.26,152.81 81.26,153.29 81.11,153.43 81.11,154.23 80.97,154.38 80.78,154.38 80.67,154.26 80.61,154.26 80.46,154.12 v2(80.46,154.06)
SW_LVDS_B2-: length 6.4
  TOP w0.102: JLVDS1.36 81.24,155.64 81.29,155.59 81.43,155.59 81.47,155.55 81.47,155.39 81.18,155.09 81.18,154.49 81.01,154.32 80.78,154.32 80.66,154.45 80.59,154.45 80.46,154.57 v2(80.46,154.64)
  BOTTOM w0.102: U13.3 81.52,153.4 81.38,153.54 81.38,154.34 81.08,154.64 v2(80.46,154.64)
SW_LVDS_BCLK+: length 12.1
  TOP w0.102: JLVDS1.38 80.24,158.21 79.78,158.67 79.55,158.67 v2(79.41,158.81)
  BOTTOM w0.102: U13.36 79.91,151.45 79.91,151.59 79.81,151.69 79.81,152.78 78.62,153.96 78.62,154.97 C1186.1 78.68,155.85 78.68,158.29 79.08,158.7 79.3,158.7 v2(79.41,158.81)
SW_LVDS_BCLK-: length 12
  TOP w0.102: JLVDS1.39 79.74,156.9 79.97,157.13 79.97,158.1 79.67,158.41 79.51,158.41 79.41,158.31 v2(79.41,158.04)
  BOTTOM w0.102: U13.1 80.52,151.78 80.41,151.68 80.2,151.68 80.07,151.8 80.07,152.89 v3(79.24,153.73) 78.89,154.07 78.89,154.8 C1185.1 79.35,155.39 78.94,155.79 78.94,158.18 79.19,158.43 79.26,158.43 79.41,158.28 v2(79.41,158.04)
SYS_LED_MASK#: length 357.7
  TOP w0.102: v2(33.7,82.69) 34.32,83.31 Q321.2 ; 101.4,99.25 Q325.2 101.87,99.48 103.31,99.48 Q325.5 104.16,99.88 104.16,101.03 103.92,101.27 Q327.2 ; 101.4,99.25 101.09,98.95 101.09,97.78 v2(102.87,96) ; 101.4,99.25 100.1,99.25 v1(98.49,97.64) 97.71,96.86 64.62,96.86 54.61,86.86 v2(54.61,86.32) ; v2(24.38,74.74) 24.36,74.71 23.05,74.71 22.6,75.17 21.66,75.17 21.21,74.71 21.21,73.95 20.76,73.5 JIO1.100 ; v2(286.66,90.78) 286.6,90.72 Q84.5 ; v2(29.36,87.77) 29.36,88.02 29.81,88.47 U58.1 ; v2(234.3,72.12) 234.19,72.23 230.76,72.23 228.5,69.96 226.52,69.96 v2(226.36,69.81)
  IN1 w0.109: v2(102.87,96) 102.59,95.72 102.59,93.09 104.44,91.23 104.44,87.37 105.2,86.61 105.2,84.62 119.52,70.3 122.27,70.3 123.04,69.53 123.04,66.89 125.73,64.2 141.77,64.2 141.89,64.07 145.9,64.07 146.77,63.2 149.63,63.2 151.57,61.25 154.18,61.25 154.58,60.85 172.94,60.85 174.37,62.28 186.49,62.28 187.96,63.74 196.82,63.74 199.11,66.03 210.94,66.03 211.69,66.78 215.22,66.78 218.5,70.06 226.12,70.06 v2(226.36,69.81) 226.54,69.63 230.66,69.63 231.16,69.13 232.66,69.13 233.14,69.6 235.19,69.6 236.08,70.49 242.56,70.49 243.7,71.63 244.71,71.63 245.19,71.16 246.2,71.16 246.6,70.76 249.81,70.76 250.2,70.37 252.73,70.37 253.03,70.68 265.14,70.68 265.69,71.23 276.8,71.23 277.21,71.64 277.21,81.06 280.31,84.16 280.31,85.1 285.99,90.78 v2(286.66,90.78)
  IN4 w0.109: v2(29.36,87.77) 29.79,87.34 33.6,87.34 33.83,87.11 36.32,87.11 36.65,87.44 37.74,87.44 38.15,87.03 38.15,85.99 38.86,85.28 43.13,85.28 43.66,85.81 49.27,85.81 49.78,86.32 v2(54.61,86.32)
  BOTTOM w0.102: R775.2 227.84,72.45 226.41,71.03 226.41,69.86 v2(226.36,69.81) ; v2(234.3,72.12) 234.3,72.12 234.1,72.12 233.88,71.91 U46.B48 ; v2(29.36,87.77) 29.36,87.84 29.91,87.29 30.48,87.29 33.7,84.06 v2(33.7,82.69) 32.66,81.65 31.29,81.65 v2(24.38,74.74)
SYS_PWROK: length 305.4
  TOP w0.102: v2(237.18,72.75) 237.59,73.16 237.59,73.97 237.34,74.22 237.34,75.86 237.54,76.06 237.54,76.49 237.67,76.62 237.67,78.42 237.46,78.63 237.46,79.59 236.04,81.01 229.61,81.01 229.41,81.22 226.29,81.22 224.51,83 223.44,83 v2(222.32,84.11) ; RH102.1 RH85.2 57.05,68.03 56.87,68.03 55.85,69.05 54.99,69.05 54.32,69.72 v1(54.32,70.59) 54.32,72.08 53.59,72.8 53.59,74.71 52.53,75.78 v2(52.45,75.78)
  IN1 w0.109: v2(209.7,121.32) 210.9,120.13 210.9,105.64 215.41,101.13 215.41,96.75 220.24,91.91 220.24,86.35 220.34,86.25 220.34,86.09 v2(222.32,84.11)
  IN3 w0.127: v2(222.32,84.11) 221.21,83 220.78,83 217.12,79.34 217.12,68.59 212.22,63.69 212.22,61.82 205.4,55 200.93,55 193.89,47.97 192.48,47.97 190.23,45.72 184.69,45.72 184.03,45.06 177.18,45.06 176.68,44.56 169.98,44.56 167.26,41.85 166.27,41.85 165.43,41.01 147.86,41.01 145.82,43.04 124.23,43.04 122.68,44.59 112.4,44.59 110.9,46.09 101.7,46.09 100.46,47.33 98.83,47.33 98.13,48.03 94.3,48.03 94.11,47.84 92.23,47.84 90.82,49.25 80.06,49.25 79.78,48.97 76.92,48.97 75.93,49.96 69.32,49.96 66.43,52.85 66.43,54.13 65.93,54.64 62.17,54.64 61.03,55.78 57.32,55.78 56.42,56.68 53.72,56.68 50.27,60.14 50.27,74.59 51.21,75.53 52.2,75.53 v2(52.45,75.78)
  BOTTOM w0.102: RC9.1 v2(209.7,121.32) ; v2(237.18,72.75) 236.73,73.21 U46.B57
SYS_PWROK_R: length 11.4
  TOP w0.102: RH102.2 60.3,67.07 62.76,67.07 63.85,68.16 v4(66.71,68.16) 67.35,68.16 67.64,68.44 69.88,68.44 v2(69.98,68.54)
  BOTTOM w0.102: UH1.AD7 70.34,68.09 69.98,68.45 v2(69.98,68.54)
SYS_PWROK_XDP: length 4.4
  TOP w0.102: v2(212.09,121.43) 212.57,121.91 RC124.2 212.67,121.94 JXDP1.14
  BOTTOM w0.102: v2(212.09,121.43) v1(211.63,121.89) 211.15,122.37 RC9.2
SYS_RESET#: length 101.1
  IN3 w0.127: v2(15.23,125.56) 16.9,123.89 16.9,120.67 19.72,117.85 19.72,115.12 21.39,113.45 23.25,113.45 38.53,98.17 38.53,90.77 41.12,88.18 41.6,88.18 42.96,86.82 42.96,84.05 49.46,77.56 52.58,77.56 54.36,79.34 v2(60.55,79.34) 60.98,79.34 63.75,76.57 65.85,76.57 67.02,75.41 67.02,74.75 67.41,74.36 67.41,73.58 66.62,72.78 66.36,72.78 65.96,72.39 v2(65.96,72.28)
  BOTTOM w0.076: v2(65.96,72.28) 66.72,71.51 67.54,71.51 67.64,71.41 UH1.AM1
  BOTTOM w0.102: v2(15.23,125.56) 15.23,126.07 14.86,126.44 JAPS1.13 ; UC3.4 63.43,83.62 RH66.2 63.42,83.88 63.09,84.21 61.21,84.21 v1(61,84) 59.94,82.94 59.94,79.95 v2(60.55,79.34)
SYSPWR_PRES: length 6.1
  TOP w0.102: v2(241.8,39.99) 241.8,37.07 241.71,36.97 v2(241.71,36.51)
  BOTTOM w0.102: v2(241.71,36.51) 242.16,36.06 R876.1 R874.1 ; U51.A59 v2(241.8,39.99)
SYSTEM_ID: length 3.8
  BOTTOM w0.102: U51.A10 237.42,46.92 236.98,47.36 236.63,47.36 236.4,47.12 236.4,46.76 v1(236.29,46.65) 236.18,46.55 C742.1 R871.2
TEMP_ALERT#: length 230.4
  TOP w0.076: 71.17,58.99 71.17,59.96 70.86,60.26 70.86,60.87 70.56,61.18 70.14,61.18 v2(70.07,61.11)
  TOP w0.102: v2(247.57,69) 247.78,69 248.06,68.72 248.16,68.72 249.5,67.37 249.5,66.49 250.52,65.47 250.52,57.94 250.93,57.53 250.93,56.02 252.83,54.12 v2(252.83,53.56) ; 71.17,58.99 v1(71.37,58.79) 71.58,58.59 71.58,55.16 RH171.2
  IN1 w0.109: v2(70.07,61.11) 70.73,61.11 70.97,60.87 70.97,60.36 71.77,59.56 71.77,55.54 72.75,54.56 72.75,52.05 75.89,48.91 76.78,48.91 78.37,47.32 82.66,47.32 83.21,46.77 83.21,45.71 83.59,45.33 92.81,45.33 94.44,46.96 97.95,46.96 98.37,46.54 106.68,46.54 107.03,46.19 111.6,46.19 114.68,43.11 114.81,42.99 120.38,42.99 122.46,40.91 171.78,40.91 171.78,40.92 173.4,40.92 174.13,41.64 185.39,41.64 185.56,41.47 185.57,41.47 185.63,41.41 192.85,41.41 200.3,48.86 214.65,48.86 217.82,52.03 228.29,52.03 228.66,52.4 241.08,52.4 241.5,52.82 241.5,53.3 241.71,53.51 241.91,53.51 242.57,54.16 243.82,54.16 244.4,53.58 245.6,53.58 245.89,53.87 246.63,53.87 247.02,53.48 249.91,53.48 250.37,53.02 252.25,53.02 252.78,53.56 v2(252.83,53.56)
  BOTTOM w0.102: UH1.H6 69.75,61.44 v2(70.07,61.11) ; R741.2 247.06,68.49 v2(247.57,69)
TEMP_ALERT#_R: length 8.1
  IN1 w0.109: v2(241.55,67.81) 242.12,68.38 242.75,68.38 243.39,69.02 v2(245.66,69.02)
  BOTTOM w0.102: v2(241.55,67.81) 242.14,68.41 U46.B11 ; v2(245.66,69.02) 246.15,68.54 R741.1 v1(246.15,67.3)
TEST: length 4.2
  BOTTOM w0.102: U26.18 183.87,34.74 184.38,34.23 184.38,33.01 R86.1 R41.2
THERM_STP#: length 87.5
  IN3 w0.127: v2(25.58,100.24) 22.63,97.3 19.28,97.3 16.13,94.15 16.13,91.63 15.29,90.79 15.29,90.16 14.93,89.8 14.93,79.08 20.42,73.6 20.87,73.6 26.11,68.35 26.11,64.73 24.61,63.23 24.61,57.11 24.91,56.81 25.28,56.44 25.28,55.21 27.49,53 27.49,44.1 29.51,42.08 v2(30.45,42.08)
  BOTTOM w0.102: v2(25.58,100.24) v1(26.48,100.24) 33.25,100.24 34.37,99.12 34.37,97.78 33.86,97.27 R390.1
  BOTTOM w0.203: v2(30.45,42.08) 29.82,41.44 PR111.1
  BOTTOM w0.254: R390.1 34.15,96.88 U29.19
THERMATRIP2#: length 6.4
  BOTTOM w0.102: U51.B34 247.71,50.77 248.26,51.31 v1(248.26,53.02) 248.26,53.45 C327.1 R396.2 247.67,55.59 247.99,55.91 Q28.1
THERMATRIP3#: length 14.7
  TOP w0.102: v2(230.91,43.08) 230.91,44.39 v2(231.07,44.55)
  BOTTOM w0.102: v2(230.91,43.08) 230.83,43 C343.1 R397.2 231.38,41.4 231.88,41.9 v1(236.52,41.9) 236.98,42.35 236.98,42.66 237.24,42.92 U51.A2 ; R1181.1 230.54,46.5 231.14,45.9 231.14,45.25 231.07,45.19 v2(231.07,44.55) 230.84,44.55 230.54,44.86 Q115.1
THERMB3: length 2.7
  BOTTOM w0.102: Q115.2 228.01,43.55 R401.2 v1(227.33,44.65)
THSEL_STRAP: length 12.3
  TOP w0.102: v2(244.98,49.51) 245.39,49.92 245.39,50.28 244.03,51.63 244.03,52.54 244.47,52.98 244.47,56.46 243.97,56.96 v2(243.97,57.47)
  BOTTOM w0.102: R1069.1 243.84,57.34 v2(243.97,57.47) 244.17,57.67 v1(244.17,58.27) ; v2(244.98,49.51) 244.55,49.94 U51.B29
TMDS_DDCBUF: length 4.6
  TOP w0.102: R66.2 R68.2 35.18,151.09 34.34,151.09 v1(34.17,151.26) 33.39,152.04 U9.2
TMDS_PRE: length 10.2
  TOP w0.102: U9.20 29.4,159.08 v2(29.46,159.14) ; v1(24.28,162.28) 23.54,161.54 R67.2 R65.2 24.15,160.34 v2(24.18,160.36)
  IN1 w0.109: v2(24.18,160.36) 24.28,160.47 28.14,160.47 v2(29.46,159.14)
TMDS_RT: length 8
  TOP w0.102: U9.23 28.2,159.28 v1(27.89,159.6) 27.48,160.01 v2(27.38,160.01) ; R57.2 R71.2 24.03,158.56 v2(24.59,159.12)
  IN1 w0.109: v2(27.38,160.01) 27.15,159.78 25.27,159.78 24.61,159.12 v2(24.59,159.12)
TMDSE_CON_CLK: length 15.9
  TOP w0.102: R451.2 35.74,164.31 L19.3 35.74,165.04 36.06,165.36 36.06,165.48 C1333.1 35.88,165.8 36.14,166.07 36.14,166.41 35.71,166.84 35.48,166.84 35.25,166.61 v2(35.25,166.41)
  BOTTOM w0.102: v2(35.25,166.41) 35.46,166.61 36.91,166.61 37.09,166.8 37.11,166.8 37.48,167.17 37.48,167.19 38.07,167.78 38.07,169.53 37.01,170.6 33.15,170.6 32.73,170.18 32.73,169.93 JHDMI1.10
TMDSE_CON_CLK#: length 15.9
  TOP w0.102: v2(35.25,167.27) 35.47,167.06 35.8,167.06 36.36,166.5 36.36,166.04 C1334.1 36.28,165.48 36.28,165.36 36.59,165.04 L19.2 36.59,164.31 R452.2
  BOTTOM w0.102: JHDMI1.12 33.25,169.64 32.94,169.95 32.94,170.09 33.24,170.38 33.82,170.38 33.91,170.29 34.26,170.29 34.35,170.38 34.66,170.38 34.75,170.29 35.1,170.29 35.19,170.38 36.92,170.38 37.86,169.44 37.86,167.87 v3(37.13,167.14) 36.82,166.83 35.11,166.83 35,166.94 35,167.15 35.13,167.27 v2(35.25,167.27)
TMDSE_CON_N0: length 5.5
  TOP w0.102: JHDMI1.9 31.56,168.26 31.56,167.56 v3(32.36,166.76) 32.72,166.4 32.72,166.12 C1335.1 32.72,165.48 32.72,165.39 33.04,165.07 L23.2 33.04,164.31 R454.2
TMDSE_CON_N1: length 13.4
  TOP w0.102: R456.2 29.48,164.31 L24.2 29.48,165.1 29.16,165.41 29.16,165.51 29.45,165.8 C1337.1 29.16,166.12 29.16,166.57 29.44,166.84 29.72,166.84 29.79,166.76 29.79,166.54 v2(29.69,166.43)
  BOTTOM w0.102: v2(29.69,166.43) 29.5,166.62 28.48,166.62 27.63,167.47 27.04,168.07 27.04,169.5 28.38,170.84 28.68,170.84 28.69,170.85 v3(28.97,170.85) 29.22,170.85 29.23,170.84 29.55,170.84 30.12,170.27 30.12,169.96 JHDMI1.6
TMDSE_CON_N2: length 7.1
  TOP w0.102: JHDMI1.3 28.56,168.26 28.56,167.72 28.31,167.46 26.58,167.46 v3(25.91,166.8) 25.61,166.49 25.61,166.12 C1339.1 26.18,165.55 L25.2 26.18,164.31 R458.2
TMDSE_CON_P0: length 5.5
  TOP w0.102: R453.2 32.19,164.31 L23.3 32.19,165.04 32.5,165.36 32.5,165.48 C1336.1 32.5,166.12 32.5,166.31 32.41,166.41 32.39,166.41 32.01,166.78 32.01,166.8 31.35,167.47 31.35,168.23 JHDMI1.7
TMDSE_CON_P1: length 13.3
  TOP w0.102: R455.2 28.63,164.31 L24.3 28.63,165.1 28.95,165.41 28.95,165.51 28.66,165.8 C1338.1 28.95,166.12 28.95,166.66 29.14,166.85 29.35,167.06 29.58,167.06 29.69,167.17 v2(29.69,167.27)
  BOTTOM w0.102: JHDMI1.4 29.65,169.64 29.92,169.91 29.92,170.17 29.46,170.63 28.47,170.63 27.25,169.41 27.25,169.13 27.35,169.02 27.35,168.65 27.25,168.55 27.25,168.16 28.01,167.41 28.13,167.41 28.38,167.17 28.38,167.04 28.57,166.84 29.79,166.84 29.95,166.99 29.95,167.17 29.84,167.27 v2(29.69,167.27)
