# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FAN2_PWM_D: length 8
  BOTTOM w0.102: R213.1 13.24,84.9 D90.2 13.24,83.77 R403.2 ; R213.1 13.22,86.19 JFAN2.2 ; R213.1 13.92,86.84 14.98,86.84 15.78,86.04 v1(15.78,85.7)
FAN2_TACH_FB: length 30.2
  IN3 w0.127: v2(27.99,86.7) 27.99,89.42 30.5,91.94 v2(31,91.94)
  BOTTOM w0.102: JFAN2.3 12,84.94 12.47,84.47 12.47,83.5 R405.2 13.23,82.44 13.77,81.9 16.03,81.9 16.48,82.36 20.89,82.36 v1(21.56,81.69) 23.94,81.69 25.08,82.83 25.08,83.8 v2(27.99,86.7) ; U29.10 31.16,91.78 v2(31,91.94)
FB: length 10.9
  TOP w0.203: 153.97,171.62 154.33,171.62 154.55,171.39 PU500.8
  TOP w0.254: PR533.2 149.45,172.99 ; 149.45,172.99 150.21,172.23 151.18,172.23 151.79,171.62 153.97,171.62 ; 149.45,172.99 149.45,172.96 PR536.2 148.43,172.07 v2(147.95,172.55)
  BOTTOM w0.102: v4(148.07,171.7) 147.95,171.82 v2(147.95,172.55)
  BOTTOM w0.254: PR543.2 148.49,173.09 v2(147.95,172.55)
FB_+1.05VSP: length 3.7
  BOTTOM w0.102: v1(41.2,68.49) 40.89,68.19 PR307.2 PR306.2 39.22,67.7 39.6,67.33 PU300.4
FC_G6: length 13.9
  TOP w0.089: v2(168.06,110.31) JCPU1.G6
  BOTTOM w0.089: 164.44,101.28 164.44,101.69 v1(165,102.25) 165.47,102.72 165.47,108.59 165.78,108.9 167.31,108.9 167.56,109.16 167.56,109.81 v2(168.06,110.31)
  BOTTOM w0.102: 164.44,101.28 RC73.2 163.58,100.33 RC72.1
FDI_CSYNC: length 126.9
  TOP w0.102: v2(168.06,133.31) 168.53,132.84 JCPU1.H29
  IN3 w0.127: v2(83.67,71.49) 83.67,71.5 84.19,72.02 85.06,72.02 85.34,72.3 85.34,72.38 87.12,74.15 87.12,74.41 89.99,77.29 89.99,78.63 91.14,79.77 92.79,79.77 93.93,80.91 96.34,80.91 97.86,82.44 103.11,82.44 103.9,83.22 111.94,83.22 113,84.29 113,85.99 114.91,87.9 116.18,87.9 117.32,89.04 121.33,89.04 128.6,96.3 128.6,104.49 136.01,111.9 150.72,111.9 156.16,117.34 v2(156.16,117.39)
  BOTTOM w0.089: v2(83.67,71.49) 83.67,71.48 83.91,71.24 UH1.AL39
  BOTTOM w0.102: v2(156.16,117.39) 155.5,118.05 155.5,121.76 156.11,122.37 157.18,122.37 159.07,124.25 159.07,125.78 v1(160.15,126.86) 161.11,127.83 161.39,127.83 161.49,127.93 163.45,127.93 163.9,128.38 164.49,128.38 164.79,128.69 165.63,128.69 165.84,128.89 167.32,128.89 167.5,129.08 168.45,129.08 168.55,129.18 168.55,130.52 168.86,130.82 169.34,130.82 169.44,130.93 169.44,131.61 169.29,131.76 168.88,131.76 168.63,132.02 168.63,132.53 168.06,133.09 v2(168.06,133.31)
FDI_CTX_PRX_N0: length 150.6
  TOP w0.076: 175.99,139.75 175.99,139.74 176.02,139.72 176.02,137.68 175.74,137.4 175.39,137.4 174.83,136.84 JCPU1.P33
  TOP w0.102: 175.99,139.75 175.99,139.85 174.9,140.95 157.77,140.95 153.82,136.99 153.82,117.59 139.44,103.21 139.44,92.85 129.13,82.54 115.29,82.54 113.22,80.47 103.77,80.47 103.76,80.46 103.23,80.46 103.21,80.47 97.5,80.47 95.21,78.18 92.82,78.18 91.72,79.29 89.94,79.29 89.61,78.96 88.9,78.96 v2(88.64,78.7)
  IN4 w0.089: 84.99,69.94 84.98,69.94 84.95,69.96 83.82,69.96 83.79,69.94 82.81,69.94 82.57,70.17 82.57,70.34 v2(82.39,70.52)
  IN4 w0.117: v2(88.64,78.7) 88.51,78.84 88.3,78.84 88.16,78.7 88.16,77.05 88.47,76.75 88.47,74.15 86.62,72.31 86.62,71.32 85.24,69.94 84.99,69.94
  BOTTOM w0.089: UH1.AJ35 82.12,70.26 v2(82.39,70.52)
FDI_CTX_PRX_N1: length 154.6
  TOP w0.076: 177.05,139.71 177.05,139.7 177.07,139.67 177.07,139.25 177,139.17 177,137.64 176.79,137.42 176.36,137.42 175.98,137.05 175.98,136.67 175.75,136.44 174.4,136.44 173.8,135.84 JCPU1.N32
  TOP w0.102: v2(88.64,79.9) 88.87,80.12 91.77,80.12 92.28,80.63 96.26,80.63 97.62,81.99 113.85,81.99 115.04,83.17 128.85,83.17 138.71,93.03 v3(138.71,94.49) 138.71,103.54 152.98,117.82 152.98,137.2 157.62,141.83 175.27,141.83 177.05,140.06 177.05,139.71
  IN4 w0.089: 85.76,71.79 85.76,71.77 85.73,71.74 85.73,71.37 85.11,70.75 84.56,70.75 84.4,70.9 82.31,70.9 82.07,71.15 82.07,71.33 v2(81.89,71.51)
  IN4 w0.117: v2(88.64,79.9) 88.04,79.9 87.5,79.36 87.5,76.59 87.7,76.39 87.7,74.56 85.76,72.61 85.76,71.79
  BOTTOM w0.089: UH1.AL35 81.89,71.22 81.89,71.44 81.86,71.48 81.86,71.48 81.87,71.48 81.89,71.51 v2(81.89,71.51)
FDI_CTX_PRX_P0: length 150.5
  TOP w0.076: 176.21,139.75 176.21,139.74 176.18,139.72 176.18,137.59 175.83,137.24 175.46,137.24 175.39,137.16 175.39,137.04 JCPU1.R33
  TOP w0.102: v2(88.64,79.31) 88.78,79.17 89.52,79.17 89.85,79.5 91.81,79.5 92.91,78.4 95.12,78.4 97.41,80.68 v3(103.49,80.68) 113.13,80.68 115.2,82.75 129.04,82.75 139.23,92.94 139.23,103.3 153.61,117.68 153.61,137.08 157.68,141.16 174.99,141.16 176.21,139.94 176.21,139.75
  IN4 w0.089: 84.99,70.17 84.98,70.17 84.95,70.14 83.74,70.14 83.72,70.12 82.88,70.12 82.75,70.24 82.75,70.45 82.83,70.52 v2(82.97,70.52)
  IN4 w0.117: v2(88.64,79.31) 88.64,79.19 88.58,79.12 88.47,79.12 88.43,79.08 88.21,79.08 87.93,78.8 87.93,76.95 88.23,76.65 88.23,74.25 86.38,72.4 86.38,71.42 85.14,70.17 84.99,70.17
  BOTTOM w0.089: v2(82.97,70.52) 82.71,70.27 UH1.AJ36
FDI_CTX_PRX_P1: length 154.6
  TOP w0.076: 177.27,139.71 177.27,139.69 177.24,139.66 177.24,139.18 177.16,139.1 177.16,137.57 176.85,137.26 176.43,137.26 176.15,136.98 176.15,136.6 175.82,136.28 174.47,136.28 174.34,136.15 174.34,136.09 JCPU1.P32
  TOP w0.102: 177.27,139.71 177.27,140.15 175.36,142.05 157.53,142.05 152.77,137.29 152.77,117.91 138.49,103.63 138.49,94.77 138.48,94.75 138.48,94.22 138.49,94.21 138.49,93.12 128.76,83.39 114.95,83.39 113.76,82.21 97.53,82.21 96.18,80.85 92.19,80.85 91.68,80.34 88.78,80.34 v2(88.64,80.48)
  IN4 w0.089: 85.52,71.79 85.52,71.77 85.55,71.74 85.55,71.44 85.04,70.93 84.63,70.93 84.48,71.08 82.38,71.08 82.24,71.22 82.24,71.34 82.26,71.36 82.26,71.41 82.35,71.49 v2(82.47,71.49)
  IN4 w0.117: 85.52,71.79 85.52,72.71 87.47,74.66 87.47,76.29 87.27,76.5 87.27,79.46 87.94,80.13 88.3,80.13 88.47,80.31 88.55,80.31 88.64,80.4 v2(88.64,80.48)
  BOTTOM w0.089: UH1.AL36 82.47,71.23 v2(82.47,71.49)
FDI_INT: length 124.7
  TOP w0.102: v2(169.06,133.31) 169.53,132.84 JCPU1.J29 ; v2(156.62,117.77) v1(156.62,118.42)
  IN3 w0.127: v2(84.26,71.49) 84.57,71.79 85.37,71.79 87.55,73.97 87.55,74.23 90.97,77.66 91.34,77.66 94.16,80.48 96.52,80.48 98.04,82 103.29,82 104.08,82.79 112.12,82.79 117.45,88.13 121.06,88.13 129.03,96.1 129.03,104.31 136.19,111.47 150.9,111.47 155.9,116.47 155.92,116.47 156.62,117.18 v2(156.62,117.77)
  BOTTOM w0.089: UH1.AL40 84.26,71.23 v2(84.26,71.49)
  BOTTOM w0.102: v2(156.62,117.77) 155.9,118.48 155.9,121.27 156.11,121.48 157.02,121.48 159.47,123.93 159.47,125.6 161.29,127.42 161.36,127.42 161.64,127.7 163.76,127.7 163.98,127.93 165.3,127.93 166.06,128.69 167.51,128.69 167.69,128.87 168.53,128.87 168.76,129.1 168.76,129.6 168.98,129.83 169.24,129.83 169.49,130.09 169.49,130.54 169.67,130.72 169.67,132.47 169.06,133.09 v2(169.06,133.31)
FDI_IREF: length 9.2
  BOTTOM w0.254: RH96.2 89.6,79.35 v1(89.6,79.02) 89.6,76.51 88.73,75.64 88.73,75.34 88.32,74.93 88.32,74.61 86.76,73.04 UH1.AT45
FDI_RCOMP: length 9.1
  BOTTOM w0.254: RH99.2 89.97,78.7 89.97,76.37 89.41,75.82 89.41,75.51 88.82,74.93 88.82,74.6 86.85,72.63 UH1.AR44
FFS_INT2: length 232.8
  TOP w0.305: U88.9 178.29,43.45 179.07,44.23 179.07,45.35 180.67,46.95 187.44,46.95 188,46.39 199.97,46.39 v2(200.76,45.61) ; R504.2 64.18,73.83 65.18,72.84 66.14,72.84 66.6,72.37 v2(66.6,72.26)
  IN1 w0.305: v2(66.6,72.26) 66.6,72.4 66.04,72.96 64.24,72.96 62.52,71.25 62.52,60.4 60.3,58.17 60.3,56.38 61.34,55.33 61.34,51.25 67.74,44.84 67.74,44.29 68.36,43.67 75.42,43.67 77.65,41.43 94.54,41.43 95.27,42.17 98.36,42.17 99.05,41.48 103.13,41.48 103.4,41.21 113,41.21 113.86,40.35 119.81,40.35 122.55,37.61 v2(168.78,37.61) 174.8,37.61 175.75,38.55 181.02,38.55 182.04,37.54 182.04,36.67 182.75,35.95 186.92,35.95 188.39,37.43 192.3,37.43 200.48,45.61 v2(200.76,45.61)
  BOTTOM w0.076: v2(66.6,72.26) 67.15,71.72 67.92,71.72 68.12,71.51 68.4,71.51 68.71,71.82 UH1.AN4
  BOTTOM w0.305: Q29.2 204.06,63.06 203.02,64.1 202.23,64.1 v1(201.6,63.46) 200.73,62.6 200.73,57.91 200.15,57.33 200.15,46.22 v2(200.76,45.61)
FFS_INT2_Q: length 150.9
  TOP w0.305: v2(202.72,63.59) 201.71,62.58 JSATA1.18 ; 90.65,32.2 v2(90.65,34)
  IN3 w0.305: v2(90.65,34) 90.65,34.02 90.88,34.25 107.26,34.25 109.9,31.61 125.19,31.61 126.59,33.01 142.54,33.01 144.6,30.95 154.14,30.95 156.83,28.26 165.94,28.26 166.64,28.96 178.17,28.96 180.8,31.59 188.54,31.59 189.97,30.16 189.97,30.14 v2(189.99,30.14)
  BOTTOM w0.305: R506.2 202.28,62 202.28,63.16 v2(202.72,63.59) ; R506.2 202.97,61.96 203.41,62.41 Q29.3 ; R506.2 201.57,61.96 201.14,61.53 201.14,57.74 200.85,57.45 v1(200.85,51.26) 200.56,50.97 200.56,46.7 201.27,45.99 201.27,45.17 198.91,42.81 198.91,40.37 192.2,33.66 192.2,32.34 v2(189.99,30.14)
FFS_PCH_INT: length 16.6
  TOP w0.076: v2(73.38,63.18) 73.28,63.28 73.28,63.84 72.64,64.48 71.7,64.48 71.54,64.64 69.66,64.64 69.26,65.05 68.55,65.05 68.39,64.88
  TOP w0.102: 68.39,64.88 68.36,64.86 68.36,64.29 67.61,63.54 v1(65.91,63.54) 63.56,63.54 63.02,63.01 60.3,63.01 RH106.2
  BOTTOM w0.102: UH1.M15 73.56,63.36 v2(73.38,63.18)
FWP#: length 14.9
  TOP w0.102: v2(232.08,36.77) 232.59,36.77 236.12,40.3 237.77,40.3 239.53,42.05 239.53,42.34 v2(240,42.81)
  BOTTOM w0.102: v2(240,42.81) 240.55,42.26 U51.B65 ; v1(231.72,37.26) 232.08,36.91 v2(232.08,36.77) 232.41,37.1 R872.2 R879.2
GFX_CLK_REQ#: length 16.4
  TOP w0.102: v2(69.98,69.51) 69.98,69.51 69.98,69.57 69.49,70.06 69.09,70.06 68.23,69.2 62.61,69.2 RH128.1 62.33,69.58 62.33,70.32 v1(61.64,71.01) 60.04,71.01 58.72,69.69 57.66,69.69 QH3.1
  BOTTOM w0.102: v2(69.98,69.51) 69.75,69.27 UH1.AF6
GPIO_PSID_SELECT: length 349
  TOP w0.102: v2(9.68,101.16) 9.37,100.85 9.37,100.53 9.5,100.41 PU1.6
  IN4 w0.109: v2(9.68,101.16) 8.48,99.96 8.48,96.45 13.59,91.34 13.59,87.31 15.55,85.35 17.29,85.35 18.36,84.28 18.36,82.69 17.6,81.93 17.6,81.03 16.38,79.81 16.38,78.43 16.13,78.18 16.13,75.93 21.08,70.98 22.84,70.98 23.05,70.78 26.79,70.78 26.97,70.6 28.65,70.6 29.46,71.41 36.89,71.41 38,70.3 39.41,70.3 39.83,69.88 39.83,69.41 40.27,68.96 41.73,68.96 42.5,68.19 42.73,68.19 44,66.93 44.71,66.93 45.71,65.93 46.74,65.93 48.2,64.47 48.2,56.77 52.02,52.95 52.02,51.56 54.26,49.32 54.26,45.79 62.17,37.88 76.49,37.88 77.74,36.62 81.02,36.62 81.49,37.09 84.21,37.09 84.49,37.37 85.84,37.37 85.94,37.27 86.88,37.27 87.85,36.3 96.18,36.3 96.79,36.91 101.7,36.91 103.2,38.41 113.07,38.41 113.49,37.99 116.12,37.99 120.45,37.99 121.45,36.98 166.95,36.98 167.64,36.3 174.13,36.3 175.87,38.04 181.99,38.04 182.55,37.48 183.34,37.48 183.67,37.81 184.05,37.81 184.29,37.57 185.33,37.57 185.55,37.78 187.86,37.78 188.13,37.51 189.72,37.51 191.91,39.7 198.19,39.7 200.25,41.76 204.7,41.76 205.02,41.44 205.87,41.44 207.33,42.9 219.69,42.9 222.02,40.58 223.01,40.58 225.04,38.55 226.67,38.55 231.14,34.07 232.21,34.07 232.48,33.8 235.13,33.8 235.9,33.03 244.53,33.03 248.24,36.74 248.24,36.97 250.16,38.89 250.16,39.08 250.87,39.79 250.87,40.83 251.5,41.47 251.5,42.91 251.21,43.21 251.21,50.44 252.14,51.37 252.54,51.37 253.27,52.11 253.27,54.45 254.54,55.71 254.54,57.38 254.34,57.58 254.34,58.11 v2(254.61,58.38)
  BOTTOM w0.102: U46.A6 244.15,70.66 244.25,70.55 244.59,70.55 244.77,70.73 245.97,70.73 246.18,70.52 247.78,70.52 248.46,71.21 250.65,71.21 252.93,68.92 v1(252.93,66.87) 252.93,63.14 254.92,61.16 254.92,58.69 v2(254.61,58.38)
GPU_PWR_LEVEL: length 193.8
  TOP w0.102: v2(207.26,84.75) 208.2,84.75 210.06,82.89 217.75,82.89 218.44,83.58 222.4,83.58 225.91,80.07 235.53,80.07 236.14,79.46 236.35,79.46 236.7,79.11 236.7,78.58 236.09,77.97 236.09,76.32 v2(236.19,76.22) ; U17.2 113.13,126.56 114.68,125.01 115.29,125.01 116.01,125.73 117.33,125.73 117.83,125.24 v2(117.83,124.85)
  IN3 w0.127: v2(236.19,76.22) 236.75,75.66 236.75,75.35 236.98,75.12 238.56,75.12 239.47,76.04 240.14,76.04 240.61,75.56 240.61,74.54 239.55,73.47 239.55,71.69 240.94,70.29 240.94,69.96 241.44,69.46 242.46,69.46 243.45,68.47 245.26,68.47 246.18,67.55 246.18,63.93 245.31,63.06 245.31,62.47 244.35,61.51 239.93,61.51 v2(239.22,62.22)
  BOTTOM w0.102: v2(239.22,62.22) 238.73,61.74 R782.1 ; v2(236.19,76.22) 236.17,76.22 235.69,75.73 235.69,75.5 235.98,75.21 U46.A52 ; v2(207.26,84.75) 198.5,84.75 194.08,89.17 191.44,89.17 187.63,92.98 180.68,92.98 178.47,95.19 155.44,95.19 153.44,97.19 150.45,97.19 149.33,96.08 136.07,96.08 130,102.15 130,103.09 126.38,106.71 122.66,106.71 117.52,111.84 117.52,114.11 v1(118.03,114.62) 119.96,116.55 119.96,119.61 119.01,120.57 119.01,121.47 119.68,122.14 119.68,123.32 118.15,124.85 v2(117.83,124.85)
GPU_SMBCLK: length 257.5
  TOP w0.102: v2(235.99,44.74) 235.99,44.41 235.79,44.21 232.61,44.21 232.21,44.62 232.21,45.96 227.23,50.94 227.23,51.7 223.33,55.59 218.14,55.59 209.54,64.2 209.54,69.39 207.42,71.51 207.42,76 207.15,76.26 206.92,76.26 v2(206.73,76.45)
  BOTTOM w0.102: R822.2 235.96,44.77 v2(235.99,44.74) 236.23,44.74 236.9,45.42 U51.A7 ; Q295.3 50.33,141.98 50.42,142.08 52.6,142.08 52.93,141.75 52.93,140.73 v1(51.52,139.31) 51.21,139 51.21,138.67 49.76,137.22 49.76,135.32 52.83,132.25 65.07,132.25 66.57,130.75 66.57,126.53 77.47,115.63 77.47,108.97 87.41,99.02 100.48,99.02 102.59,101.13 107.01,101.13 107.82,101.94 114.18,101.94 114.66,102.43 115.6,102.43 118.3,99.73 123.05,99.73 124.12,98.67 125.16,98.67 138.47,85.36 146.72,85.36 147.86,86.5 152.86,86.5 154.99,88.63 165.08,88.63 170.06,83.66 179.53,83.66 180.5,82.69 182.37,82.69 183.21,83.53 191.82,83.53 197.48,77.86 204.42,77.86 206.02,76.26 206.54,76.26 v2(206.73,76.45)
GPU_SMBCLK_R: length 43.7
  TOP w0.102: JMXM1.70 49.44,144.16 49.3,144.02 49.3,143.82 48.61,143.13 48.61,141.9 48.72,141.8 48.79,141.8 49.7,140.89 49.83,140.89 49.88,140.84 v2(49.88,140.83) ; R2182.1 15.87,143.14 18.55,143.14 19.43,142.27 22.59,142.27 v2(22.77,142.09)
  IN4 w0.109: v2(22.77,142.09) 22.94,142.26 24.1,142.26 24.73,142.89 40.57,142.89 42.75,140.71 46.8,140.71 47.23,140.28 48.83,140.28 49.38,140.83 v2(49.88,140.83)
  BOTTOM w0.102: R1.2 50.38,140.08 Q295.4 49.9,140.83 v2(49.88,140.83)
GPU_SMBDAT: length 256.8
  TOP w0.102: v2(239.14,45.16) 239,45.16 238.63,44.79 236.7,44.79 235.89,43.98 232.45,43.98 231.52,44.91 v2(231.52,45.03) 231.62,45.03 231.98,45.39 231.98,45.87 227,50.85 227,51.6 223.24,55.36 218.05,55.36 209.31,64.1 209.31,69.29 207.19,71.41 207.19,75.91 207.06,76.04 206.93,76.04 v2(206.73,75.83)
  BOTTOM w0.102: v2(239.14,45.16) 239.13,45.17 U51.B7 ; v2(206.73,75.83) 206.53,76.04 205.92,76.04 204.32,77.64 197.39,77.64 191.72,83.3 183.3,83.3 182.47,82.46 180.4,82.46 179.44,83.43 169.97,83.43 164.99,88.41 155.08,88.41 152.95,86.27 147.96,86.27 146.81,85.13 138.38,85.13 125.07,98.44 124.02,98.44 122.95,99.51 118.2,99.51 115.51,102.2 114.76,102.2 114.27,101.71 107.91,101.71 107.1,100.9 102.68,100.9 100.58,98.79 87.32,98.79 77.24,108.87 77.24,115.54 66.34,126.44 66.34,130.65 64.98,132.02 52.74,132.02 49.53,135.22 49.53,137.32 50.98,138.77 50.98,138.8 50.77,139 49.27,139 48.6,139.68 Q295.6 ; v2(231.52,45.03) 231.79,44.77 R829.2
GPU_SMBDAT_R: length 43.9
  TOP w0.102: JMXM1.68 48.94,144.16 49.08,144.02 49.08,143.92 48.39,143.23 48.39,141.49 v2(48.56,141.31) ; v2(22.77,142.67) 22.59,142.49 19.52,142.49 18.65,143.37 15.87,143.37 R2183.1
  IN4 w0.109: v2(48.56,141.31) 48.82,141.31 49.07,141.06 49.07,140.86 48.73,140.51 47.33,140.51 46.9,140.95 42.85,140.95 40.66,143.13 24.64,143.13 24.01,142.5 22.94,142.5 v2(22.77,142.67)
  BOTTOM w0.102: R2.2 50.75,141.34 49.24,141.34 Q295.1 48.6,141.35 v2(48.56,141.31)
GREEN_CRT: length 96.4
  IN4 w0.109: v2(104.32,107.4) 104.91,108 104.91,112.87 105.5,113.45 105.5,115.1 107.77,117.38 107.77,123.43 107.47,123.74 107.47,126.02 107.77,126.33 107.77,126.91 106.48,128.21 106.48,132.59 110.78,136.89 110.78,137.48 110.88,137.58 111.28,137.58 111.38,137.68 111.38,140.63 111.28,140.73 110.88,140.73 110.78,140.83 110.78,142.41 111.63,143.27 111.63,143.79 110.95,144.47 110.95,145.2 111.08,145.33 112.46,145.33 112.59,145.45 112.59,147.49 112.94,147.84 112.94,150.25 110.02,153.17 103.83,153.17 94.81,162.18 93.27,162.18 92.3,163.15 90.28,163.15 90.02,163.4 86.87,163.4 86.09,162.62 v2(85.44,162.62)
  BOTTOM w0.102: v2(104.32,107.4) v1(102.14,107.4) 99.46,107.4 99,106.94 U19.32 ; L2.1 86.59,160.08 86.21,159.7 84.66,159.7 84.56,159.8 84.56,160.24 84.66,160.34 85.27,160.34 85.44,160.52 C23.1 R54.1 v2(85.44,162.62)
GREEN_CRT_L: length 12.6
  BOTTOM w0.102: JCRT1.2 86.64,170.17 v1(86.64,169.15) 86.64,164.45 86.26,164.07 C12.1 86.26,162.14 L2.2
GREEN_DOCK: length 13.1
  IN3 w0.127: v2(94.38,109.54) 94.36,109.54 93.75,110.15 93.75,114.95 v2(94.94,116.14)
  BOTTOM w0.102: JDOCK1.59 97.24,117.5 v1(95.88,116.14) v2(94.94,116.14) ; v2(94.38,109.54) 94.71,109.21 U19.23
H_CATERR#: length 15
  TOP w0.102: JCPU1.AN32 v2(194.06,136.31)
  BOTTOM w0.102: v2(194.06,136.31) 193.6,136.77 193.6,137.57 193.89,137.86 194.23,137.86 194.49,138.11 194.49,140.63 v1(198.34,144.48) 200.33,146.47 200.33,147.01 RC128.2
H_CPU_RSVD: length 2.6
  TOP w0.102: JCPU1.G26 168.06,130.31 v2(168.06,131.31)
  BOTTOM w0.089: v2(168.06,131.31) 168.12,131.25 RC59.1
H_CPU_SVIDALRT#: length 14.7
  TOP w0.254: RC61.1 v2(202.28,136.34) ; JCPU1.AM28 192.59,131.78 v2(193.06,131.31)
  IN1 w0.254: v2(193.06,131.31) 193.06,131.32 193.56,131.83 194.29,131.83 194.57,132.1 194.57,133.53 194.85,133.81 195.32,133.81 195.55,134.05 195.55,134.51 195.85,134.81 199.26,134.81 199.41,134.96 200.4,134.96 200.99,135.55 200.99,135.87 201.45,136.34 v2(202.28,136.34)
  BOTTOM w0.102: v2(202.28,136.34) v1(203,136.34)
H_CPU_TESTLO: length 16
  TOP w0.089: JCPU1.W34 179.59,137.85 v2(180.06,138.32)
  BOTTOM w0.102: RC45.1 169.14,145.1 v1(169.53,144.7) 169.82,144.41 173.25,144.41 177.8,139.87 178.3,139.87 178.54,139.64 178.54,139.13 178.92,138.75 179.63,138.75 v2(180.06,138.32)
H_CPUPWRGD: length 304
  TOP w0.102: RC5.1 201.42,146.44 RC25.1 v2(200.91,146.6)
  IN1 w0.109: v2(208.66,134.07) 208.66,135.71 200.91,143.46 v2(200.91,146.6)
  IN3 w0.127: v2(208.66,134.07) 210.67,132.07 210.67,126.51 212.55,124.63 212.55,120.85 211.15,119.45 211.15,118.47 211.8,117.83 211.8,106.64 212.14,106.29 212.14,105.02 215.77,101.39 215.77,95.59 218.92,92.44 218.92,86.42 215.9,83.4 215.9,72.25 211.81,68.16 211.81,66.35 210.27,64.82 210.27,62.66 205.71,58.1 205.71,57.42 204.7,56.4 200.35,56.4 197.12,53.17 195.97,53.17 192.17,49.37 191.25,49.37 189.03,47.14 170.49,47.14 166.59,43.24 165.69,43.24 164.85,42.41 149.27,42.41 148.31,43.37 148.31,44.01 147.17,45.15 124.51,45.15 121.53,48.12 119.12,48.12 116.68,50.56 101.34,50.56 100.51,51.4 92.47,51.4 92.23,51.16 85.13,51.16 84.53,51.75 77.91,51.75 77.22,52.44 75.82,52.44 73.79,54.47 68.99,54.47 66.98,56.48 66.98,57.29 66.1,58.16 66.1,58.94 64.46,60.58 61.96,60.58 60.88,59.5 60.4,59.5 59.63,60.27 57.02,60.27 56.68,59.94 54.19,59.94 52.56,61.57 52.56,69.32 53.18,69.93 53.18,70.95 54.98,72.75 55.37,72.75 58.1,75.48 62.85,75.48 63.24,75.87 65.49,75.87 v2(65.89,75.48)
  BOTTOM w0.076: v2(65.89,75.48) 65.89,75.04 66.19,74.74 67.03,74.74 67.61,74.16 67.97,74.16 68.17,73.95 68.5,73.95 68.6,73.85 UH1.AV3
  BOTTOM w0.102: v2(208.66,134.07) v1(209.33,134.07)
H_CPUPWRGD_XDP: length 31.3
  TOP w0.102: v2(207.04,121) 207.59,120.44 JXDP1.17 ; RC5.2 v2(201.78,144.87)
  IN1 w0.109: v2(207.04,121) 207.04,123.13 210.36,126.45 210.36,134.6 201.78,143.18 v2(201.78,144.87)
  BOTTOM w0.102: v2(207.04,121) v1(206.43,121)
H_PM_SYNC: length 283.1
  TOP w0.102: JCPU1.AT28 199.47,131.84 v2(200.05,132.42) ; v2(66.37,75.12) 66.39,75.1 T129.1
  IN3 w0.127: v2(200.05,132.42) 202.67,132.42 204.15,130.94 204.15,120.02 207.19,116.98 207.19,115.59 209.98,112.79 209.98,106.42 210.82,105.58 210.82,104.46 214.43,100.85 214.43,96.97 211.15,93.7 211.15,89.21 212.22,88.14 212.22,80.65 208.79,77.22 208.79,72.25 204.61,68.07 204.61,64.59 202.36,62.34 202.36,61.29 199.48,58.41 199.48,56.2 196.92,53.64 195.77,53.64 191.97,49.84 191.06,49.84 188.84,47.61 169.74,47.61 168.66,46.53 166.76,46.53 164.44,44.21 150.13,44.21 148.5,45.83 128.63,45.83 128.41,45.62 124.7,45.62 121.73,48.59 119.31,48.59 116.88,51.03 101.67,51.03 100.75,51.96 92.37,51.96 92.04,51.63 85.34,51.63 84.75,52.22 78.1,52.22 76.72,53.61 75.46,53.61 74.13,54.94 69.99,54.94 66.57,58.36 66.57,59.14 65.59,60.11 65.59,61.1 65.19,61.51 64.79,61.51 64.34,61.05 61.75,61.05 61.09,60.39 60.55,60.39 60.2,60.74 56.83,60.74 56.49,60.41 54.39,60.41 53.03,61.76 53.03,69.12 53.65,69.74 53.65,70.75 55.17,72.28 55.57,72.28 56.13,72.84 59.89,72.84 60.02,72.96 63.96,72.96 65.84,74.84 66.09,74.84 v2(66.37,75.12)
  BOTTOM w0.076: v2(66.37,75.12) 66.55,74.94 67.11,74.94 67.68,74.37 67.98,74.37 68.27,74.66 UH1.AY3
H_PROCHOT#: length 286.2
  TOP w0.102: PC510.1 155.24,175.4 v2(155.09,175.25)
  TOP w0.254: PR524.1 155.68,174.54 155.7,174.56 PC510.1
  IN1 w0.109: v2(207.9,149.92) 206.06,151.76 206.06,173.3 204.46,174.89 163.95,174.89 163.1,174.05 160.7,174.05 160.2,174.56 155.78,174.56 v2(155.09,175.25)
  IN2 w0.127: v2(222.48,48.3) 223.92,46.85 v2(223.92,44.35)
  IN3 w0.127: v2(254.86,44.26) 254.04,45.09 252.45,45.09 251.03,43.66 248.73,43.66 247.21,45.17 243.38,45.17 240,48.55 236.59,48.55 236.45,48.69 233.61,48.69 233.15,49.16 231.65,49.16 231.28,48.79 231.28,47.61 230.19,46.52 230.19,45.29 228.52,43.63 224.65,43.63 v2(223.92,44.35)
  IN4 w0.109: v2(242.42,24.66) 243.04,24.04 246.87,24.04 256.44,33.6 256.44,41.8 254.86,43.37 v2(254.86,44.26) ; v2(207.9,149.92) 207.19,149.21 207.19,145.25 204.91,142.98 204.91,138.81 209.32,134.4 209.32,130.65 207.87,129.2 207.87,115.33 211.09,112.11 211.09,105.87 216.25,100.72 216.25,98.87 221.08,94.04 221.08,90.48 225.02,86.54 225.02,72.94 v2(225.47,72.48)
  BOTTOM w0.102: R1180.2 254.23,43.83 254.23,43.5 254.55,43.18 Q47.1 254.61,44.01 v2(254.86,44.26) ; v2(223.92,44.35) 223.52,43.94 223.17,43.94 221.18,45.94 PQ1080.3 220.79,47.07 218.26,49.59 218.26,54.94 219.84,56.51 219.84,63.8 223.67,67.64 223.67,68.9 225.47,70.7 v2(225.47,72.48) ; PQ1080.6 v2(222.48,48.3) ; RC57.1 RC44.2 204.16,148.32 205.76,149.92 v2(207.9,149.92) ; PR739.2 242.68,21.74 v1(242.68,24.21) 242.68,24.4 v2(242.42,24.66)
H_PROCHOT#_R: length 22.9
  TOP w0.102: JCPU1.AM30 v2(193.06,134.31)
  BOTTOM w0.102: v2(193.06,134.31) 193.24,134.49 193.24,134.65 193.06,134.84 191.72,134.84 191.49,135.07 191.49,135.6 191.69,135.8 193.42,135.8 193.55,135.93 197.31,135.93 198.06,136.68 198.06,140.32 v1(199.5,141.75) 202.51,144.77 202.51,145.12 RC57.2
H_THERMTRIP#: length 133.4
  TOP w0.102: RC129.1 RC126.2 v1(205.17,147.31) 205.64,147.31 v2(205.84,147.51)
  IN3 w0.127: v2(218.31,95.52) 220.38,93.45 220.38,87.16 223.93,83.62 223.93,82.59 226.92,79.59 234.67,79.59 235.25,79.01 235.61,79.01 236.09,79.49 236.85,79.49 237.46,80.1 241.07,80.1 242.22,81.25 247.57,81.25 253.44,75.38 253.44,64.05 250.76,61.36 250.76,59.61 248.95,57.81 v2(248.95,57.2)
  IN4 w0.109: v2(218.31,95.52) 215.42,98.41 215.42,100.37 210.27,105.53 210.27,111.77 206.88,115.15 206.88,116.5 204.88,118.5 204.88,138.24 204.44,138.67 204.44,143.14 206.65,145.35 206.65,146.7 v2(205.84,147.51)
  BOTTOM w0.102: v2(248.95,57.2) 248.65,57.5 Q28.3
H_THERMTRIP#_R: length 14.3
  TOP w0.102: JCPU1.AM35 193.9,140.15 197.05,140.15 197.39,140.49 197.39,140.5 200.25,143.36 200.49,143.6 201.16,144.27 201.76,144.27 202.67,145.17 RC129.2 203.16,145.53 v1(203.68,146.05)
HDD1_DET#: length 214.5
  TOP w0.102: v2(201.78,45.61) 203.22,45.61 207.19,49.57 207.19,51.45 203.67,54.96 JSATA1.12
  IN1 w0.109: v2(201.78,45.61) 200.81,44.64 200.66,44.64 193.14,37.12 188.52,37.12 187.05,35.65 181.91,35.65 179.31,38.25 175.95,38.25 174.8,37.1 122.62,37.1 119.68,40.04 113.73,40.04 112.87,40.9 103.27,40.9 103,41.17 98.92,41.17 98.23,41.86 95.4,41.86 94.67,41.12 77.51,41.12 75.27,43.36 67.47,43.36 65.77,45.06 65.77,46.3 60.79,51.28 60.79,55.23 60.81,55.24 59.97,56.08 59.97,58.28 62.21,60.53 62.21,72.39 v2(64.54,74.71)
  BOTTOM w0.102: UH1.AT1 67.62,73.04 67.16,73.5 66.33,73.5 65.54,74.28 64.97,74.28 v2(64.54,74.71) 64.34,74.51 64.06,74.51 v1(63.34,75.23) 62.89,75.68 62.89,76.16 RH36.1 61.72,76.21 61.11,76.21 60.88,76.44 60.88,76.82 60.04,77.67 58.51,77.67 57.87,77.03 RH11.1
HDD2_DET#: length 82.4
  TOP w0.102: v2(74.65,34.44) 74.65,33.29 78.61,29.32 81.46,29.32 83.03,30.9 JSATA2.12
  IN1 w0.109: v2(74.65,34.44) 74.15,34.94 69.19,34.94 67.74,36.39 64.51,36.39 54,46.9 54,62.62 54.61,63.23 54.61,64.66 54.09,65.18 54.09,71.55 55.22,72.68 v2(55.22,73.19)
  BOTTOM w0.076: 65.67,71.68 65.95,71.68 66.55,71.08 67.44,71.08 67.61,70.9 67.94,70.9 68.15,70.7 68.62,70.7 UH1.AK3
  BOTTOM w0.102: 65.67,71.68 64.12,71.68 63.35,72.45 RH227.1 61.77,72.96 60.37,72.96 RH19.1 ; v2(55.22,73.19) 55.88,72.53 v1(57.55,72.53) 57.77,72.53 58.03,72.79 58.69,72.79 58.7,72.78 59.43,72.78 RH19.1 ; RH19.1 RH225.1
HDD_FALL_INT: length 162.1
  TOP w0.305: U88.11 R503.2 176.22,44.69 175.97,44.95 v2(175.97,45.73) ; RH106.1 v1(56.74,63.44) 56.08,64.1 56.08,64.25 v2(56.03,64.3)
  IN1 w0.305: v2(171.46,32.54) 170.61,31.69 156.69,31.69 154.82,33.55 117.74,33.55 115.72,35.57 81.73,35.57 81.59,35.71 69.45,35.71 67.22,37.94 65.96,37.94 60.83,43.07 60.83,44.87 54.96,50.74 54.96,60.82 56.03,61.89 v2(56.03,64.3)
  BOTTOM w0.305: v2(171.46,32.54) 171.46,42.77 173.71,45.02 175.36,45.02 175.97,45.63 v2(175.97,45.73)
HDMI_CEC: length 10.1
  TOP w0.102: v2(37.49,163.77) 38,163.77 R1165.1 38.45,165.15 v1(38.42,165.19)
  IN3 w0.127: JHDMI1.13 33.4,168.1 33.4,165.82 35.46,163.77 v2(37.49,163.77)
HDMI_HPD_SINK: length 16.6
  TOP w0.102: R1128.1 R1164.1 40.74,162.93 40.74,162.5 40.23,161.99 37.62,161.99 v2(37.18,162.42) ; U9.17 30.6,159.12 v2(30.63,159.14)
  BOTTOM w0.102: v2(37.18,162.42) v1(36.3,162.42) 31.39,162.42 30.63,161.66 v2(30.63,159.14)
HDMI_HPD_SINK_R: length 8.1
  TOP w0.102: R1164.2 41.12,164.78 v2(41.38,165.04) 41.77,165.04 v1(42.14,165.41)
  IN3 w0.127: v2(41.38,165.04) 41.38,165.67 38.41,168.64 JHDMI1.19
HDMI_SCL_SINK: length 39.8
  TOP w0.102: JHDMI1.15 35.52,168.06 37.26,168.06 37.76,168.55 38.11,168.55 39.72,166.94 v3(39.72,165.79) 39.72,165.38 v2(39.39,165.04) 39.67,164.76 39.67,164.55 R461.2 ; v2(27.81,147.21) 27.62,147.4 27.62,149.01 27.65,149.04 27.65,149.55 28.2,150.11 U9.48
  IN1 w0.117: v2(39.39,165.04) 39.39,164.85 39.47,164.77 39.72,164.77 39.82,164.87 39.82,165.25 39.49,165.58 36.36,165.58 35.05,164.28 35.05,162.26 32.07,159.28 32.07,152.85 27.46,148.23 27.46,147.56 v2(27.81,147.21)
HDMI_SDA_SINK: length 39.9
  TOP w0.102: JHDMI1.16 36.02,170.22 36.76,170.22 39.94,167.04 39.94,166.06 39.95,166.05 39.95,165.52 39.94,165.51 39.94,165.34 v2(40.24,165.04) 39.9,164.7 39.9,164.55 R460.2 ; v2(27.23,147.18) 27.41,147.36 v3(27.41,149.35) 27.41,149.62 27.8,150.02 U9.47
  IN1 w0.117: v2(40.24,165.04) 40.24,165.17 39.59,165.82 36.26,165.82 34.81,164.37 34.81,162.36 31.83,159.38 31.83,152.94 27.22,148.33 27.22,147.19 v2(27.23,147.18)
HOST_DEBUG_RX: length 12.2
  IN3 w0.127: v2(246.99,44.7) 247.02,44.7 248.53,43.19 255.68,43.19 v2(255.78,43.29)
  BOTTOM w0.102: R760.2 256.56,45.02 255.78,44.23 v1(255.78,44.03) v2(255.78,43.29) ; v2(246.99,44.7) 247.03,44.67 U51.B46
HOST_DEBUG_TX: length 266.4
  TOP w0.102: v2(210.84,66.94) 210.84,63.82 218.46,56.2 224.26,56.2 231.55,48.91 232.45,48.91 233.95,47.41 234.06,47.41 234.92,46.55 238.88,46.55 238.98,46.64 239.94,46.64 240.73,47.44 245.06,47.44 246.18,46.32 246.28,46.32 246.91,45.69 v2(246.91,45.67)
  IN3 w0.127: v2(269.98,34.68) 268.15,36.51 262.25,36.51 258.81,39.96 258.81,42.72 256.12,45.4 255.12,45.4 254.96,45.56 252.25,45.56 250.9,44.21 250.01,44.21 249.63,44.59 248.72,44.59 247.64,45.67 v2(246.91,45.67)
  IN4 w0.109: v2(210.84,66.94) 210.36,66.94 209.52,67.78 209.52,68.12 188.05,89.59 173.44,89.59 170.59,92.44 144.18,92.44 133.89,102.73 132.59,102.73 132.49,102.83 121.95,102.83 118.58,106.2 118.58,114.66 121.66,117.73 124.81,117.73 125.9,118.83 125.9,126.6 124.82,127.69 122.92,127.69 122.2,128.41 122.2,133.64 120.85,134.99 120.85,136.93 120,137.78 120,148.24 119.02,149.21 119.02,151.54 119.48,152 v2(119.48,153.3)
  BOTTOM w0.102: JDEG2.3 275.21,32.09 274.88,31.76 274.88,30.84 275.08,30.64 275.08,29.83 274.24,28.99 270.25,28.99 269.98,29.27 R848.2 269.26,31 v1(269.26,31.36) 269.26,33.97 v2(269.98,34.68) ; v2(119.48,153.3) 119.25,153.3 116.25,156.3 116.25,156.68 C595.1 116.69,157.62 JMINI2.16 ; v2(246.91,45.67) 246.91,45.67 U51.B44
HSYNC: length 5
  TOP w0.102: RH94.2 87.22,66.13 87.22,65.27 86,64.05 v1(85.6,64.05) 84.86,64.05 v2(84.81,64.1)
  BOTTOM w0.102: v2(84.81,64.1) 85.1,63.8 UH1.N42
HSYNC_BUF: length 72.6
  TOP w0.102: L4.1 86.11,165.08 86.49,164.71 86.49,162.4 v1(86.77,162.12) v2(87.49,161.39)
  IN4 w0.109: v2(87.49,161.39) 88.26,161.39 89.89,159.77 89.89,158.06 90.49,157.46 92.63,157.46 94.61,155.48 94.61,144.51 94.21,144.12 94.21,141.48 95.35,140.34 95.35,137.88 102.36,130.87 102.36,121.41 101.99,121.03 101.99,112.97 102.1,112.85 102.1,109.52 101.1,108.52 101.1,105.84 99.74,104.48 v2(99.67,104.48)
  BOTTOM w0.102: U19.37 99.22,104.94 v2(99.67,104.48)
HSYNC_DOCK: length 12.8
  TOP w0.102: v2(99.21,116.8) 99.49,116.8 v1(99.86,116.43)
  IN3 w0.127: v2(96.85,108.93) 96.95,108.93 97.28,109.26 97.28,113.52 98.58,114.82 98.58,116.06 98.88,116.37 98.88,116.52 99.16,116.8 v2(99.21,116.8)
  BOTTOM w0.102: U19.28 96.71,108.79 v2(96.85,108.93) ; v2(99.21,116.8) 98.8,117.21 98.8,117.89 98.74,117.96 JDOCK1.65
HSYNC_L: length 9.8
  TOP w0.102: JCRT1.13 87.3,171.03 C19.1 R52.2 87.31,166.67 87.31,165.77 L4.2 86.96,164.18 v1(86.98,164.16)
HW_GPS_DISABLE2#: length 71.8
  TOP w0.102: v2(253.26,34.84) 253.26,35 251.99,36.27 251.99,37.58 248.54,41.03 248.54,42.6 248.98,43.04 249.83,43.04 251.46,44.67 251.46,46.33 250.53,47.26 249.95,47.26 249.6,47.61 249.27,47.61 248.84,48.04 248.84,50.71 248.73,50.83 248.73,54.43 247.55,55.61 247.55,62.76 246,64.3 v2(245.15,64.3)
  IN4 w0.109: v2(233.83,64.17) 234.13,64.47 243.5,64.47 244.08,63.89 244.75,63.89 v2(245.15,64.3)
  BOTTOM w0.102: v2(245.15,64.3) 245.18,64.3 246.15,65.27 R779.2 ; JMINI1.51 268.46,41.8 265.43,38.77 260.37,38.77 259.94,39.21 255.62,39.21 254.63,38.22 254.63,36.08 v1(253.96,35.41) 253.83,35.41 v2(253.26,34.84) ; U46.B34 234.23,64.57 v2(233.83,64.17)
ICLK_IREF: length 2.5
  TOP w0.102: v1(88.16,72.2) RH163.1
  TOP w0.254: RH163.1 87.1,71.51 v2(87.07,71.48)
  BOTTOM w0.254: UH1.AM45 86.46,71.44 87,71.44 87.04,71.48 v2(87.07,71.48)
IMON: length 3.7
  TOP w0.203: PU500.4 156.15,171.76
  TOP w0.254: 156.15,171.76 156.15,173.08 PC509.2 156.67,173.55 PR521.1
IMVP_PWRGD: length 169.5
  TOP w0.102: PR522.1 158.67,174.59 PR519.1 158.67,175.6 159,175.93 v1(160.78,175.93) 161.66,175.93 v2(162.56,175.03)
  IN1 w0.109: v2(162.56,175.03) 162.84,175.31 204.64,175.31 206.48,173.47 206.48,161.14 211.88,155.73 211.88,138.4 211.11,137.63 211.11,105.73 215.62,101.22 215.62,96.84 220.23,92.23 221.27,92.23 230.63,82.87 238.48,82.87 239.62,81.73 239.62,80.96 240.66,79.92 240.66,78.44 241.32,77.78 241.32,76.52 v2(241.22,76.41)
  BOTTOM w0.102: v2(241.22,76.41) 241.22,76.21 240.98,75.97 U46.A62
IMVP_VR_ON: length 172.6
  TOP w0.102: v1(161.77,174.68) 161.77,175.06 v2(161.43,175.4) 161.06,175.4 160.48,174.82 159.82,174.82 PR513.1
  IN1 w0.109: v2(161.43,175.4) 161.76,175.73 204.81,175.73 206.9,173.64 206.9,161.31 212.3,155.91 212.3,137.64 211.63,136.97 211.63,130.21 211.56,130.14 211.56,105.88 216.04,101.39 216.04,97.01 220.4,92.65 221.48,92.65 230.64,83.5 238.61,83.5 241.77,80.33 242.39,80.33 242.71,80.01 242.71,76.77 v2(242.48,76.54)
  IN3 w0.127: v2(242.48,76.54) 242.48,74.8 v2(241.04,73.37)
  BOTTOM w0.102: U46.B66 241.23,73.55 v2(241.04,73.37)
IN1_AEQ#: length 6.3
  BOTTOM w0.102: U629.59 37.31,125.03 37.18,125.16 37.18,126.99 36.88,127.29 v1(36.88,128.04) 36.88,128.18 36.37,128.69 36.37,129.99 R117.1
IN1_PEQ: length 4.9
  BOTTOM w0.102: U629.52 34.51,125.04 34.29,125.26 33.6,125.26 33.32,125.54 33.32,126.94 R121.1 R119.1
IN2_AEQ#: length 4.2
  BOTTOM w0.102: U629.58 36.91,125.07 36.85,125.13 v1(36.85,126.4) 36.85,126.99 35.91,127.93 R118.1
IN2_PEQ: length 5.8
  BOTTOM w0.102: R120.1 R122.1 32.1,127.39 32.31,127.19 32.31,126.12 32.13,125.95 v1(32.13,125.29) 32.46,124.96 33.73,124.96 34.11,124.57 U629.51
INTRUDER#: length 4
  BOTTOM w0.076: UH1.A8 70.98,58.44 70.43,57.9 70.43,57.32
  BOTTOM w0.102: RH43.2 71.22,55.58 v1(70.83,55.97) 70.43,56.36 70.43,57.32
IRQ_SERIRQ: length 272.1
  TOP w0.076: v2(71.96,71.49) 72.01,71.54 72.01,73.34 71.32,74.03 71.27,74.03 70.81,74.49 70.81,74.97 70.36,75.43 69.59,75.43 69.37,75.65 69.37,76.44 69.29,76.52
  TOP w0.102: v2(240.36,65.93) 240.26,66.03 239.85,66.03 239.6,65.77 239.6,65.3 240,64.9 240.12,64.9 241.21,63.82 242.22,63.82 243.28,62.76 243.28,62.22 246.3,59.2 246.3,55.13 246.58,54.85 246.58,53.64 v2(246.15,53.21) ; RH168.2 68.3,80.07 68.3,78.63 68.68,78.25 68.68,77.13 69.29,76.52
  IN1 w0.109: v2(71.96,71.49) 71.45,72 68.45,72 67.67,71.21 64.88,71.21 63.66,69.99 63.66,63.6 64.22,63.03 64.22,61.78 64.16,61.72 64.16,59.39 64.8,58.75 64.8,54.87 63.94,54 63.94,52.55 64.6,51.89 65.35,51.89 67.77,49.46 67.77,48.47 70.36,45.89 72.44,45.89 73.3,45.03 75.99,45.03 76.77,44.25 81.25,44.25 82.28,43.22 93.68,43.22 94.45,43.99 103.68,43.99 103.99,43.68 105.38,43.68 105.61,43.9 108.67,43.9 109.77,45 111.28,45 114.32,41.96 120.22,41.96 122.11,40.07 172.13,40.07 172.13,40.07 172.49,40.07 172.5,40.07 172.79,40.07 172.79,40.07 173.15,40.07 173.16,40.07 173.75,40.07 174.45,40.77 177.2,40.77 178.05,39.92 183.23,39.92 183.51,39.64 187.55,39.64 188.05,40.13 193,40.13 200.1,47.23 210.53,47.23 211.49,48.19 215.37,48.19 217.68,50.5 231.48,50.5 232.96,51.98 243.27,51.98 243.65,52.35 243.65,52.66 244.14,53.16 246.1,53.16 v2(246.15,53.21) ; v2(250.87,67.25) 246.92,67.25 245.99,66.32 243.5,66.32 243.33,66.49 240.91,66.49 v2(240.36,65.93)
  BOTTOM w0.102: U46.B21 240.73,65.56 v2(240.36,65.93) ; v2(71.96,71.49) 72.13,71.31 UH1.AL11 ; v2(250.87,67.25) v1(251.26,66.86) 251.64,66.49 251.64,65.04 251.2,64.6 U39.27 ; v2(246.15,53.21) 246.07,53.29 245.15,53.29 244.91,53.05 244.91,52.14 244.8,52.03 U51.A28
ISEN1: length 16.1
  TOP w0.203: v2(153.08,169.05) 153.19,169.15 PU500.12
  TOP w0.254: PC539.2 148.35,164.91 v2(148.44,164.91)
  IN1 w0.254: v2(153.08,169.05) 152.86,169.05 152.37,168.57 151.61,168.57 150.33,167.28 150.33,167.2 148.44,165.3 v2(148.44,164.91)
  BOTTOM w0.254: PR557.1 PR556.1 PR553.2 151.55,161.67 v1(149.71,163.51) 148.44,164.78 v2(148.44,164.91)
ISEN2: length 27.3
  TOP w0.102: v2(147.09,166.48) v1(146.32,166.48)
  TOP w0.203: v2(152.5,170.04) 152.63,169.91 152.73,169.91 153.09,169.55 PU500.11
  TOP w0.254: PC541.2 v2(147.09,166.48)
  IN1 w0.254: v2(147.09,166.48) 147.09,164.56 148.82,162.83 151.61,162.83 153.54,160.9 156.01,160.9 v2(156.39,161.28)
  IN3 w0.254: v2(152.5,170.04) 152.35,170.19 150.61,170.19 147.75,167.34 147.75,167.15 v2(147.09,166.48)
  BOTTOM w0.254: PR547.1 PR546.1 155.88,162.37 155.88,161.09 PR539.2 156.46,161.2 v2(156.39,161.28)
ISEN3: length 33.5
  TOP w0.102: PC543.2 v1(147.77,168.58)
  TOP w0.203: v2(153.08,170.22) 153.19,170.22 153.45,169.95 PU500.10
  TOP w0.254: PR516.2 PR518.2 160.76,159.78 v2(160.96,159.78) ; v2(147.14,167.37) PC543.2 ; v2(157.3,161.28) 157.07,161.28 156.3,160.5 PR510.1
  IN1 w0.254: v2(147.14,167.37) 147.14,167.35 146.53,166.74 146.53,166.15 146.73,165.95 146.73,164.42 148.67,162.47 151.47,162.47 153.4,160.54 156.56,160.54 v2(157.3,161.28)
  IN2 w0.254: v2(157.3,161.28) 157.86,160.72 160.02,160.72 v2(160.96,159.78)
  IN3 w0.254: v2(147.14,167.37) 147.14,167.38 150.33,170.57 152.73,170.57 v2(153.08,170.22)
IST_TRIGGER: length 1.4
  TOP w0.102: v2(192.06,130.31) JCPU1.AL26
  BOTTOM w0.102: T163.1 192.06,130.12 v2(192.06,130.31)
ISUMN: length 40.7
  TOP w0.254: v2(158.75,161.58) 158.49,161.33 PR512.1 ; PC539.1 148.59,166.4 PC541.1 148.66,167.34 PC543.1 149.12,166.94 150.01,166.94 PC528.1 150.37,167.35 149.91,167.35 149.76,167.5 v2(149.76,167.5) ; PH501.1 167.56,155.21 167,155.77 162.53,155.77 v1(161.26,157.04) v2(160.68,157.62)
  IN1 w0.254: v2(152.5,166.84) 153.21,166.13 153.21,163.49 154.14,162.56 155.08,162.56 155.29,162.34 v2(155.29,162.04)
  IN2 w0.254: v2(158.75,161.58) 158.72,161.61 158.72,161.63 158.06,162.29 155.55,162.29 v2(155.29,162.04)
  IN3 w0.254: v2(149.76,167.5) 150.42,166.84 v2(152.5,166.84)
  BOTTOM w0.254: PC547.1 153.39,168.59 152.64,167.84 152.64,166.98 v2(152.5,166.84) ; PR537.2 150.39,168.72 PR545.1 PR550.1 150.34,166.89 PR548.1 149.45,167.2 149.76,167.5 v2(149.76,167.5) ; v2(160.68,157.62) 160.45,157.85 160.45,159.5 159.69,160.26 PR544.2 158.75,160.39 v2(158.75,161.58) ; PR555.2 155.29,161.68 v2(155.29,162.04)
ISUMP: length 21.2
  TOP w0.203: PU500.15 153.49,167.95 153.18,167.65
  TOP w0.254: v2(151.99,165.42) 151.99,165.48 PC538.2 151.29,167.31 PC528.2 PR558.2 151.36,168.21 152.07,167.5 v1(152.35,167.5) 153.03,167.5 153.18,167.65 ; PR511.1 157.99,161.06 v2(157.99,161.58)
  IN1 w0.254: v2(151.99,165.42) 151.99,164.2 154.13,162.07 v2(154.71,162.07)
  IN2 w0.254: v2(157.99,161.58) 157.76,161.81 156.18,161.81 155.88,161.51 155.12,161.51 154.71,161.91 v2(154.71,162.07)
  BOTTOM w0.254: v2(154.71,162.07) 154.32,161.67 PR552.1 ; v2(157.99,161.58) 157.81,161.4 PR535.1 ; v2(151.99,165.42) 151.48,164.91 PC532.2 151.29,166.04 PR551.2 PR550.2
IVR_ERROR: length 10.8
  TOP w0.102: JCPU1.AR32 v2(196.06,136.31)
  BOTTOM w0.102: v2(196.06,136.31) 196.52,136.77 196.52,137.4 196.93,137.81 197.23,137.81 197.48,138.06 197.48,138.62 197.26,138.85 197.26,140.56 T162.1
JETWAY_14M: length 5
  TOP w0.102: v2(84.37,60.32) 84.12,60.08 84.12,58.62 v1(85.01,57.73) 85.66,57.09 RH161.2
  BOTTOM w0.102: UH1.F39 84.03,59.99 v2(84.37,60.32)
JETWAY_CLK14M: length 183
  TOP w0.102: v2(89,56.45) 88.62,56.45 CH80.1 RH161.1
  IN1 w0.109: v2(257.48,57.67) 255.7,59.45 253.53,59.45 253.08,59.91 252.02,59.91 250.65,58.54 243.47,58.54 242.88,57.95 241.65,57.95 240.98,58.63 238.07,58.63 237.85,58.41 229.34,58.41 228.93,58.81 226.97,58.81 226.49,58.34 213.15,58.34 210.66,55.84 199.63,55.84 197.6,53.81 196.82,53.81 191.57,48.55 159.1,48.55 158.55,49.1 155.04,49.1 154.49,48.55 122.55,48.55 121.89,49.21 118.91,49.21 114.08,54.04 103.79,54.04 101.51,56.32 95.48,56.32 95.03,55.87 93.56,55.87 93.12,56.32 91.15,56.32 90.78,55.94 89.51,55.94 v2(89,56.45)
  BOTTOM w0.102: v2(257.48,57.67) 257.26,57.45 U39.13
JTAG_CLK: length 37.3
  IN3 w0.127: v2(244.98,42.23) 245.24,42.23 246.18,43.17 247.47,43.17 247.9,42.74 249.63,42.74 250.04,42.33 250.04,42 251.41,40.63 255.34,40.63 257.81,38.16 257.81,38.06 260.98,34.89 267.63,34.89 269.54,32.98 v2(271.04,32.98)
  BOTTOM w0.102: U51.B56 245.05,42.16 v2(244.98,42.23) ; JDEG2.7 275.33,34.09 R860.2 273.28,33.11 v1(271.92,33.11) 271.17,33.11 v2(271.04,32.98)
JTAG_RST#: length 13.4
  BOTTOM w0.102: U51.A57 242.8,40.4 242.72,40.32 242.72,39.33 243,39.05 244.91,39.05 R836.1 C735.1 247.06,37.78 247.06,36.41 247.27,36.21 v1(248.6,36.21) 250.65,36.21 250.85,36.41 R1981.2 250.85,37.94 JTAG1.1
JTAG_TDI: length 44
  IN3 w0.127: v2(270.86,31.48) 267.61,28.23 257.6,28.23 253.41,32.42 251.38,32.42 250.72,33.08 250.72,34.71 250.29,35.14 250.29,38.83 249.58,39.54 246.2,39.54 245.92,39.82 v2(245.92,39.99)
  BOTTOM w0.102: v2(245.92,39.99) 245.8,40.11 U51.A51 ; v2(270.86,31.48) 270.25,32.09 270.25,33.26 v1(271.56,34.57) 272.13,35.14 273.4,35.14 273.81,34.74 R858.2 274.29,35.09 JDEG2.9
JTAG_TDO: length 40.3
  IN3 w0.127: v2(271.65,32.63) 271.54,32.74 271.54,33.3 271.02,33.82 269.59,33.82 268.3,35.12 261.5,35.12 259.41,37.21 259.41,37.88 256.41,40.88 252.6,40.88 250.52,42.96 248,42.96 247.57,43.4 246.08,43.4 245.5,42.81 v2(244.98,42.81)
  BOTTOM w0.102: v2(244.98,42.81) 245.39,42.41 245.39,42 245.55,41.84 U51.B55 ; v1(271.65,31.84) v2(271.65,32.63) 271.84,32.44 271.84,32.31 272.11,32.04 273.38,32.04 273.81,31.61 R861.2 274.42,32.17 274.42,32.7 275.31,33.59 JDEG2.6
JTAG_TMS: length 44.3
  IN3 w0.127: v2(271.04,32.32) 271.4,31.97 271.4,31.23 268.17,28 257.5,28 253.69,31.81 250.43,31.81 249.01,33.24 249.01,35.66 248.14,36.53 248.14,37.12 247.86,37.4 247.17,37.4 244.8,39.77 v2(244.8,39.99)
  BOTTOM w0.102: v2(271.04,32.32) 270.88,32.32 v1(270.58,32.61) 270.54,32.66 270.54,33.22 271.42,34.1 273.3,34.1 R859.2 274.81,34.59 JDEG2.8 ; U51.A53 v2(244.8,39.99)
KB_DET#: length 102.7
  TOP w0.076: v2(72.9,65) 73.23,64.67 73.23,64.17 73.84,63.56 73.84,62.52 73.96,62.4 73.96,60.44 74.22,60.19 74.22,59.62 74.24,59.6
  TOP w0.102: RH212.1 75.03,47.77 75.03,53.48 74.24,54.27 74.24,59.6 ; v2(125.27,86.25) 125.88,86.86 126.62,86.86 131.5,91.73 v1(131.5,94.22) JKB1.2 JKB1.1
  IN3 w0.127: v2(72.9,65) 73,65 73.18,65.18 73.18,66.51 73.48,66.82 74.75,66.82 75.08,67.15 75.82,67.15 76.45,66.51 78.38,66.51 79.96,68.09 80.64,68.09 81.18,67.55 86.28,67.55 86.57,67.84 86.75,67.84 88.11,69.2 91.18,69.2 92.89,70.9 97.36,70.9 100.68,74.23 101.6,74.23 106.91,79.54 113.41,79.54 118.24,84.37 123.26,84.37 125.14,86.25 v2(125.27,86.25)
  BOTTOM w0.102: v2(72.9,65) 72.86,65.04 72.86,65.37 UH1.U12
LAN_ACTLED_YEL#: length 17.1
  TOP w0.102: U32.17 115.1,101.4 115.24,101.54 115.57,101.54 v2(115.62,101.49) ; v2(102.31,99.89) 102.29,99.9 Q325.1 v1(100.38,99.9)
  IN3 w0.127: v2(115.62,101.49) 115.24,101.49 114.73,100.98 113.03,100.98 111.58,99.53 105.15,99.53 104.8,99.89 v2(102.31,99.89)
LAN_ACTLED_YEL#_Q: length 138.5
  TOP w0.102: Q325.6 v2(103.54,100.5)
  IN4 w0.109: v2(83.92,160.95) 85.65,160.95 87.23,162.53 88.62,162.53 90.51,160.64 92.64,160.64 94.39,158.89 94.39,157.17 95.71,155.85 95.71,141.51 98.55,138.67 98.55,137.95 103.61,132.88 103.61,125.73 104.1,125.24 104.1,121.53 103.02,120.45 103.02,113.4 103.14,113.28 103.14,109.09 102.35,108.3 102.35,103.22 103.31,102.27 103.31,100.73 v2(103.54,100.5)
  BOTTOM w0.102: v2(83.92,160.95) 83.92,160.86 82.51,159.45 76.05,159.45 75.59,159.91 69.65,159.91 67.66,157.93 67.66,155.64 63.35,151.32 42.65,151.32 40.11,153.86 40.11,159.96 v1(41.57,161.42) 42.39,162.24 R1171.1
LAN_DISABLE#_R: length 147.9
  TOP w0.102: v2(125.58,94.73) 125.58,91.5 124.31,90.23 v1(122.34,90.23) 119.78,90.23 R555.2 R557.1 119.28,88.58 118.77,89.09 117.5,89.09 R549.2 116.15,90.44 115.21,90.44 115.17,90.49 U31.3
  IN4 w0.109: v2(125.58,94.73) 125.65,94.81 126.31,94.81 135.66,85.46 174.95,85.46 183.18,77.23 197.56,77.23 205.5,69.29 205.5,68.35 206.98,66.87 207.89,66.87 211.31,63.44 218.46,63.44 219.57,64.55 228.29,64.55 229.79,66.05 231.98,66.05 233.44,67.51 235.05,67.51 235.56,68.02 235.56,71.18 235.37,71.37 235.37,71.5 v2(234.92,71.95)
  BOTTOM w0.102: v2(234.92,71.95) 234.67,71.69 234.06,71.69 233.77,71.41 U46.B47
LAN_SMBCLK: length 101.8
  TOP w0.102: U31.28 108.09,92.89 108,92.98 105.03,92.98 104.42,92.37 91.71,92.37 87.42,96.66 64.83,96.66 55.24,87.08 55.24,84.97 55.07,84.8 54.89,84.8 v2(54.71,84.98) ; v2(55.59,66.85) 55.4,66.66 55.12,66.66 RH174.2
  IN3 w0.102: 68.83,65.29 68.85,65.29 68.86,65.28 68.93,65.28 68.95,65.27 69.13,65.27 69.77,64.63 70.14,64.63 v2(70.53,65.02)
  IN3 w0.127: v2(55.59,66.85) 55.73,66.71 57.41,66.71 58.27,65.85 64.77,65.85 65.33,65.29 68.83,65.29
  IN4 w0.109: v2(54.71,84.98) 54.58,84.85 54.28,84.85 53.31,83.87 53.31,72.79 54.1,72 55.37,72 56.43,70.94 56.43,67.14 55.95,66.66 55.78,66.66 v2(55.59,66.85)
  BOTTOM w0.102: v2(70.53,65.02) 70.94,65.43 UH1.U8
LAN_SMBDATA: length 101.6
  TOP w0.102: U31.31 107.97,91.69 107.85,91.81 104.93,91.81 104.6,92.14 91.62,92.14 87.32,96.43 64.92,96.43 55.47,86.98 55.47,84.87 55.17,84.57 54.89,84.57 v2(54.71,84.39) ; RH175.2 55.12,66.43 55.37,66.43 v2(55.59,66.22)
  IN3 w0.102: 68.83,65.04 69.04,65.04 69.67,64.4 70.07,64.4 70.21,64.26 70.21,64.11 70.17,64.07 v2(70.11,64.07)
  IN3 w0.127: 68.83,65.04 65.22,65.04 64.66,65.6 58.16,65.6 57.3,66.46 55.75,66.46 55.59,66.3 v2(55.59,66.22)
  IN4 w0.109: v2(55.59,66.22) 55.59,66.24 55.78,66.43 56.05,66.43 56.67,67.04 56.67,71.04 55.47,72.23 54.2,72.23 53.54,72.89 53.54,83.77 54.38,84.61 54.49,84.61 v2(54.71,84.39)
  BOTTOM w0.102: UH1.R7 70.34,64.31 v2(70.11,64.07)
LAN_TEST_EN: length 2.1
  TOP w0.102: U31.30 107.51,92.09 107.33,92.27 R561.1
LAN_TX0+: length 3.6
  TOP w0.089: L70.1 115.82,97.62 v3(114.24,96.04) 113.9,95.71 113.9,95.41 113.93,95.38 U31.13
LAN_TX0+R: length 4.9
  TOP w0.089: L70.2 115.28,99.51 115.28,99.58 115.1,99.76 112.98,99.76 112.51,100.23 112.51,100.48 112.6,100.57 U32.12
LAN_TX0-: length 3.4
  TOP w0.089: U31.14 113.53,95.38 113.56,95.41 113.56,95.85 114.75,97.04 114.75,97.29 L69.1
LAN_TX0-R: length 5
  TOP w0.089: U32.11 112.1,100.57 112.16,100.51 112.16,100.09 112.84,99.42 114.96,99.42 115.02,99.36 115.02,99.32 114.6,98.9 L69.2
LAN_TX1+: length 3
  TOP w0.089: U31.17 112.33,95.38 112.3,95.41 v3(112.3,96.18) 112.3,96.99 L68.1
LAN_TX1+R: length 3
  TOP w0.089: U32.10 111.6,100.57 111.52,100.49 111.52,100.05 v3(111.68,99.89) 112.19,99.38 112.19,99.28 112.57,98.9 L68.2
LAN_TX1-: length 3
  TOP w0.089: L67.1 111.96,97.12 111.96,95.41 111.93,95.38 U31.18
LAN_TX1-R: length 2.9
  TOP w0.089: U32.9 111.1,100.57 111.18,100.49 111.18,99.91 111.94,99.15 111.94,99.02 111.81,98.9 L67.2
LAN_TX2+: length 4.3
  TOP w0.089: L66.1 109.43,97.07 109.43,96.97 109.53,96.88 110.5,96.88 111.1,96.28 111.1,95.44 111.13,95.41 U31.20
LAN_TX2+R: length 2.8
  TOP w0.089: L66.2 109.86,98.9 109.36,99.4 109.36,99.52 v3(109.74,99.9) 110.02,100.18 110.02,100.52 110.1,100.59 U32.7
LAN_TX2-: length 4.3
  TOP w0.089: L65.1 109.09,97.04 109.09,96.83 109.38,96.53 v3(109.82,96.53) 110.36,96.53 110.76,96.13 110.76,95.44 110.73,95.41 U31.21
LAN_TX2-R: length 2.7
  TOP w0.089: U32.6 109.6,100.59 109.68,100.52 109.68,100.32 109.02,99.67 109.02,99.4 108.52,98.9 L65.2
LAN_TX3+: length 6.1
  TOP w0.089: L64.1 106.44,97.62 106.35,97.52 106.35,97.22 106.75,96.82 106.85,96.82 v3(107.38,96.29) 107.7,95.97 109.62,95.97 109.88,95.72 109.88,95.47 109.93,95.41 U31.23
LAN_TX3+R: length 3.1
  TOP w0.089: L64.2 106.82,99.1 106.82,99.52 106.88,99.58 107.37,99.58 107.94,100.16 107.94,100.44 108.1,100.59 U32.3
LAN_TX3-: length 5.7
  TOP w0.089: L63.1 105.72,97.62 106.01,97.33 106.01,97.08 106.61,96.48 106.71,96.48 107.55,95.63 109.48,95.63 109.53,95.58 U31.24
LAN_TX3-R: length 3.6
  TOP w0.089: U32.2 107.6,100.3 107.22,99.92 v3(107,99.92) 106.64,99.92 106.27,99.56 106.27,99.23 105.95,98.9 L63.2
LAN_WAKE#: length 170.3
  TOP w0.102: R556.1 120.55,87.34 v1(121.74,87.34) 125.5,87.34 125.7,87.54 125.7,89.22 126.01,89.52 v2(126.01,94.32) ; v2(243.99,49.51) 243.53,49.97 243.53,52.62 243.96,53.05 243.96,56.39 240.32,60.03 237.38,60.03 237.1,59.75 225.88,59.75 225.63,60.01 222.16,60.01 216.58,65.58 216.58,65.97 215.54,67.02 214.81,67.02 214.55,67.27 214.55,67.81 v2(214.35,68.01)
  IN4 w0.109: v2(243.99,49.51) 243.84,49.51 243.48,49.87 243.48,50.25 243.03,50.7 239.13,50.7 238.83,50.41 237.9,50.41 236.98,51.32 233.63,51.32 v2(233.15,50.84)
  BOTTOM w0.102: U51.B27 243.55,49.95 v2(243.99,49.51) ; R846.2 233.15,51.32 v2(233.15,50.84) ; v2(214.35,68.01) 213.29,69.08 211.14,69.08 210.34,69.88 210.34,70.76 207.68,73.42 206.81,73.42 203.61,76.62 187.41,76.62 184.31,79.72 181.27,79.72 178.83,82.16 169.3,82.16 166.4,85.06 148.53,85.06 147.36,83.88 137.18,83.88 126.74,94.32 v2(126.01,94.32)
LAN_WAKE#_R: length 5.6
  TOP w0.102: R556.2 118.85,88.13 117.42,88.13 116.99,88.56 R559.1 v1(115.97,89.6) 115.49,90.09 U31.2
LANCLK_REQ#: length 95.4
  TOP w0.102: U31.48 113.93,88.55 114.4,88.09 114.4,86.98 115.34,86.04 123.45,86.04 v1(123.75,86.34) v2(124.18,86.78) ; v2(65,69.81) 64.95,69.76 64.92,69.76 62.74,71.95 60.3,71.95 RH145.1 RH20.1
  IN3 w0.127: v2(124.18,86.78) 122.18,84.77 118.32,84.77 113.34,79.79 105.54,79.79 96.98,71.23 91.4,71.23 89.59,69.43 88.02,69.43 86.89,68.3 86.32,68.3 85.98,67.96 81.41,67.96 80.85,68.52 79.88,68.52 78.97,69.43 75.28,69.43 74.73,68.87 74.73,67.5 74.27,67.04 73.39,67.04 72.95,66.61 72.95,65.67 72.77,65.49 69.45,65.49 69.32,65.62 68.68,65.62 67.3,67 67.3,67.02 65,69.32 v2(65,69.81)
  BOTTOM w0.102: UH1.AF1 66.37,68.97 66.17,69.18 65.64,69.18 v2(65,69.81)
LAT_ON_SW#: length 12.1
  TOP w0.102: v2(243.03,36.34) 243.03,37.2 242.31,37.91 242.31,40.53 241.53,41.31 241.53,42.28 241.02,42.79 v2(241.02,42.91)
  BOTTOM w0.102: U51.B63 241.55,42.38 v2(241.02,42.91) ; v2(243.03,36.34) 243.03,35.7 R870.2 243.51,35.24 v1(243.51,33.41)
LCD_CBL_DET#: length 182.8
  TOP w0.102: v2(99.43,161.5) 99.43,157.87 98.74,157.18 JLVDS1.1 ; v2(74.34,61.23) 74.9,60.67 74.9,58.44 74.65,58.18 74.65,54.44 75.44,53.65 75.44,49.19 76.3,48.32 RH77.2 76.35,47.26 76.81,46.8 76.81,45.89 76.6,45.68 76.6,44.69 76.91,44.39 79.68,44.39 80.36,45.07 80.72,45.07 81.51,45.86 81.51,46.58 83.69,48.76 83.69,50.15 84.4,50.86 v1(84.4,51.64) 84.4,52.69 v2(85.04,53.33)
  IN3 w0.127: v2(117.35,160.62) 109.9,160.62 109.2,161.31 99.62,161.31 v2(99.43,161.5)
  IN4 w0.109: v2(85.04,53.33) 85.88,53.33 86.67,54.13 86.67,57.92 87.45,58.7 87.45,59.44 88.52,60.5 88.52,61.79 92.45,65.72 92.45,68.24 91.14,69.56 91.14,76.19 92.45,77.51 92.45,78.94 91.95,79.45 91.95,83.76 91.03,84.68 91.03,87.46 101.06,97.48 103.76,97.48 105.06,98.78 106.61,98.78 107.83,100 107.83,101.09 108.81,102.08 108.81,103.45 110.29,104.93 110.29,106.71 110.82,107.24 110.82,114.61 112.93,116.72 112.93,133.89 115.05,136.02 115.05,138.59 116.58,140.12 116.58,159.85 v2(117.35,160.62)
  BOTTOM w0.102: UH1.G17 74.6,60.97 v2(74.34,61.23)
LCD_EDID_CLK: length 46.7
  TOP w0.102: v2(87.75,151.35) 87.26,151.85 R1124.2
  IN1 w0.109: v2(87.75,151.35) 87.79,151.32 98.07,151.32 99.04,150.35 107.39,150.35 107.82,150.78 118.01,150.78 118.87,151.64 125.57,151.64 v2(125.98,152.06)
  BOTTOM w0.102: v2(125.98,152.06) 125.96,152.03 125.96,150.99 125.45,150.48 v1(125.45,149.49) 125.45,148.96 125.33,148.84 U23.46 ; U11.6 88.86,150.93 88.54,151.24 87.86,151.24 v2(87.75,151.35)
LCD_EDID_DATA: length 50.3
  IN1 w0.109: v2(92.38,154.29) 92.38,154.12 91.16,152.9 91.16,151.94 91.27,151.83 91.51,151.83 91.62,151.94 91.62,152.59 91.74,152.71 92.11,152.71 92.2,152.8 92.2,153.27 92.31,153.39 92.51,153.39 92.63,153.27 92.63,152.14 92.74,152.03 92.96,152.03 93.07,152.14 93.07,154.16 93.18,154.27 93.4,154.27 93.51,154.16 93.51,152.93 94.16,152.28 94.16,151.92 94.27,151.81 98.27,151.81 99.24,150.84 107.19,150.84 107.62,151.27 117.8,151.27 119.08,152.55 124.32,152.55 v2(124.81,152.06)
  BOTTOM w0.102: R1123.2 92.3,154.37 v2(92.38,154.29) 92.18,154.09 U11.14 ; v2(124.81,152.06) 124.87,152.01 124.87,149.39 125.09,149.16 125.09,148.78 124.93,148.61 U23.45
LCD_ENVDD_SW: length 87.3
  IN4 w0.109: v2(120.39,172.23) 120.47,172.3 121.16,172.3 121.75,171.72 124.81,171.72 125.86,170.68 125.86,167.88 130.78,162.96 130.78,160.85 129.26,159.33 129.26,155.59 128.01,154.34 128.01,151.75 127.9,151.63 126.25,151.63 122.93,148.32 122.93,141.49 v2(123.29,141.14)
  BOTTOM w0.102: v2(123.29,141.14) 123.33,141.17 U23.20 ; U55.1 96.76,161.19 96.29,161.66 R433.1 94.99,162.19 97.05,162.19 97.59,162.73 97.59,165.29 96.95,165.93 95.93,165.93 95.38,166.48 95.38,168.36 95.63,168.62 97.31,168.62 97.41,168.52 101.98,168.52 102.54,169.07 v1(102.54,170.71) 102.54,171.86 103.69,173.01 105.59,173.01 107.14,171.46 109.85,171.46 110.59,172.2 111.84,172.2 113.19,173.55 119.07,173.55 v2(120.39,172.23)
