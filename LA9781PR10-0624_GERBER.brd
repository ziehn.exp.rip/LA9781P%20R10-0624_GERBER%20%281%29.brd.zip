# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.05V_0.8V_PWROK: length 214.8
  TOP w0.102: PR517.1 160.76,174.33 v2(160.96,174.54) ; v2(236.22,57.19) 237.92,58.89 240.87,58.89 243.13,56.63 243.13,53.56 v2(243.1,53.53)
  IN1 w0.109: v2(242.29,79.85) 241.96,79.85 238.52,83.28 230.52,83.28 221.36,92.44 220.31,92.44 215.83,96.92 215.83,101.31 211.32,105.81 211.32,137.54 212.09,138.31 212.09,155.82 206.69,161.23 206.69,173.56 204.72,175.52 162.35,175.52 161.36,174.54 v2(160.96,174.54)
  IN3 w0.127: v2(242.29,79.85) 243.29,79.85 243.64,79.49 245.09,79.49 247.59,76.99 247.84,76.99 249.6,75.23 249.6,65.19 248.21,63.79 248.21,60.62 246.15,58.56 244.43,58.56 242.54,56.68 236.78,56.68 236.27,57.19 v2(236.22,57.19)
  BOTTOM w0.102: v2(243.1,53.53) 243.1,53.58 243.67,54.15 RP7.5 ; v2(236.22,57.19) 236.39,57.02 U50.4 ; v2(160.96,174.54) v1(160.33,174.54)
1.05V_A_PWRGD: length 257.2
  IN2 w0.254: v2(38.86,70.73) 38.86,70.75 44.04,75.93 47.83,75.93 50.49,73.27 50.49,60.67 50.11,60.29 50.11,50.08 50.67,49.52 50.67,47.42 55.3,42.79 57.25,42.79 57.65,42.38 59.36,42.38 62.08,45.1 65.1,45.1 67.78,47.78 78.37,47.78 79.22,46.93 84.63,46.93 85.65,45.91 93.03,45.91 94.35,44.59 103.38,44.59 104.39,43.57 106.22,43.57 108.71,41.09 118.18,41.09 119.97,39.29 123.59,39.29 124.75,38.14 179.32,38.14 181.49,35.97 187.05,35.97 188.07,34.94 193.93,34.94 197.11,38.11 204.7,38.11 205.33,38.75 207.36,38.75 211.1,42.48 223.82,42.48 232.71,51.37 236.55,51.37 237.56,50.36 238.48,50.36 238.86,50.74 243.35,50.74 v2(243.99,50.1)
  BOTTOM w0.254: v2(243.99,50.1) 244.05,50.16 U51.B28 ; PU300.1 38.09,67.2 37.57,67.73 PR300.1 37.62,68.19 38.1,68.67 38.1,69.76 v1(38.58,70.24) 38.86,70.52 v2(38.86,70.73)
1.5V_RUN_PWRGD: length 175.1
  IN3 w0.254: v2(97.36,38.39) 98.83,36.92 102.54,36.92 103.03,37.41 117.3,37.41 118.86,35.85 122.1,35.85 123.1,36.86 143.14,36.86 146.28,33.72 155.19,33.72 156.06,32.86 167.49,32.86 168.85,34.21 178.66,34.21 179.7,35.26 189.96,35.26 192.63,37.92 194.16,37.92 194.67,38.43 204.59,38.43 205.15,38.99 207.52,38.99 217.52,48.98 226.52,48.98 228.34,50.81 228.34,52.06 233.22,56.93 v2(233.22,57.44)
  BOTTOM w0.254: PU400.4 104.3,29.27 103.83,28.8 PR400.2 101.71,29.43 101.1,29.43 100.8,29.12 100.8,28.52 100.44,28.17 98.39,28.17 97.36,29.2 v2(97.36,38.39) ; v2(233.22,57.44) 233.22,57.95 v1(233.43,58.16) 233.75,58.48 237.23,58.48 237.85,57.86 U50.1
1.5VSP_FB: length 5.9
  BOTTOM w0.102: PR405.1 100.66,32.97 v1(100.66,34.35)
  BOTTOM w0.254: PU400.6 103.64,32.41 PC402.2 PR402.2 PR405.1
1.5VSP_LX:
  vias: v1(104.6,28.18)
1.5VSP_VIN:
  vias: v1(108.61,34.13)
1.35V_B+: length 14
  IN2 w0.254: v3(155.12,22.21) 153.77,23.56 146.91,23.56 v3(144.25,26.23)
  BOTTOM w0.102: v3(144.25,26.23) 144.52,26.23 v1(144.74,26.44)
  BOTTOM w0.254: PR205.1 154.69,22.21 v3(155.12,22.21)
1.35V_FB: length 17.2
  TOP w0.254: v3(162.26,26.46) 161.64,25.85 158.09,25.85 157.66,26.27 v3(157.66,26.54) 157.66,26.56 157.43,26.78 153.86,26.78 v2(153.54,26.46)
  BOTTOM w0.254: v2(153.54,26.46) 153.54,25.61 PR207.2 153.52,25.59 PR204.2 ; PU200.6 151.82,23.26 152.58,24.02 v1(152.58,24.56) PR204.2 ; PR204.2 152.58,25.59 PC211.1 ; v3(157.66,26.54) 157.66,26.51 PR218.1 ; v3(162.26,26.46) 162.26,25.77 PR211.2
1.35V_SUS_PWRGD: length 206
  TOP w0.102: v2(154.58,20.05) 155.29,20.05 156.06,20.82 156.06,21.76 158.93,24.63 166.7,24.63 172.67,30.59 175.69,30.59 v2(175.9,30.38) ; v2(210.44,67.5) 210.44,63.94 218.38,55.99 224.15,55.99 233.8,46.34 237.34,46.34 237.48,46.2 v2(239.11,46.2) ; RC46.1 200.91,108.42 200.91,109.31 202.16,110.55 203.43,110.55 ; 203.43,110.55 202.92,111.06 202.92,111.62 v1(203.73,112.43) 203.73,112.76 204.6,113.63 206.88,113.63 208.08,112.43 208.46,112.43 208.71,112.18 v2(208.71,111.77) ; 203.43,110.55 RC103.2
  IN1 w0.109: v2(210.44,67.5) 210.54,67.4 210.54,70.4 216.77,76.63 216.77,83 209.32,90.44 209.32,95.61 207.26,97.67 207.26,101.63 207.8,102.17 207.8,110.86 v2(208.71,111.77)
  IN3 w0.127: v2(175.9,30.38) 177.81,30.38 180.24,32.8 193.81,32.8 197.58,36.58 209.01,36.58 209.25,36.82 218.54,36.82 224.54,42.81 229.33,42.81 230.6,44.08 234.31,44.08 235.43,45.2 238.13,45.2 239.11,46.18 v2(239.11,46.2)
  BOTTOM w0.102: U51.B9 239.09,46.17 239.11,46.18 v2(239.11,46.2) ; v2(154.58,20.05) 154.51,20.13 154.08,20.13 153.55,20.66 PR209.2
  BOTTOM w0.203: PU200.10 151.86,21.66 152.25,21.27
  BOTTOM w0.254: 152.25,21.27 152.63,20.89 PR209.2
3.3V_RUN_GFX_ON: length 521.3
  TOP w0.102: C362.1 108.46,174.56 108.05,174.97 v2(108.05,175.15) ; C362.1 108.75,173.91 108.82,173.85 U34.3 ; C362.1 R301.1 ; v2(37.95,128.82) 37.98,128.85 U35.3 ; v2(20.02,141.02) 18.34,139.33 18.34,132.55 18.02,132.23 15.59,132.23 15.33,131.96 Q87.2 ; QH3.2 57.52,71.46 55,73.98 55,74.39 52.83,76.56 52.83,79.74 52.63,79.94 52.63,82.33 52.22,82.74 52.22,84.75 52.5,85.03 52.5,89.5 v1(54.69,91.69) 55.15,92.15 55.15,93.68 v2(55.12,93.71) 53.75,93.71 48.31,88.28 40.87,88.28 39.67,87.08 39.01,87.08 38.71,87.39 37.49,87.39 36.78,86.68 36.78,82 v2(36.42,81.65)
  IN2 w0.127: v2(36.42,81.65) 36.42,80.96 38.33,79.06 41.88,79.06 44.63,76.31 48,76.31 50.82,73.5 50.82,60.54 50.42,60.14 50.42,50.19 50.97,49.64 50.97,47.54 55.42,43.08 57.37,43.08 57.78,42.67 59.19,42.67 62.14,45.62 64.25,45.62 66.71,48.07 78.49,48.07 79.34,47.22 84.75,47.22 85.77,46.2 93.15,46.2 94.44,44.92 103.55,44.92 104.6,43.88 107.42,43.88 109.92,41.38 118.3,41.38 120.09,39.59 123.71,39.59 124.87,38.43 177.02,38.43 177.57,38.98 184.5,38.98 185.6,37.88 186.87,37.88 189.48,35.27 193.85,35.27 196.99,38.41 204.57,38.41 205.32,39.15 207.24,39.15 211.66,43.57 211.66,46.87 226.78,61.99 227.51,61.99 229.28,63.77 229.28,66.71 231.32,68.75 232.33,68.75 232.54,68.95 232.54,70.52 231.62,71.44 231.62,71.91 231.88,72.16 233.27,72.16 233.89,72.78 233.89,73.79 234.71,74.61 236.37,74.61 237.55,75.79 237.55,75.8 237.73,75.98 237.73,76.41 238.6,77.28 v2(238.66,77.28)
  IN3 w0.127: v2(55.12,93.71) 55.12,93.82 53.01,95.93 53.01,96.99 48.11,101.89 48.11,105.63 42.72,111.01 42.29,111.01 40.54,112.76 40.54,117.18 38.45,119.27 38.45,124.12 39.32,124.98 39.32,127.45 v2(37.95,128.82) 37.72,128.82 37.13,128.23 34.57,128.23 32.64,130.16 32.64,130.98 22.59,141.02 v2(20.02,141.02)
  IN4 w0.109: v2(108.05,175.15) 107.52,175.15 105.71,173.34 105.71,172.02 103.63,169.94 97.62,169.94 97.27,170.29 91.52,170.29 90.9,170.9 79.6,170.9 75.47,166.77 75.47,156.98 71.5,153.01 71.5,147.23 68.58,144.31 38.99,144.31 38.24,143.56 22.57,143.56 v2(20.02,141.02)
  BOTTOM w0.102: v2(238.66,77.28) 238.61,77.33 237.84,77.33 237.74,77.23 237.74,75.98 237.48,75.71 U46.A55
3V_5V_EN: length 11.4
  TOP w0.508: v2(34.49,39.23) v1(34.49,37.87) 34.49,36.08 v2(34.92,35.65)
  IN3 w0.508: v2(34.49,39.23) 34.29,39.43 31,39.43 v2(29.87,40.56)
  BOTTOM w0.203: PU101.20 35.13,35.86 v2(34.92,35.65) ; v2(34.49,39.23) 34.49,39.72 34.68,39.92 35.05,39.92 35.13,39.84 PU101.6
3V_PWROK#: length 2.5
  BOTTOM w0.254: R391.2 30.69,93.54 31.31,92.92 31.88,92.92 32.02,92.78 U29.12
+0.9V_LAN: length 17
  TOP w0.203: U31.22 v3(110.33,95.77) ; U31.11 115.44,93.69 v3(115.67,93.92) ; U31.47 113.53,88.43 113.97,88 v2(113.97,87.95) ; U31.43 111.93,88.38 111.78,88.23 111.78,87.77 112.19,87.36 v3(112.52,87.36) ; U31.46 113.13,88.28 113.38,88.02 v2(113.38,87.9) ; C466.1 116.99,91.91 116.42,92.49 U31.8 ; U31.40 v3(110.73,87.95) ; U31.16 112.73,95.68 112.75,95.7 v3(112.75,95.76) ; v3(109.53,87.97) U31.37
  TOP w0.254: v3(116.23,91.91) 116.64,91.5 C466.1
  BOTTOM w0.102: v3(115.67,93.92) v4(116.34,93.92)
  BOTTOM w0.457: v2(113.97,87.95) 113.99,87.97 C463.1
  BOTTOM w0.508: C467.1 110.34,95.77 v3(110.33,95.77) ; C463.1 C469.1 ; C468.1 v3(112.75,95.76)
+0.675V_DDR_VTT: length 27.6
  TOP w0.305: JDIMM3.204 125.94,48.64 125.22,47.92
  TOP w0.356: JDIMM3.203 126.24,57.12 125.66,56.54 v2(125.21,56.54) ; JDIMM3.204 125.94,51.54 v2(125.02,52.46)
  TOP w0.508: v2(125.32,74.41) CD18.1 CD17.1 ; CD61.1 CD62.1 127.93,45.86 125.27,45.86 124.81,46.32 124.81,47.51 125.22,47.92
  BOTTOM w0.102: v4(117.59,68.63) 117.85,68.9 v3(119.3,68.9)
  BOTTOM w0.305: 125.94,71.42 v2(125.32,70.8)
  BOTTOM w0.356: JDIMM2.204 125.94,71.42 ; v2(125.02,52.46) 126.24,51.24 JDIMM4.203 ; v2(125.33,65.62) 125.49,65.62 126.24,64.87 JDIMM2.203
  BOTTOM w0.508: CD20.1 CD19.1 v2(119.3,67.12) ; CD38.1 v3(119.3,68.9) ; CD37.1 v3(119.99,71.06)
  vias: v3(119.84,51.3) v3(119.77,50.53) v3(120.34,50.86) v3(120.79,50.37) v3(121.59,68.36) v3(121.59,67.35)
+0.675V_P: length 2
  BOTTOM w0.102: v1(145.67,28.19) 146.05,28.19 146.63,27.61 PC208.1
+1.05V_M: length 14.3
  TOP w0.254: CH29.1 75.82,63.57 75.82,63.26 75.54,62.98 v2(75.33,62.98)
  TOP w0.508: v3(89.43,68.26) 87.96,68.26 87.32,67.63 RH239.1 ; RH234.1 74.98,66.64 75.33,66.28 v2(75.36,66.28) ; CH30.1 74.85,65.82 75.06,65.62 v2(75.36,65.62)
  BOTTOM w0.254: UH1.AA18 UH1.Y18 75.03,66.61 v2(75.36,66.28) ; UH1.V20 75.43,66.28 v2(75.36,66.28) ; v2(75.33,62.98) 75.25,62.98 75.04,62.76 UH1.L17 ; UH1.U18 75.03,65.29 v2(75.36,65.62) 75.69,65.29 75.7,65.29 ; v2(75.36,66.28) 75.03,65.95 UH1.V18 ; v2(75.36,66.28) 75.69,66.61 UH1.Y20 UH1.Y22 ; 75.7,65.29 v2(75.36,64.94) ; 75.7,65.29 UH1.U20
  BOTTOM w0.305: UH1.V22 76.66,65.95 v2(76.99,65.62) ; UH1.V24 77.32,65.95 v2(76.99,65.62) ; v2(76.99,65.62) 77.06,65.62 77.39,65.29 UH1.U24 ; v2(76.99,65.62) 76.93,65.62 76.6,65.29 UH1.U22 ; UH1.R18 74.98,64.63 75.29,64.94 v2(75.36,64.94)
  vias: v3(55.6,55.26) v3(55.57,54.62) v3(55.57,53.99) v3(84.58,80.73) v3(85.39,81.57) v3(89.38,67.02) v4(54.53,55.63)
+1.05V_MP: length 25.9
  IN1 w0.254: v3(45.13,49.65) 47.7,52.22 47.7,59.65 43.03,64.33 43.03,65.42 41.31,67.13 40.45,67.13 39.27,68.31 39.27,69.71 v2(39.22,69.76)
  BOTTOM w0.254: PR306.1 v2(39.22,69.76)
  vias: v1(56.54,49.48)
+1.05V_RUN: length 582.8
  TOP w0.254: v2(82.39,64.93) 82.39,65.01 82.85,65.47 85.7,65.47 CH47.1 ; v3(60.6,80) 60.6,81.65 61.57,82.61 61.57,85.41 v3(60.43,86.55)
  TOP w0.381: CH36.1 82.83,73.02 83.07,72.78 83.07,72.48 83.08,72.49 83.12,72.49 83.11,72.48 v2(83.11,72.46)
  TOP w0.508: v3(201.65,148.91) 202.33,148.22 RC126.1 ; v3(81.08,46.04) 81.08,46.83 82.98,48.73 82.98,52.13 82.27,52.85 80.16,52.85 RH243.1 78.79,53.66 v3(78.54,53.4) ; v2(76.99,68.92) 77.37,69.3 CH37.1 ; CH34.1 74.96,69.29 75.33,68.92 v2(75.36,68.92) ; RC17.1 207.49,146.38 207.13,146.02 206.31,146.02 v3(206.02,146.31) ; v2(76.99,68.26) 76.16,68.26 CH25.1 ; v3(157.78,118.35) 158.35,118.92 158.35,125.21 158.02,125.54 RC105.2 157.39,124.88 156.65,124.14 v3(155.42,124.14) ; v3(204.32,144.84) 204.32,144.4 RC4.2 RC99.2 ; v3(88.77,70.78) 89.6,69.95 RH244.1 ; CH35.1 79.37,65.6 v2(80.26,65.6)
  IN1 w0.508: v3(205.64,67.55) 205.94,67.55 207.29,68.9 207.29,70.73 209.29,72.73 209.29,75.38 210.08,76.16 210.08,78.85 211.91,80.68 211.91,84.9 207.92,88.89 207.92,93.82 207.47,94.27 207.47,96.89 206.78,97.57 206.78,101.92 207.36,102.5 207.36,111.01 207.53,111.18 207.53,112.34 208.08,112.89 v3(208.28,112.89)
  IN2 w0.254: v3(46.46,84.65) 46.46,85.79 48.11,87.44 59.54,87.44 v3(60.43,86.55)
  IN2 w0.508: v3(95.55,76.82) 95.83,77.1 97.89,77.1 99.21,75.78 99.21,74.08 101.98,71.31 102.97,71.31 103.94,70.35 112.57,70.35 v3(114.37,72.15) ; v3(208.28,112.89) 208.28,115.43 204.54,119.16 204.54,125.11 205.71,126.28 v3(205.74,126.28) ; v3(157.78,118.35) 157.4,118.73 154.56,118.73 139.27,103.44 139.27,99.45 131.06,91.25 v3(128.73,91.25) 128.73,88.25 130.45,86.53 130.45,82.79 127.63,79.97 125.8,79.97 122.5,76.67 122.5,76.14 118.01,71.64 117.17,71.64 v3(116.76,71.23) ; v3(88.77,70.78) 90.49,69.06 94.74,69.06 v3(95.17,69.5) ; v3(81.08,46.04) 81.66,46.04 82.68,45.02 92.74,45.02 94.11,43.65 102.89,43.65 103.96,42.58 105.94,42.58 108.28,40.25 117.83,40.25 119.62,38.46 123.24,38.46 124.4,37.3 166.93,37.3 167.71,36.51 175.61,36.51 177,35.13 186.7,35.13 187.73,34.1 194.61,34.1 197.78,37.28 205.04,37.28 205.68,37.91 207.92,37.91 209.32,39.31 226.3,39.31 227.32,38.29 229.46,38.29 230.22,37.53 233.65,37.53 235.53,35.65 235.53,35.04 237.56,33.01 244.83,33.01 246.23,34.4 249.43,34.4 250.77,35.75 250.77,37.3 v3(252.65,39.18)
  IN3 w0.508: v3(198.73,148.91) 199.52,148.12 200.86,148.12 v3(201.65,148.91) 203.38,147.18 205.14,147.18 v3(206.02,146.31) 206.69,145.63 210.29,145.63 212.08,143.84 212.08,139.34 205.23,132.5 205.23,131.18 205.79,130.62 205,129.83 205,126.73 205.46,126.28 v3(205.74,126.28)
  IN4 w0.508: v3(204.32,144.84) 205.21,144.84 206.02,145.66 v3(206.02,146.31) ; v3(114.37,72.15) 115.29,71.23 v3(116.76,71.23) ; v3(252.65,39.18) 253.01,39.18 254.28,40.45 254.28,41.93 252.88,43.32 252.88,43.37 252.83,43.42 v3(252.83,43.96) ; v3(128.73,91.25) 135.03,84.95 174.88,84.95 183.01,76.82 192.66,76.82 200.56,68.92 204.27,68.92 v3(205.64,67.55) ; v3(95.55,76.82) 93.84,76.82 93.26,76.24 93.26,71.38 95.14,69.5 v3(95.17,69.5)
  BOTTOM w0.254: JXDP2.40 47.7,84.45 v3(47.55,84.6) ; v2(78.62,68.28) 78.67,68.28 UH1.AD28 ; v3(60.6,80) 61.03,79.57 RH206.1 ; UH1.U35 81.77,65.14 v2(81.77,64.94) ; UH1.AK20 75.43,70.9 v2(75.36,70.9) 75.03,70.57 UH1.AK18 ; UH1.AK22 UH1.AM22 76.58,71.6 v3(76.36,71.82) 76.69,72.15 UH1.AP22 UH1.AR22 UH1.AT22 ; UH1.AN34 UH1.AN35 82.12,72.28 82.31,72.47 83.1,72.47 83.11,72.48 v2(83.11,72.46) ; UH1.AM20 75.77,71.46 v2(75.33,71.9) 74.95,71.51 UH1.AM18
  BOTTOM w0.305: v2(82.39,64.93) 82.39,65.1 82.71,65.42 UH1.U36
  BOTTOM w0.457: v3(205.74,126.28) 205.26,125.79 RC29.1
  BOTTOM w0.508: R1179.1 252.4,44.13 252.5,44.03 252.53,44.03 252.55,44.01 252.78,44.01 v3(252.83,43.96) ; v3(95.55,76.82) 95.19,76.45 CH38.1 RH241.1 ; RC29.1 RC32.1 ; RC69.1 v3(155.42,124.14) ; RC35.1 v3(198.73,148.91) ; RC27.1 v3(201.65,148.91) ; R866.2 v3(252.65,39.18)
  vias: v2(75.36,68.26) v3(45.82,74.46) v3(46.07,73.72) v3(46.07,63.82) v3(46.18,64.58) v3(46.28,65.27) v3(46.53,74.44) v3(46.68,64.09) v3(46.71,63.44) v3(46.84,73.72) v3(46.79,64.88) v3(46.91,62.76) v3(47.04,84.98) v3(47.29,64.45) v3(47.29,63.8) v3(47.39,63.17) v3(47.35,62.29) v4(46.67,61.23)
+1.5V_RUN: length 205.2
  TOP w0.508: RH192.1 80.36,81.73 81.38,82.74 v3(81.66,82.74) ; v3(91.86,74.8) 91.85,74.81 86.23,74.81 v2(85.9,75.15) 86.2,75.44 CH26.1 ; LH1.1 90.93,62.17 91.31,62.55 92.63,62.55 93.5,61.68 v3(93.5,61.66) ; RH163.2 90.8,73.11 v3(92,71.92)
  TOP w1.016: 47.85,93.79 48.61,94.55 50.65,94.55 53.69,97.6 80.24,97.6
  IN1 w1.016: 25.12,129.35 25.25,129.48 25.25,132.02 27.58,134.35 27.58,144.41 26.52,145.48
  IN2 w1.016: 24.51,83.4 26.06,84.95 26.06,86.2 27.1,87.24 27.1,89.55 27.91,90.36 36.8,90.36 37.06,90.62 37.95,90.62 40.61,93.28 44.93,93.28 46.07,92.14
  IN3 w0.508: v3(91.49,81.06) 91.44,81.06 89.29,78.92 89.29,77.58 87.27,75.56 86.31,75.56 v2(85.9,75.15)
  IN4 w1.016: 80.87,99 80.87,100.85 77.61,104.12 77.61,109.81 75.94,111.47 74.8,111.47 73.51,112.76 70.51,112.76 69.77,112.03 64.16,112.03 63.37,111.24 48.97,111.24 46.23,113.98 46.23,127.04 42.26,131 35.84,131 31.9,127.06 25.5,127.06
  BOTTOM w0.102: v4(96.8,61.32) 96.57,61.54 v3(96.57,62.19)
  BOTTOM w0.254: v2(72.54,71.49) 72.54,71.64 72.21,71.97 UH1.AN11 ; v2(85.9,75.15) 85.8,75.24 UH1.BB44 ; UH1.AK28 78.99,70.57 v2(78.61,70.96) 78.22,70.57 UH1.AK26 ; v2(76.9,77.64) 76.72,77.45 UH1.BE22 ; v2(81.18,69.56) 81.18,69.38 UH1.AF34 ; v2(85.29,75.18) 85.24,75.14 85.24,74.97 UH1.AW40
  BOTTOM w0.508: v3(73.8,83.28) 74.89,84.37 CH52.1 ; RH99.1 RH96.1 v3(91.49,81.06) ; RH165.2 91.42,74.36 v3(91.86,74.8) ; v3(81.66,82.74) 81.66,82.46 RH188.1
  vias: v3(23.47,82.92) v3(23.87,82.41) v3(24.87,128.33) v3(24.87,127.7) v3(47.85,92.77) v3(47.85,92.14) v3(79.86,88.96) v3(80.36,89.47) v3(80.49,88.84) v3(81.13,89.09) v3(81.15,97.3) v3(81.84,97.32) v3(93.14,50.91) v3(93.78,50.91) v3(96.57,62.88)
+1.05V_RUN_CHG: length 2.3
  TOP w0.102: v1(47.97,76.09) R925.2
  TOP w0.508: R925.2 Q70.1
+1.05V_RUN_ENABLE: length 30.4
  TOP w0.508: R930.2 v1(41.96,75.17) R1611.1 C773.1 43.79,74.26 v3(43.81,74.23) ; R930.2 40.99,74.77 41.44,74.32 Q304.3 ; R930.2 40.82,74.99 39.78,74.99 R933.2
  IN4 w0.508: v3(43.81,74.23) 44.04,74.23 45.72,72.55 47.25,72.55 48.72,71.08 50.29,71.08 51.31,70.07 52.55,70.07 53.01,69.61 53.01,59.16 v3(53.18,58.99)
  BOTTOM w0.508: v3(53.18,58.99) 52.42,59.75 Q63.4 ; v3(53.18,58.99) 53.19,58.99 53.19,58.99 v3(53.18,58.99)
+1.05V_RUN_VCC: length 2.8
  BOTTOM w0.102: v1(93.1,79.05) 93.45,78.7 RH241.2
  BOTTOM w0.508: LH2.1 93.4,77.8 RH241.2
+1.5V_RUNP: length 17
  IN3 w0.254: v3(105.48,24.36) 105.48,25.86 108.84,29.21 108.84,29.78 106.37,32.25 104.25,32.25 103.76,32.74 v2(103.76,33.24)
  BOTTOM w0.102: v2(103.76,33.24) v1(103.76,33.9)
  BOTTOM w0.254: PR402.1 PC402.1 102.63,33.33 102.72,33.24 v2(103.76,33.24)
+1.05VSP_B+:
  vias: v1(38.31,55.09)
+1.35V_MEM: length 242.3
  TOP w0.254: JDIMM3.106 155.34,49 154.89,48.55 154.89,48.17 v2(154.79,48.07)
  TOP w0.305: v2(152.03,62.59) 151.74,62.88 JDIMM1.118
  TOP w0.356: 152.04,59.71 JDIMM3.117 ; v2(152.17,68.33) 152.65,68.33 153.54,67.44 JDIMM1.112 153.54,62.7 ; JDIMM3.94 158.94,48.25 v2(159.05,48.14) ; JDIMM1.81 162.84,73.78 ; JDIMM1.93 159.24,73.85 ; JDIMM3.99 157.44,59.37 ; 164.64,73.78 JDIMM1.75 164.64,71.17 165.98,69.83 165.98,68.93 v2(166.89,68.02) ; JDIMM3.118 151.74,48.24 v2(151.84,48.14) ; v2(150.53,68.63) 150.28,68.63 149.79,69.11 149.79,70.87 150.24,71.31 JDIMM1.123 ; JDIMM1.82 162.54,62.68 ; v2(156.6,70.69) 156.97,70.69 157.44,71.16 JDIMM1.99 ; JDIMM1.124 149.94,65.75 150.29,66.1 150.52,66.1 v2(150.53,66.09) ; JDIMM3.112 153.54,48.27 v2(153.67,48.14) ; v2(160.96,67) 160.82,67 160.37,66.56 160.37,66.21 160.74,65.85 JDIMM1.88 160.74,62.69 ; v2(150.09,48.14) 149.94,48.29 JDIMM3.124 ; JDIMM1.87 161.04,73.75 ; JDIMM1.117 152.04,74.53 150.64,75.92 v2(149.97,75.92) ; JDIMM3.100 157.14,48.74 157.66,48.22 ; 155.64,59.25 JDIMM3.105 ; 159.24,59.4 JDIMM3.93 ; JDIMM3.123 150.24,59.51 ; v2(156.6,68.4) 156.07,68.94 156.07,70.92 155.64,71.35 JDIMM1.105 ; v2(162.69,48.14) 162.54,48.28 JDIMM3.82 ; 158.94,62.15 JDIMM1.94 ; v2(152.17,69.51) 152.4,69.51 152.69,69.22 153.22,69.22 153.84,69.83 JDIMM1.111 ; JDIMM3.87 161.04,59.34 ; 162.84,59.72 JDIMM3.81 ; JDIMM3.76 164.34,48.44 v2(164.64,48.14) ; v2(160.88,48.14) 160.74,48.28 JDIMM3.88 ; JDIMM1.106 155.34,62.95 155.66,62.62 v2(156.38,62.62) 156.92,62.62 157.14,62.84 JDIMM1.100 ; JDIMM3.75 164.64,59.3 ; JDIMM3.111 153.84,59.32 ; JDIMM1.76 164.34,62.77
  TOP w0.381: v2(176.06,106.31) 176.53,105.84 JCPU1.T2 ; v2(183.06,105.33) 182.59,105.8 JCPU1.AB2 ; JCPU1.AB5 v2(183.06,109.31) ; JCPU1.AE8 v2(186.06,112.31) ; v2(179.06,106.31) 179.53,105.84 JCPU1.W2 ; v2(186.08,108.38) 185.63,108.84 JCPU1.AE5 ; JCPU1.T8 v2(176.06,111.31) ; JCPU1.AE2 v2(186.06,106.31) ; JCPU1.W5 179.53,108.84 v2(179.06,109.31) ; JCPU1.N8 v2(173.06,111.31) ; JCPU1.AB8 v2(183.06,112.31) ; JCPU1.W8 179.53,111.84 v2(179.06,112.31) ; v2(176.06,108.31) JCPU1.T5
  TOP w0.508: CD11.1 v2(150.34,81.32) ; v2(197.15,107.32) 197.21,107.38 200.76,107.38 201.26,106.87 RC16.1 ; RD5.1 v3(208.2,94.73) ; RD44.1 v3(171.25,43.75)
  IN4 w0.254: v2(186.06,106.31) 186.57,106.82 196.76,106.82 197.15,107.22 v2(197.15,107.32) 196.67,107.8 186.67,107.8 v2(186.08,108.38)
  IN4 w0.508: v3(165.68,43.73) 165.68,44.16 165.94,44.41 170.59,44.41 v3(171.25,43.75)
  BOTTOM w0.254: v2(149.97,75.92) 150.29,75.6 151.48,75.6 152.07,75.01 152.07,73.55 151.74,73.23 JDIMM2.118 ; v2(155.48,74.64) 154.3,74.64 153.54,73.87 JDIMM2.112
  BOTTOM w0.305: 153.84,62.79 JDIMM2.111 ; v2(156.38,62.62) 156.4,62.61 ; JDIMM2.75 164.64,62.75
  BOTTOM w0.356: 157.44,62.66 JDIMM2.99 157.44,65.41 157.8,65.77 157.8,67.79 158.21,68.2 v2(158.91,68.2) ; 150.21,59.37 149.94,59.1 JDIMM4.124 ; JDIMM4.105 155.64,50.78 156.02,51.16 157.13,51.16 157.44,50.85 JDIMM4.99 157.44,48.72 157.89,48.27 158.92,48.27 v2(159.05,48.14) 159.24,48.33 JDIMM4.93 ; v2(151.84,48.14) 152.04,48.34 JDIMM4.117 ; v2(156.6,66.12) 156.28,66.12 155.64,65.47 JDIMM2.105 155.64,62.77 ; JDIMM4.106 155.34,59.33 ; v2(160.88,48.14) 161.04,48.3 JDIMM4.87 ; JDIMM4.123 150.24,48.29 v2(150.09,48.14) ; JDIMM2.124 149.94,68.97 150.28,68.63 v2(150.53,68.63) ; v2(162.69,48.14) 162.84,48.29 JDIMM4.81 ; v2(150.53,66.09) 150.2,66.09 149.95,65.84 149.95,65.28 150.24,64.99 JDIMM2.123 150.24,62.57 ; JDIMM4.118 151.74,59.88 ; 158.94,59.56 JDIMM4.94 ; v2(153.85,59.98) 153.54,59.68 JDIMM4.112 ; JDIMM2.117 152.04,62.6 v2(152.03,62.59) ; 162.54,73.72 JDIMM2.82 162.54,71.33 163.48,70.39 163.48,69.06 163.8,68.74 164.34,68.74 164.55,68.53 v2(165.03,68.53) ; 160.74,59.28 JDIMM4.88 ; 164.34,73.57 JDIMM2.76 164.34,71.18 165.98,69.54 v2(166.89,69.54) ; JDIMM4.111 153.84,48.31 v2(153.67,48.14) ; JDIMM2.100 157.14,71.22 v2(156.6,70.69) ; v2(156.6,68.4) 156.31,68.4 155.81,68.9 155.81,70.33 155.34,70.81 JDIMM2.106 ; v2(160.96,67) 161.12,67 161.47,66.66 161.47,66.13 161.27,65.93 161.27,65.4 161.04,65.17 JDIMM2.87 161.04,62.71 ; JDIMM4.76 164.34,59.24 v2(164.16,59.42) ; v2(162.23,59.45) 162.54,59.14 JDIMM4.82 ; 158.94,73.67 JDIMM2.94 ; JDIMM2.93 159.24,62.68 ; JDIMM4.75 v2(164.64,48.14) ; JDIMM4.100 157.14,59.43 ; JDIMM2.81 162.84,62.73 ; 160.74,73.89 JDIMM2.88
  BOTTOM w0.508: v2(197.15,107.32) 202.84,101.63 202.84,99.15 206.4,95.59 207.29,95.59 208.15,94.73 v3(208.2,94.73)
  vias: v2(148.76,55.46) v2(148.76,54.19) v2(149.97,74.4) v2(150.13,55.38) v2(150.13,54.11) v2(150.13,52.84) v2(150.44,77.9) v2(150.53,69.9) v2(150.53,67.36) v2(150.88,60.56) v2(150.9,59.92) v2(151.57,55.24) v2(151.57,53.97) v2(151.57,52.5) v2(153.52,77.92) v2(153.74,55.44) v2(153.74,54.17) v2(153.73,52.9) v2(154.08,81.32) v2(154.62,69.6) v2(154.69,68.19) v2(154.66,66.38) v2(154.79,86.71) v2(155.19,87.14) v2(155.27,80.51) v2(155.48,76.59) v2(155.6,87.56) v2(156.03,87.98) v2(156.04,56.05) v2(156.04,53.76) v2(156.39,61.53) v2(156.37,60.41) v2(156.37,59.76) v2(156.6,76.76) v2(158.08,55.29) v2(158.08,54.02) v2(158.08,52.75) v2(158.46,81.13) v2(158.57,77.94) v2(158.91,69.47) v2(158.91,66.93) v2(159.41,53.4) v2(160.74,55.28) v2(160.74,54.01) v2(160.74,52.73) v2(160.96,69.54) v2(160.96,68.27) v2(161.09,77.74) v2(162.25,60.04) v2(162.44,79.31) v2(162.62,69.54) v2(162.62,68.27) v2(162.62,67) v2(162.78,55.26) v2(162.78,53.99) v2(162.78,52.72) v2(164.16,60.06) v2(164.34,55.37) v2(164.34,54.09) v2(164.34,52.82) v2(165.03,67.07) v2(166.39,55.12) v2(166.39,53.85) v2(166.37,52.52) v2(166.89,66.5) v2(166.89,64.97) v2(167.92,55.46) v2(168.84,118.05) v2(170.74,118.05) v2(172.84,118.05) v2(174.87,118.05) v2(174.88,90.23) v2(174.97,86.73) v2(175.31,90.64) v2(175.37,87.16) v2(175.72,91.07) v2(175.78,87.57) v2(176.13,91.48) v2(176.22,88) v2(176.55,91.92) v2(176.9,118.05) v2(176.98,92.32) v2(178.55,118.05) v2(180.39,118.05) v2(180.9,83.71) v2(182.24,118.05) v2(184.01,118.05) v2(185.79,118.05) v2(187.57,117.98) v3(121.31,24.4) v3(121.99,24.4) v3(122.35,24.98) v3(122.71,24.4) v3(123.01,24.98) v3(123.34,24.4) v3(123.65,24.96) v3(124,24.37) v3(124.28,24.98) v3(124.64,24.35) v3(124.92,24.96) v3(125.27,24.37) v3(125.55,24.96) v3(125.91,24.37) v3(126.24,24.93) v3(126.62,25.51) v3(126.57,24.37) v3(126.92,24.93) v3(127.28,25.49) v3(127.28,24.37) v3(127.71,24.93) v3(128.01,24.37) v3(150.95,48.11) v3(152.78,48.11) v3(153.9,39.56) v3(154.53,39.56) v3(155.17,39.56) v3(155.8,39.56) v3(156.44,39.56) v3(157.07,39.56) v3(157.71,39.56) v3(158.34,39.56) v3(158.98,39.56) v3(159.61,39.56) v3(159.84,48.11) v3(160.25,39.56) v3(160.88,39.56) v3(161.52,39.56) v3(161.87,48.1) v3(162.15,39.56) v3(162.79,39.56) v3(163.42,39.56) v3(163.63,48.11) v3(164.18,39.56) v3(164.82,39.56) v4(124.83,26.38)
+1.35V_MEN_P: length 77.2
  IN3 w0.254: v3(150.97,28) 149.72,29.25 144.45,29.25 142.31,31.38 128.98,31.38 126.36,28.77 120.37,28.77 118.97,27.37 v3(118.97,25.85) ; v3(151.36,24.19) 147.42,28.13 138.53,28.13 135.79,30.87 129.36,30.87 126.62,28.13 120.88,28.13 119.73,26.99 v3(119.73,25.85)
  BOTTOM w0.203: PU200.5 151.18,24.01 v3(151.36,24.19)
  BOTTOM w0.254: v3(150.97,28) 151.15,28 151.61,27.54 PC214.1
  BOTTOM w0.508: PR204.1 151.66,26.56 PC211.2 151.67,27.54 PC214.1
  vias: v1(122.16,18.49) v3(120.5,26.48) v3(120.5,25.85) v3(122.38,21.3) v3(122.4,20.64) v3(122.4,20) v3(122.4,19.24) v3(123.14,21.3) v3(123.16,20.64) v3(123.16,20) v3(123.16,19.24) v3(123.9,21.3) v3(123.93,20.64) v3(123.93,20) v3(123.93,19.24) v3(124.66,21.3) v3(124.69,20.64) v3(124.69,20) v3(124.69,19.24) v3(145.03,27.1) v3(145.67,27.1)
+3.3V_ALW: length 613.4
  TOP w0.203: U36.6 71.37,40.79 v3(71.09,41.06) 70.97,40.93 U36.7 ; U40.2 100.11,40.04 100.11,40.06 v3(99.9,40.27) 100.06,40.44 U40.1
  TOP w0.254: C723.1 21.22,102.9 JIO1.2
  TOP w0.381: U17.5 112.48,129.41 112.75,129.68 112.75,130.16 C92.1 ; U58.5 33.31,88.47 C778.1 ; C90.1 109.56,130.18 U16.5
  TOP w0.508: v3(18.1,124.49) 14.31,124.49 R426.1 ; v3(64.92,45.66) 65.38,46.11 RH246.1 ; v3(96.24,69.48) 96.79,68.94 96.79,64.11 97.23,63.67 97.23,54.72 96.34,53.84 96.34,53.25 97,52.59 97.89,52.59 98.83,51.65 98.83,42.56 99.9,41.49 v3(99.9,40.27) ; v3(37.15,69.81) 36.17,69.81 35.28,68.92 33.86,68.92 28.9,73.88 v3(28.9,81.5) ; C778.1 34.36,88.41 34.77,88 v3(34.77,87.57) 35.28,87.06 R932.1 ; v3(42.11,83.27) 42.88,84.04 PR21.1 ; PR2.1 v3(209.65,10.02) ; C92.1 112.5,130.34 111.91,129.76 v3(111.5,129.76) ; v3(118.15,106.87) 119.8,105.22 127.76,105.22 128.5,104.49 JKB1.7 JKB1.8 128.5,98.57 C756.1 128.73,98.57 129.17,98.12 129.17,97.23 127.35,95.41 127.35,88.74 126.79,88.18 v3(126.26,88.18) ; v3(33.04,23.29) 32.55,23.79 R515.1 ; v3(108.49,129.46) 108.49,130.07 108.84,130.42 C90.1 ; PR8.2 9.45,97.78 v3(9.98,97.24) ; R14.1 116.81,130.54 v3(116.33,130.06) ; v3(244.54,36.36) 243.93,35.75 243.93,33.05 243.36,32.47 242.06,32.47 240.77,31.18 240.77,27.22 v3(243.32,24.66) ; R937.1 129.13,168.03 127.84,166.74 v3(127.84,166.56) ; C723.1 v3(22.12,102.68) ; v3(58.29,29.48) 58.29,38.35 v3(55.87,40.78)
  IN1 w0.508: v3(28.9,81.5) 28.37,82.03 28.37,84.42 25.37,87.41 v3(25.37,88) 25.37,88.28 26.41,89.32 29.03,89.32 v3(29.31,89.04) ; 36.17,86.14 37.39,84.93 39.95,84.93 41.6,83.27 v3(42.11,83.27)
  IN2 w0.508: v3(58.33,56.31) 58.33,56.65 62.27,60.58 62.27,61.82 63.63,63.18 68.43,63.18 69.19,62.42 ; v3(126.26,88.18) 126.26,86.73 128.22,84.77 128.22,83.99 126.92,82.69 126.14,82.69 121.03,77.58 121.03,76.42 118.52,73.9 112.85,73.9 110.31,71.36 106.7,71.36 104.98,73.09 v3(101.22,73.09) ; v3(28.5,51.68) 28.73,51.45 28.73,50.74 27.41,49.42 27.41,47.28 28.93,45.76 28.93,43.96 30.02,42.86 31.47,42.86 v3(32.1,42.23) 33.7,40.63 33.7,40.58 32.43,39.31 32.43,36.39 29.97,33.92 28.31,33.92 27.27,32.88 27.27,30.71 26.94,30.38 26.94,21.91 28.08,20.77 30.31,20.77 32.84,23.29 v3(33.04,23.29) 33.36,22.97 33.36,21.54 39.47,15.43 46.99,15.43 48.77,13.65 54,13.65 54.46,14.11 v3(54.46,15.53)
  IN3 w0.381: v3(73.38,40.83) 72.87,40.32 71.58,40.32 71.09,40.81 v3(71.09,41.06)
  IN3 w0.508: v3(265.48,81.62) 271.52,81.62 274.55,84.65 274.55,90.62 v3(275.69,91.76) ; v3(96.24,69.48) 97.61,69.48 101.22,73.09 v3(101.22,73.09) ; v3(110.54,29.15) 110.73,29.34 113.21,29.34 114.71,27.84 114.71,27.03 116.6,25.13 121.13,25.13 122.15,26.15 130.71,26.15 137.57,19.29 137.57,17.95 140.03,15.48 155.35,15.48 156.54,16.68 v3(156.54,18.38)
  IN4 w0.508: v3(9.98,97.24) 14.53,101.79 20.55,101.79 C723.1 v3(22.12,102.68) ; v3(118.15,106.87) 118.17,106.9 118.17,116.14 119.02,116.99 119.02,121.27 119.91,122.16 119.91,123.2 119.02,124.09 119.02,125.9 121.75,128.63 v3(121.75,132.4)
  BOTTOM w0.305: JAPS1.7 17.96,123.44 v3(18.54,124.03)
  BOTTOM w0.381: C727.1 97.15,163.92 97.15,163.2 U55.5 ; U50.5 235.37,57.86 C720.1 ; PU1081.5 221.3,51.89 222.05,52.64 PC1081.2 ; C726.1 104.78,164.73 U54.5 ; PC1080.2 221.15,61.8 PU1080.5 ; v3(58.33,56.31) U12.5 57.21,56.97 C289.1 ; PC733.2 245.65,20.26 245.98,19.93 PU704.5
  BOTTOM w0.508: v3(247.77,65.33) 247.76,65.34 R779.1 ; R864.1 v3(272.26,35.62) ; v3(249.24,55.99) 249.24,55.17 248.99,54.93 R396.1 ; PR221.1 v3(156.54,18.38) ; R755.1 123.49,131.42 122.52,132.4 v3(121.75,132.4) ; v3(255.85,35.52) 255.55,35.22 PR1025.2 ; R763.1 236.17,78.35 236.17,78.85 v3(236.24,78.93) ; R814.1 254.96,45.25 v3(254.96,44.92) ; v3(220.88,62.55) 220.95,62.47 PC1080.2 ; R875.1 233.12,45.63 233.55,45.63 v3(233.78,45.4) 234.01,45.63 234.44,45.63 R871.1 ; R845.1 244.61,37.11 244.61,36.44 v3(244.54,36.36) ; R760.1 255.67,45.89 255.62,45.94 v3(255.6,45.94) ; PR757.1 PR764.1 232.6,25.72 233.08,26.2 236.03,26.2 236.51,25.72 242.26,25.72 v3(243.32,24.66) 243.99,23.99 PR749.1 243.99,21.45 244.91,20.53 PC733.2 ; R847.1 v3(272.26,30.54) 271.14,30.54 R848.1 ; v3(231.47,36.72) 231.47,36.51 231.85,36.13 233.16,36.13 R872.1 ; R858.1 v3(272.26,34.61) ; v3(158.46,26.54) 158.46,26.98 158.92,27.44 159.49,27.44 159.85,27.08 PR216.1 ; v3(275.69,91.76) 275.69,92.33 279.46,96.1 279.46,96.25 281.7,98.49 282.21,98.49 283.29,99.57 288.84,99.57 290.84,101.57 R938.1 ; v3(252.8,42.48) 252.68,42.61 252.14,42.61 R1126.1 ; R768.1 228.75,65.72 v3(228.5,65.98) ; v3(25.37,88) 25.28,87.91 v4(24.2,87.91) 22.8,87.91 v4(19.26,91.44) v4(19.26,95.29) 19.26,99.37 21.49,101.59 21.49,102.35 21.82,102.68 v3(22.12,102.68) ; R418.1 R841.1 233.42,42.36 v3(233.78,42.71) 234.14,42.36 R838.1 R420.1 ; R850.1 v3(272.26,29.53) ; PR222.1 v3(155.76,27.6) ; 60.07,47.66 60.35,47.94 63.83,47.94 64.92,46.85 v3(64.92,45.66) ; 59.1,47.23 R1633.2 ; R386.1 29.36,89.09 v3(29.31,89.04) ; v3(228.01,58.33) 228.01,58.97 229.61,60.57 R2158.1 ; PR213.1 v3(159.46,18.38) ; v3(32.1,42.23) 32.36,42.48 PR119.2 ; v3(28.5,51.68) 28.55,51.63 33.07,51.63 34.64,53.2 34.64,64.33 35.41,65.09 35.41,67.35 37.15,69.1 37.56,69.1 PR300.2 37.57,69.37 37.4,69.53 37.4,69.56 v3(37.15,69.81) ; PR1083.1 v3(225.96,50.99) ; R94.2 266.52,78.07 v3(266.27,78.07) ; v3(105.54,165.82) 105.54,165.04 105.76,164.81 C726.1 ; C720.1 234.35,57.93 233.86,57.43 v3(233.86,56.99) ; Q90.3 v3(265.48,81.62) ; C727.1 96.87,164.07 v3(96.37,163.56) ; v3(237.84,81.22) 237.72,81.09 R800.1 ; v3(231.65,38.34) 232.26,38.34 R1125.1 ; R834.1 237.34,55.21 236.83,55.72 v3(236.83,55.77) ; R859.1 v3(272.26,33.59) ; R860.1 v3(272.26,32.58) ; v3(58.29,29.48) 58.29,27.6 62.08,23.81 62.08,19.11 63.47,17.72 63.47,14.64 61.97,13.15 56.23,13.15 55.22,14.16 55.22,14.8 ; v3(255.09,51.47) 254.68,51.88 R759.1 ; R861.1 v3(272.26,31.56) ; v3(228.62,40.84) 229.18,41.4 R397.1 ; R1980.1 v3(252.42,51.88) ; v3(239.75,58) 239.75,57.54 R817.1 ; R805.1 v3(232.38,79.03) ; v3(73.23,41.92) 73.23,41.95 72.87,42.31 72.87,44.29 71.98,45.18 71.98,46.67 70.61,48.04 70.61,49.53 72.06,50.98 RH238.1 ; R849.1 v3(272.26,28.51) ; PC1081.2 v2(222.05,53.86) ; v3(37.84,146.06) 38.07,145.83 R11.1
  vias: v3(13.69,141.54) v3(14.32,141.54) v3(14.63,142.13) v3(14.96,141.54) v3(56.1,46.76) v3(56.3,47.42) v3(56.56,46.28) v3(56.75,46.94) v3(56.92,47.58) v3(57.02,45.82) v3(57.21,46.48) v3(57.38,47.1) v3(57.47,45.37) v3(57.67,46.02) v3(57.83,46.64) v3(57.93,44.91) v3(58.13,45.56) v3(58.29,46.19) v3(58.41,44.45) v3(58.61,45.11) v3(58.75,45.73) v3(58.87,43.99) v3(59.07,44.65) v3(59.23,45.27) v3(59.69,44.81) v3(72.95,41.34) v3(73.68,41.47) v3(73.99,40.63) v3(74.34,41.19) v3(74.78,40.68) v3(98.96,166.43) v3(99.59,166.43) v3(99.86,37.57) v3(100.25,166.46) v3(100.52,37.55) v3(100.96,166.51) v3(101.65,166.51) v3(110.01,29.55) v3(110.26,173.62) v3(110.64,173.09) v3(111.1,173.62) v3(111.45,173.09) v3(155.17,21.53) v3(155.17,20.87) v3(158.72,31.05) v3(159.49,31.05) v3(229.08,73.83) v3(229.39,73.19) v3(229.72,76.26) v3(229.79,73.72) v3(247.9,75.53) v3(248,74.87) v3(250.85,69.2) v3(250.85,68.47) v3(252.8,37.07) v3(254.15,37.76) v3(254.18,37.1) v3(254.68,53.58) v3(255.32,53.25) v3(273.53,37.28) v3(274.17,37.28) v3(274.8,38.04) v3(274.8,37.28) v3(275.49,38.04) v3(275.49,37.33)
+3.3V_ALW2: length 447
  TOP w0.381: UH2.5 63.62,48.39 CH11.1
  TOP w0.508: v3(1.37,116.52) 1.29,116.6 1.29,132.91 PR27.1 ; v3(63.07,41.92) 63.37,42.23 63.37,46.52 63.52,46.67 63.52,48.32 CH11.1 ; R909.1 37.15,72.5 34.36,69.72 v3(33.99,69.72) ; v3(241.83,30.7) 241.83,28.68 v3(249.15,21.36) 249.15,21.36 253.7,21.36 v3(257.02,24.68) ; v3(33.17,37.28) 33.17,36.46 34.69,34.94 37.92,34.94 38.89,35.9 38.89,36.08 40.16,37.35 41.65,37.35 42.57,38.27 v3(42.57,38.39)
  IN1 w0.508: v3(243.97,15.29) 243.53,15.29 241.64,17.18 v3(239.9,17.18) 236.7,13.98 v3(227.48,13.98) ; v3(12.85,81.29) 12.85,81.43 10.9,83.39 10.9,88.4 7.16,92.13 7.16,101.94 1.37,107.73 v3(1.37,116.52)
  IN2 w0.508: v3(63.07,41.92) 63.8,42.66 73.53,42.66 74.14,42.05 75.59,42.05 76.35,42.81 80.29,42.81 80.59,43.12 92.07,43.12 94.61,40.58 98.6,40.58 98.98,40.96 100.33,40.96 101.34,39.94 103.68,39.94 105.61,38.01 119.21,38.01 119.38,37.83 122.81,37.83 123.95,36.69 166.67,36.69 167.46,35.9 175.36,35.9 176.75,34.52 178.74,34.52 179.89,33.36 186.64,33.36 187.43,32.58 194.25,32.58 198.34,36.67 205.3,36.67 205.83,37.2 208.08,37.2 209.56,38.68 225.97,38.68 226.97,37.68 228.67,37.68 230.73,35.62 232.05,35.62 232.69,36.26 233.91,36.26 234.73,35.43 234.73,34.97 237.42,32.28 240.24,32.28 v3(241.83,30.7) ; v3(249.15,21.36) 243.97,16.18 v3(243.97,15.29)
  IN3 w0.508: v3(12.85,81.29) 12.85,78.83 13.88,77.8 13.88,76.05 20.62,69.3 22.83,69.3 24.59,67.55 24.59,64.94 23.32,63.67 23.32,57.68 24.86,56.14 24.86,54.96 27.07,52.75 27.07,43.2 28.42,41.85 28.42,39.88 30.64,37.66 32.79,37.66 v3(33.17,37.28)
  IN4 w0.508: v3(33.99,69.72) 30.95,69.72 30.23,69 26.3,69 26.12,69.18 22.38,69.18 22.37,69.19 22.13,69.19 22.04,69.28 20.52,69.28 14.51,75.28 14.51,79.06 12.85,80.72 v3(12.85,81.29)
  BOTTOM w0.203: PU101.3 33.76,37.96 33.39,38.32 PC114.2
  BOTTOM w0.508: v3(241.83,30.7) 241.83,31.53 241.01,32.36 PR1100.1 240.5,33.16 241.27,33.93 R874.2 ; v3(63.07,41.92) v4(60.35,39.21) 60.11,38.97 43.15,38.97 v3(42.57,38.39) ; v3(249.15,21.36) 248.92,21.13 PR1073.1 ; PQ1072.3 v3(243.97,15.29) ; PR741.1 v3(227.48,13.98) ; PR737.1 v3(239.9,17.18) ; v3(257.02,24.68) 257.35,25.01 PR1022.1 258.7,24.98 258.7,24.24 259.26,23.69 PR1013.1 ; PC114.2 32.53,38.11 PR103.1 33.14,37.25 v3(33.17,37.28)
+3.3V_ALW_PCH: length 494.7
  TOP w0.254: CH43.1 76.23,65.63 76.9,64.96 v2(76.99,64.96)
  TOP w0.381: CH51.1 79.37,56.05 78.48,56.05 v2(78.34,55.9) ; v2(60.73,64.2) 61.26,64.2 61.36,64.3 RH213.2
  TOP w0.457: v2(76.99,64.96) 77.19,64.96 77.24,65.02 77.24,65.04 77.75,65.55 CH45.1
  TOP w0.508: v3(64.13,64.61) 64.49,64.96 RH254.2 ; v3(58.4,66.54) 58.66,66.28 59,66.28 RH123.2 ; RH212.2 74.52,46 v3(74.88,45.64) ; RH211.2 60.73,66.36 v3(60.7,66.33) ; RH210.2 60.78,65.22 v3(60.68,65.11) ; RC124.1 212.52,122.82 212.14,122.44 v3(212.01,122.44) ; CH51.1 79.6,55.13 80.16,54.57 80.16,54.27 80.95,53.48 82.5,53.48 83.72,52.26 83.72,51.12 v3(83.74,51.09) ; RH88.1 58.9,62.6 v3(57.4,62.6) ; v3(127.15,84.11) 128.52,84.11 137.21,92.8 v3(137.21,107.28) ; RH170.1 v3(60.68,62.17) ; v3(41.1,86.6) 41.1,86.65 40.62,87.13 40.62,87.42 41.05,87.85 45.62,87.85 46.4,87.06 50.09,87.06 51.26,85.89 v3(51.26,85.81) ; v3(57.94,65.06) 58.67,64.33 RH73.1 ; RH240.1 66.65,46.06 66.34,45.76 v3(66.34,45.1) ; v3(71.73,53.48) 71.73,54.09 RH171.1 ; 66.01,39.31 61.27,39.31 52.83,47.75 52.83,56.15 53.95,57.26 53.95,58.46 54.91,59.42 54.91,59.86 55.22,60.16 56.13,60.16 56.74,59.55 v3(58.24,59.55) 58.44,59.75 RH75.1 RH166.1 ; R520.1 R796.1 v3(27.76,23.74) ; RH128.2 RH124.2 61.29,68.57 v3(60.68,68.57) ; RH222.2 60.81,67.63 v3(60.68,67.5) ; v3(207.08,87.72) 205.76,89.04 205.76,95.75 206.35,96.33 v3(206.58,96.33)
  IN2 w0.508: v3(212.01,122.44) 211.25,121.68 211.25,116.32 210.41,115.48 v3(210.41,113.88)
  IN3 w0.508: v3(41.1,86.6) 41.1,86.7 40.86,86.94 39.11,86.94 37.77,88.28 37.77,98.02 23.83,111.95 v3(23.16,111.95) ; v3(108.46,58.48) 109.63,59.65 109.63,65.16 116.18,71.72 116.18,72.96 114.4,74.74 114.4,78.85 118.16,82.61 125.65,82.61 v3(127.15,84.11)
  IN4 w0.508: v3(108.46,58.48) 106.07,56.1 97.94,56.1 96.32,54.47 96.32,52.85 97.36,51.8 97.36,50.66 96.32,49.62 91.13,49.62 89.69,51.07 83.77,51.07 v3(83.74,51.09) 82.9,50.25 79.15,50.25 v2(78.92,50.48) ; v3(137.21,107.28) 137.21,106.08 143.23,100.06 184.86,100.06 197.2,87.72 v3(207.08,87.72) ; v3(55.02,70.45) 54.89,70.57 54.41,70.57 53.16,71.82 53.16,72.06 52.49,72.73 51.46,72.73 50,74.19 50,84.62 50.63,85.26 50.7,85.26 v3(51.26,85.81)
  BOTTOM w0.254: JXDP2.44 50.89,85.45 v3(51.26,85.81) ; JXDP2.43 41.29,85.45 CH2.1 ; UH1.AJ32 80.33,69.6 v2(80.24,69.6) 80.15,69.6 UH1.AJ30 ; UH1.R20 UH1.R22 76.66,64.63 v2(76.99,64.96) 77.06,64.96 UH1.R24 UH1.R26 78.27,64.63 v2(78.63,64.98) ; v2(78.63,64.98) 78.98,64.63 UH1.R28 ; v2(78.63,64.98) 78.52,64.98 78.21,65.29 UH1.U26 ; v2(78.34,55.9) 78.34,56.11 78.13,56.33 78.13,58.23 UH1.A26
  BOTTOM w0.305: JAPS1.1 15.1,120.44
  BOTTOM w0.381: RH140.2 61.34,66.26 60.78,66.26 v3(60.7,66.33) ; RH147.2 v3(60.68,67.5)
  BOTTOM w0.457: v2(78.92,50.48) 78.92,50.99 78.97,51.04 RH35.1
  BOTTOM w0.508: v3(206.58,96.33) 205.52,97.38 205.52,111.8 207.86,114.14 210.16,114.14 v3(210.41,113.88) ; R1624.2 57.37,55.18 58.19,54.37 R1622.2 57.91,53.79 57.55,53.43 57.55,50.7 v2(58.44,49.81) ; RH130.1 60.7,65.09 v3(60.68,65.11) ; RH84.1 61.03,62.52 v3(60.68,62.17) ; 15.1,120.44 18.02,120.44 v4(19.05,119.41) 22.35,116.12 22.35,112.76 v3(23.16,111.95) ; RH46.1 56.04,69.65 55.24,70.45 v3(55.02,70.45) 53.97,71.49 50.6,71.49 48.77,69.66 43.72,69.66 40.68,72.71 38.09,72.71 36.87,71.49 36.65,71.49 35.63,70.47 32.69,70.47 31.19,68.97 29.4,68.97 27.79,67.36 27.79,64.96 29.82,62.93 32.99,62.93 34.01,61.91 34.01,53.43 32.89,52.31 28.22,52.31 27.05,51.14 27.05,24.45 v3(27.76,23.74) ; v3(66.34,45.1) 66.34,44.92 65.76,44.34 65.76,39.31 66.37,38.7 v3(66.37,38.55) ; RH41.1 RH60.1 77.06,50.86 v3(76.68,50.48) 76.55,50.36 76.55,48.27 74.88,46.59 v3(74.88,45.64) ; v2(73.86,51.91) 73.76,51.8 RH237.1 ; v3(58.4,66.54) 59,66.54 RH125.2 ; CH2.1 41.32,85.66 41.32,86.37 v3(41.1,86.6)
  vias: v3(57.43,65.47) v3(57.4,61.94)
+3.3V_ALW_PCH_JTAG: length 4.1
  TOP w0.102: v3(58.29,70.3) 58.58,70.3 v1(58.98,70.69)
  BOTTOM w0.381: RH46.2 57.69,69.15 v3(58.34,69.15) RH48.1 ; v3(58.29,70.3) RH50.1
  BOTTOM w0.508: v3(58.36,68.19) 58.41,68.14 RH52.1
+3.3V_ALW_PCH_PWR: length 1.3
  TOP w0.102: C416.1 69.82,37.35 v1(69.98,37.2)
+3.3V_ALW_U46: length 28.4
  IN2 w0.508: 236.29,77.31 236.28,77.32 232.75,77.32 231.28,75.85 231.28,74.96 231.66,74.59 232.68,74.59 233.21,74.05 233.21,73.44 232.57,72.81 231.61,72.81 230.96,72.16 230.96,70.5 v3(231.04,70.42)
  BOTTOM w0.254: U46.B5 242.53,71.41 242.25,71.12 v2(242.17,71.12) ; v2(236.14,65.47) 236.23,65.39 U46.B30 ; C718.1 231.11,71.06 231.27,70.9 231.97,70.9 232.21,70.66 U46.A43 ; U46.A17 241.98,63.57 242.82,62.73 v1(242.82,62.66) 242.82,61.84 C708.1 ; U46.A54 236.98,75.48
  BOTTOM w0.508: C718.1 C710.1 230.78,70.17 v3(231.04,70.42) ; 236.98,75.48 236.98,76.11 v3(237.08,76.21) 236.96,76.34 C719.1 ; v3(243.79,62.4) 243.79,62.37 243.18,61.76 C708.1 ; C717.1 235.51,61.66 v3(235.51,62.29) ; v3(247.9,71.36) 247.72,71.18 C709.1
  vias: v3(246.1,75.81) v3(246.66,76.14)
+3.3V_ALW_U51: length 37.2
  IN2 w0.508: 237.03,42.94 239.01,40.96 246.58,40.96 248.66,38.88 v2(248.84,38.88)
  BOTTOM w0.203: 236.32,47.61 237.16,47.61 237.36,47.42 U51.A11 ; U51.B3 238.78,43.17 238.89,43.27 239.44,43.27 239.7,43.53 v2(239.7,43.64) ; 249.53,46.09 248.94,46.09 248.77,45.92 U51.A41
  BOTTOM w0.254: v2(250.44,45.4) 250.95,45.91 C781.1 250.93,45.96 249.94,45.96 249.81,46.09 249.53,46.09 ; U51.A26 243.8,52.35 243.86,52.41 243.86,53.2 C1355.1 ; U51.B35 247.69,50.2 247.92,50.2 248.77,51.05 248.77,52.18 249.48,52.9 C777.1 ; v2(235.13,48.07) 235.13,47.69 C1348.1 235.8,47.44 235.98,47.61 236.32,47.61 ; C780.1 248.46,38.24 247.93,38.77 247.93,39.21 247.62,39.51 v1(247.29,39.51) 246.94,39.51 246.66,39.23 245.77,39.23 245.3,39.7 U51.A52
  BOTTOM w0.508: v2(245.44,54) 245.35,54.09 C1355.1 ; v3(236.27,41.14) 235.99,41.42 C1345.1 ; v2(248.84,38.88) 248.79,38.82 248.79,38.39 C780.1
  vias: v2(251.64,53.58) v2(252.22,53.58)
+3.3V_LAN: length 348
  TOP w0.203: U32.30 111.1,105.25 v2(110.92,105.42) ; C474.1 105.19,103.56 U32.39
  TOP w0.254: v2(113.66,100.19) 113.66,100.44 113.6,100.51 U32.14 ; U32.4 v3(108.6,100.17) ; C472.1 105.21,100.9 106.93,100.9 107.1,101.07 U32.1 ; U32.8 v2(110.6,100.19) ; U32.21 117,103.56 C473.1
  TOP w0.381: R559.2 v3(118.59,88.58) ; R549.1 117.98,89.52 v3(118.59,89.52) ; v3(118.59,90.69) 117.98,90.69 R553.1
  TOP w0.508: v2(65.45,85.43) 65.45,86.63 67.94,89.12 69.9,89.12 72.11,86.91 79.7,86.91 81.05,88.25 85.19,88.25 91.16,82.28 92.71,82.28 93.55,83.12 97.85,83.12 98.08,82.89 v2(99.95,82.89) ; JLOM1.9 64.99,160.47 C1167.1 65.68,161.28 v2(66.52,162.12) ; v2(52.22,72.12) 52.6,71.74 52.6,68.26 RH174.1 RH175.1 ; R554.1 118.01,87.67 v3(118.59,87.67) ; JLOM1.12 50.71,164.85 49.12,163.26 C483.1 44.63,162.36 C481.1 45.31,162.12 v2(45.69,162.5) ; C474.1 105.1,103.65 v2(104.42,103.65) ; v2(117.78,103.62) C473.1 ; v3(105.13,101.61) C472.1
  IN1 w0.508: v2(52.22,72.12) 51.84,72.12 49.57,74.4 49.57,76.45 50.41,77.29 51.85,77.29 53.9,79.34 56.33,79.34 57.55,80.56 57.55,83.83 58.75,85.03 65.05,85.03 v2(65.45,85.43)
  IN2 w0.508: 105.89,171.26 101.7,171.26 100.51,170.07 93.67,170.07 91.08,167.48 89.1,167.48 87.07,165.44 83.89,165.44 81.43,162.98 67.38,162.98 v2(66.52,162.12)
  IN2 w1.016: 111.73,171.77 112.71,170.79 120.84,170.79 121.56,171.51 125.07,171.51 125.3,171.29 126.74,171.29 129.39,173.93 137.82,173.93 144.96,166.79 144.96,157.47 149.12,153.3 149.12,152.03 150.7,150.46 154.38,150.46 156.34,148.5 156.34,142.08 147.7,133.44 137.79,133.44 134.9,130.54 134.9,125.18 133.22,123.51 133.22,108.27 135.36,106.13 135.36,97.6 130.28,92.52 128.24,92.52 125.35,89.62 119.84,89.62
  IN3 w0.508: v2(45.69,162.5) 42.9,162.5 40.11,159.7 40.11,154.12 42.77,151.45 63.73,151.45 68.25,155.97 68.25,159.5 66.52,161.23 v2(66.52,162.12)
  vias: v2(104.27,93.76) v2(104.88,93.79) v3(99.92,77.66) v3(99.92,77) v3(105.28,88.91) v3(105.92,88.89) v4(116.89,91.08)
+3.3V_LAN_OUT: length 9.1
  TOP w0.203: v3(112.99,96.35) 113.23,96.11 113.23,95.49 113.13,95.39 U31.15 ; U31.29 107.83,92.49 v3(107.8,92.52) ; U31.19 v3(111.53,95.77) ; U31.5 115.18,91.29 115.24,91.22 115.54,91.22 v3(115.77,91) 115.66,90.89 U31.4
  BOTTOM w0.102: v3(107.8,92.52) v1(107.8,91.67)
  BOTTOM w0.508: R209.1 114.91,90.49 C464.1 115.52,90.74 v3(115.77,91)
+3.3V_M: length 366.6
  TOP w0.457: v2(72.37,68.54) 72.45,68.47 72.8,68.47 CH59.1
  TOP w0.508: v3(62.25,88.43) 62.91,87.77 65.73,87.77 67.77,89.8 v3(70.84,89.8) ; v3(100.48,54.98) 99.52,55.94 98.37,55.94 97.84,56.48 97.84,64.12 97.41,64.55 97.41,71.62 98.58,72.78 98.58,76.62 v3(97.33,77.86) ; 108.18,43.27 108.99,43.27 109.98,42.28 109.98,36.67 v3(109.8,36.49)
  IN1 w0.508: v3(37.64,86.91) 37.64,87.95 39.29,89.6 ; 39.29,89.6 35.22,89.6 34.64,90.19 30.37,90.19 v3(28.55,92.01) ; 39.29,89.6 39.6,89.9 41.5,89.9 43.86,87.54 61.37,87.54 v3(62.25,88.43)
  IN2 w0.203: 69.26,68.49 69.26,68.5 69.79,69.03 72.03,69.03 72.37,68.69 v2(72.37,68.54)
  IN2 w0.254: 69.26,68.39 69.26,68.49 ; 69.72,77.42 69.29,76.99 69.29,75.07 69.67,75.07 71.44,76.84 71.44,77.42 69.72,77.42
  IN2 w0.305: 69.26,68.39 69.65,68.01 72.01,68.01 72.37,68.37 v2(72.37,68.54)
  IN2 w0.508: v3(97.33,77.86) 97.33,82.08 94.64,84.77 91.82,84.77 90.02,86.58 84.45,86.58 83.77,87.26 83.77,89.01 82.53,90.25 71.29,90.25 v3(70.84,89.8) 70.38,89.35 70.38,81.24 71.89,79.73 71.89,77.88 71.44,77.42 ; v3(255.65,51.85) 256.08,52.29 256.08,53.96 254.71,55.33 244.04,55.33 242.77,56.6 238.61,56.6 v3(237.77,55.77) ; 69.29,75.07 68.02,73.8 68.02,69.08 68.71,68.39 69.26,68.39
  IN3 w0.508: v3(27.99,95.39) 27.99,95.29 26.69,93.99 26.69,93.16 27.1,92.75 28.09,92.75 28.55,92.29 v3(28.55,92.01) ; v3(109.8,36.49) 110.25,36.93 116.93,36.93 118.49,35.37 122.3,35.37 123.3,36.37 142.86,36.37 146.02,33.21 155.02,33.21 156.32,31.9 177.03,31.9 179.9,34.77 190.16,34.77 192,36.61 194.89,36.61 196.23,37.95 204.79,37.95 205.35,38.51 207.76,38.51 216.86,47.6 225.94,47.6 233.15,54.8 237.32,54.8 237.77,55.25 v3(237.77,55.77)
  BOTTOM w0.254: UH1.AD12 72.73,68.18 v2(72.37,68.54) ; JSPI1.16 104.03,51.33 103.1,52.26 102.51,52.26 RH185.1
  BOTTOM w0.457: R389.1 28.98,94.43 28.68,94.73 28.45,94.73 27.99,95.19 v3(27.99,95.39)
  BOTTOM w0.508: v3(107.36,43.22) 100.71,43.22 98.12,45.81 98.12,50.33 100.48,52.69 RH185.1 v3(100.48,54.98) ; R893.1 255.78,50.97 255.78,51.73 v3(255.65,51.85) ; R388.1 38.45,87.41 37.95,86.91 v3(37.64,86.91) ; R837.1 238.23,55.31 v3(237.77,55.77) ; v3(28.55,92.01) 28.8,91.76 R411.2 R385.1 ; v3(27.99,95.39) 26.97,96.41 v4(26.97,97.07) 26.97,97.68 27.48,98.18 R130.1
+3.3V_M_PWR: length 1.1
  TOP w0.102: U40.14 v1(102.78,41.53)
+3.3V_MXM: length 560
  TOP w0.381: R1122.1 86.69,148.5 81.99,148.5 R5.1 R3.1 R1978.1 79.73,149.39 v2(78.59,150.53) ; U27.5 122.39,136.62 C94.1 122.35,136.64 121.79,136.08 v3(121.79,135.83) ; U14.5 119.72,136.62 C96.1 120.37,136 v3(120.37,135.83) ; U60.4 10.63,143.23 v3(10.16,142.76) ; U25.5 117.05,136.62 C95.1
  TOP w0.508: R38.1 v2(111.48,132.08) ; v2(126.36,96.48) 126.64,96.2 126.64,89.32 v3(126.34,89.01) ; v3(43.13,148.27) 42.82,147.97 R1977.1 ; v3(114.12,132.08) 114.12,132.09 114.15,132.07 114.15,131.71 R37.1 ; v3(92.53,59.93) 93.01,59.45 93.01,55.56 91.29,53.84 89.43,53.84 88.82,53.23 88.82,52.39 88.75,52.31 RH113.1 ; C95.1 117.14,136.64 117.75,136.03 v3(117.75,135.83) ; R2184.2 R2185.2 v2(16.36,145.48)
  IN2 w0.508: v3(121.79,135.83) v3(120.37,135.83) v3(117.75,135.83) 117.75,135.73 114.12,132.1 v3(114.12,132.08) ; v3(126.34,89.01) 129.61,85.74 129.61,82.82 127.38,80.58 125.55,80.58 121.89,76.92 121.89,76.39 117.81,72.3 116.74,72.3 110.01,65.57 110.01,64.66 106.25,60.9 93.5,60.9 v3(92.53,59.93) ; v3(43.13,148.27) 77.57,148.27 78.59,149.29 v2(78.59,150.53) 84.19,144.93 88.15,144.93 88.78,145.57 93.9,145.57 94.8,146.47 94.8,152.22 93.95,153.07 93.95,158.27 93.29,158.93 v2(93.29,160.6) 95.05,162.36 96.7,162.36 98.3,163.96 101.36,163.96 101.98,164.58 106.97,164.58 ; v3(10.13,142.1) 10.13,142.74 v3(10.16,142.76) 12.37,142.76 15.09,145.48 v2(16.36,145.48) 16.99,145.48 21.18,141.29 28.55,141.29 29.56,140.27 36.8,140.27 36.98,140.09 v2(42.65,140.09) 43.23,140.09 v2(43.38,139.94) 44.86,139.94 47.65,142.74 v2(49.02,142.74) 49.02,141.77 49.25,141.54 49.25,139.69 v2(49.5,139.43) 50.42,139.43 v2(52.53,141.54) 54.71,141.54 55.08,141.91 56.16,141.91 57.8,140.27 58.63,140.27 58.79,140.42 59.68,140.42 59.83,140.27 61.47,140.27 61.64,140.09 100.19,140.09 100.33,140.24 v2(100.33,141.14) 100.75,141.55 100.75,145.25 ; v2(126.36,96.48) 126.59,96.71 129.44,96.71 131.23,98.5 131.23,104.75 132.28,105.8 132.28,126.7 131.09,127.89 v3(131.09,128.89) ; 110.34,144.88 110.62,144.6 110.62,140.97 111.48,140.11 v2(111.48,132.08)
  IN2 w1.016: 110.34,144.88 101.12,144.88 100.75,145.25 100.75,159.37 104.14,162.76 107.01,162.76
  IN3 w0.508: v3(114.12,132.08) 114.12,131.51 113.87,131.26 112.34,131.26 111.48,132.12 v2(111.48,132.08)
  IN4 w0.508: v3(215.64,64.91) 215.64,64.71 215.21,64.28 211.74,64.28 208.63,67.38 208.63,67.78 187.81,88.61 172.29,88.61 169.52,91.38 131.47,91.38 v2(126.36,96.48)
  BOTTOM w0.305: v3(5.28,138.27) 5.41,138.14 5.41,137.61 5.68,137.34 U59.3
  BOTTOM w0.381: v2(49.02,142.74) 49.25,142.51 Q295.2 ; v2(93.29,160.6) 92.66,159.97 92.66,156.83 92.31,156.49 91.88,156.49 91.41,156.02 R1121.1 ; Q295.5 49.25,139.65 49.46,139.43 v2(49.5,139.43)
  BOTTOM w0.508: R401.1 R400.1 225.68,41.88 223.65,41.88 223,41.22 223,40.49 220.04,37.53 215.53,37.53 213.54,39.52 213.54,44.2 214.76,45.42 214.76,56.63 215.77,57.65 215.77,63.95 215.64,64.07 v3(215.64,64.91) ; R4.1 43.38,140.42 v2(43.38,139.94) 44.21,139.11 Q5.2 ; R1.1 R2.1 v2(52.53,141.54) ; v2(1.32,137.68) 2.2,137.68 2.72,138.19 PC17.2 ; R10.1 v2(42.65,140.09) ; v2(100.33,141.14) R1979.1 R6.1 ; v3(121.79,135.83) 121.84,135.78 v4(123.16,135.78) 125.22,135.78 131.09,129.91 v3(131.09,128.89)
  vias: v3(107.49,164.15) v3(107.49,163.51) v3(108.15,164.2) v3(108.15,163.56) v3(111.49,144.88) v3(112.13,144.88) v3(112.76,144.88) v3(113.68,144.88)
+3.3V_MXM_PWR: length 3.2
  TOP w0.102: C400.1 109.7,167.84 108.91,167.06 v1(108.91,164.99)
  vias: v3(109.47,168.62) v3(109.57,169.99)
+3.3V_PCIE_FLASH: length 10.8
  BOTTOM w0.508: JMINI3.24 78.14,30.66 C637.2 78.36,30.72 v2(78.79,30.29) ; v2(91.01,29.93) 90.8,29.93 C638.2 90.02,29.66 90.14,29.53 JMINI3.2 ; JMINI3.52 66.94,30.68 C634.1 65.77,30.72 C633.1 v2(65.76,29.91)
  vias: v2(71.22,18.61) v2(72.11,18.61) v3(58.01,15.05) v3(58.01,14.42) v4(57.29,14.22)
+3.3V_PCIE_NVM: length 12.9
  BOTTOM w0.381: JMINI4.24 22.04,148.65 22.22,148.47 22.22,147.23 C621.1
  BOTTOM w0.508: C621.1 22.07,147.33 v3(21.54,147.87) ; v3(34.34,147.21) C623.1 33.24,147.21 JMINI4.52 ; JMINI4.39 C617.1 C618.1 ; C618.1 v2(29.56,159.88) ; C618.1 28.84,159.79 JMINI4.41
  vias: v2(10.9,146.27) v3(10.97,147.21) v3(14.96,147.26) v3(15.59,147.26) v3(16.23,147.89) v3(16.23,147.26) v4(16.15,146.18)
+3.3V_PCIE_WWAN: length 7.7
  BOTTOM w0.508: 259.14,52.52 259.61,52.52 259.7,52.6 JMINI1.24 ; 259.14,52.52 259.75,51.91 v3(259.84,51.91) ; 259.14,52.52 C612.1 ; R719.2 258.39,45.62 v2(258.39,46.14) ; JMINI1.2 259.15,64.6 C614.1 259.13,65.42 v3(259.43,65.72)
  vias: v3(258.93,51.83) v3(260.26,40.82) v3(260.93,40.67) v3(275.18,46.17) v3(275.18,45.4) v3(275.82,46.17) v3(275.82,45.4) v3(276.45,46.17) v3(276.45,45.4) v4(278.2,49.92)
+3.3V_RTC_LDO: length 167.2
  TOP w0.508: v3(48.42,48.15) 46.97,46.71 v1(46.97,46.39) 46.97,40.93 42.61,36.56 40.28,36.56 39.57,35.85 39.57,35.65 38.25,34.33 33.46,34.33 31.04,36.75 v3(31.04,36.77)
  IN1 w0.508: v3(21.13,114.34) 21.13,113.84 10.3,103.01 9.11,103.01 7.77,101.67 7.77,93.9 11.5,90.16 11.5,83.68 13.49,81.69 13.49,78.52 18.87,73.14 25.16,73.14 25.98,72.32 25.98,71.06 27.05,69.99 28.65,69.99 29.26,70.6 36.19,70.6 36.98,71.39 39.11,71.39 40.02,70.49 40.02,69.14 40.63,68.53 41.71,68.53 43.67,66.56 43.67,64.54 48.42,59.8 v3(48.42,48.15)
  IN4 w0.508: v3(21.13,114.34) 22.63,112.84 38.78,112.84 40.17,111.44 45.06,111.44 v3(45.62,110.88)
  BOTTOM w0.508: PD1.3 48.69,102.35 48.03,103.01 48.03,108.62 45.77,110.88 v3(45.62,110.88) ; v3(31.04,36.77) 31.52,37.25 PR103.2
+3.3V_RUN: length 365.6
  TOP w0.203: v3(33.72,157.73) 33.65,157.73 32.76,156.84 U9.14 ; C410.1 23.39,151.73 24.46,151.73 24.77,152.04 U9.41 ; U9.56 31.4,149.92 31.62,149.7 ; U9.28 26.2,158.31 25.88,158.63 25.88,159.09 v3(25.81,159.17)
  TOP w0.254: U88.1 175.76,39.02 C391.1 ; v3(90.61,157.95) 90.83,157.73 90.83,157.33 91.24,156.92 JLVDS1.16 91.24,154.81 C243.1
  TOP w0.305: 179.25,42.81 179.88,43.45 v3(179.88,44.36) ; 179.25,42.81 178.91,42.47 U88.8 ; 179.25,42.81 179.25,42.23 178.99,41.97 U88.7 ; U88.14 173.53,42.47 C392.1 ; v2(77.91,63.04) 78.07,63.04 78.41,62.7 78.41,60.26 77.99,59.84 RH245.1
  TOP w0.356: JDIMM3.199 127.44,59.82 v2(127.52,59.9) ; JDIMM1.199 v2(127.44,73.87)
  TOP w0.381: UC1.5 209.28,147.73 CC140.1 ; U20.14 54.92,112.12 v3(54.28,112.76) ; CH12.1 55.12,77 56.77,77 57.52,76.25 UH3.5 58.11,76.42 v3(58.39,76.42) ; CH65.1 80.31,70.17 v2(80.24,70.24)
  TOP w0.508: 112.85,30.93 113.26,30.52 v3(113.26,30.21) ; 112.85,30.93 113.84,30.93 113.94,30.82 JUSH1.13 ; 112.85,30.93 C51.1 ; RH328.1 87.53,51.98 v3(87.53,52.59) ; v2(80.24,64.3) 80.03,64.3 79.63,64.7 CH27.1 ; R70.1 C437.1 v3(33.5,159.32) ; v3(108.96,149.57) 108.58,149.95 R339.1 ; v3(10.08,151.17) R44.1 R43.1 ; v3(119.56,169.38) 120.29,168.64 R340.1 119.96,168.26 C244.1 ; v3(202.74,50.2) 202.74,50.1 202.57,49.93 200.48,49.93 JSATA1.8 ; C392.1 173.39,42.96 174.03,43.6 v3(174.04,43.6) ; v3(37.59,150.58) 37.16,150.58 36.93,150.81 R68.1 ; C1145.1 C1146.1 89.2,146.88 v3(89.2,146.67) ; v3(26.31,147.33) 26.31,147.99 R518.1 R64.1 ; v3(29.82,147.21) 29.82,147.41 30.1,147.7 30.1,147.97 R58.1 ; R2151.1 v3(19.53,153.81) ; PR519.2 159.74,175.47 160.2,175.47 v3(160.3,175.37) ; v3(87.3,154.79) 87.44,154.65 87.44,154.03 88.17,153.29 R1124.1 C243.1 ; v2(127.44,73.87) 127.48,73.91 CD22.1 CD21.1 128.78,75.17 129.31,75.71 129.31,76.47 128.01,77.76 v3(127.41,77.76) ; R2157.1 23.42,148.17 v3(22.99,147.74) ; R2152.1 v3(17.88,153.81) ; v3(202.77,51.12) 202.73,51.15 JSATA1.9 ; RH120.1 61.26,73.44 v3(60.7,73.44) ; R502.1 177.06,38.09 176.5,38.65 v3(176.5,39.18) ; v3(174.93,39.15) 175.11,38.98 175.72,38.98 C391.1 ; v3(64.13,75.2) 63.62,74.68 R504.1 ; v3(20.34,144.06) 20.67,144.39 R2159.1 ; CC140.1 v3(209.93,147.71) ; v3(129.79,148.96) 129.79,148.15 130.72,147.22 L61.2 ; CH48.1 77.25,62.71 77.57,63.04 v2(77.91,63.04) ; v3(6.06,143.07) 5.84,143.28 2.39,143.28 ; R503.1 177.27,45.61 178.33,44.54 v3(178.33,44.36) ; RD8.2 125.32,78.5 125.07,78.5 124.28,77.71 124.28,77.38 v3(123.93,77.03) ; RD27.2 v3(114.68,56.07) ; v3(293.62,108.4) 293.94,108.4 294.56,107.78 JBT1.9 ; v3(20.95,161.02) 21.66,161.02 22.35,160.34 R65.1 ; C405.1 25.25,159.58 25.65,159.17 v3(25.81,159.17) ; v3(30.78,111.87) 30.68,111.98 29.79,111.98 29.39,111.57 C301.1 27.04,111.27 Q24.3 ; v3(21.28,156.17) 21.33,156.22 21.33,157.26 21.74,157.67 R72.1 22.12,158.05 R71.1 ; RH77.1 RH83.1 75.41,46.04 75.51,45.94 v3(75.51,45.63) ; v3(37.49,163.15) 37.89,163.15 38.05,163.31 R1165.2 ; R501.1 180.9,41.87 180.64,42.13 v3(180.64,44.36) ; 31.62,149.7 32.23,149.09 C402.1 32.24,148.97 C766.1 34.28,148.97 v3(34.31,148.93) ; RH145.2 58.9,71.69 58.39,72.2 v3(58.39,72.33) ; JSATA2.8 77.95,34.02 78.28,34.35 C408.1 ; v3(73.93,45.66) 73.93,45.87 73.63,46.17 RH86.1 ; v2(72.41,69.51) 72.41,69.52 72.88,69.99 CH49.1 ; v3(16.69,148.53) 17.12,148.1 R2154.1 ; v3(151.54,156.76) 151.74,156.96 R1992.2 R1990.2 ; C410.1 v3(22.91,153.12) ; JSATA2.9 79.22,35.5 ; RD26.2 v3(114.68,56.96)
  IN2 w0.508: v3(78.99,37.83) 78.99,37.94 80.36,39.31 88.24,39.31 93.19,34.35 99.67,34.35 101.19,32.83 v3(101.19,28.13) 108.43,28.13 109.35,29.05 109.35,30.28 110.15,31.08 112.75,31.08 113.26,30.57 v3(113.26,30.21) ; v3(38.84,86.17) 39.67,85.33 43.03,85.33 46.02,88.33 54.46,88.33 55.22,89.09 63.6,89.09 ; v2(127.44,62.62) 126.39,61.57 126.39,60.57 127.05,59.9 v2(127.52,59.9)
  IN3 w0.508: v3(35.48,85.43) 38.1,85.43 v3(38.84,86.17)
  BOTTOM w0.203: U11.35 90.67,146.8 90.55,146.67 v3(89.2,146.67) ; C494.1 31.16,118.53 31.55,118.15 31.55,117.97 31.8,117.72 32.4,117.72 32.56,117.88 U629.35 ; v3(35.67,114.7) 35.71,114.74 U629.26 ; U13.35 79.12,150.66 78.64,151.14 78.33,151.14 ; U629.60 37.71,125.29 ; U19.11 92.62,103.74 C1181.1 ; R128.2 38.58,113.55 38.58,114.34 37.71,115.21 U629.21 ; v3(290.19,74.05) 290.19,73.85 289.89,73.54 U22.32
  BOTTOM w0.254: UH1.M31 80.52,63.36 v2(80.87,63.01) ; U22.25 v3(289.56,77.04) ; UH1.AG14 73.31,69.25 72.98,69.58 72.48,69.58 v2(72.41,69.51) 72.73,69.2 UH1.AF12 73.18,68.59 UH1.AE14 ; UH1.R30 80.16,64.3 v2(80.24,64.3) 80.31,64.3 UH1.R32 ; U629.49 32.87,123.48 32.46,123.89 C495.1 ; v3(289.56,71.46) 289.48,71.54 U22.36 ; U26.20 182.87,35 182.73,34.86 181.71,34.86 ; U26.10 184.87,39.67 185.14,39.94 186.54,39.94 ; C497.1 280.74,68.57 280.74,71.23 281.05,71.54 U22.1 ; v2(73.84,52.52) 74.07,52.52 74.34,52.79 74.34,53.3 73.89,53.76 RH148.1 ; v2(77.91,63.04) 77.7,63.04 UH1.L24 ; UH1.AK32 80.64,70.57 80.31,70.24 v2(80.24,70.24) 80.16,70.24 UH1.AK30 ; C496.1 280.11,76.65 280.51,77.04 U22.12 ; C504.1 37.87,126.61 37.57,126.3 37.57,125.43 37.71,125.29 ; U22.6 v3(280.8,74.04)
  BOTTOM w0.356: JDIMM4.199 127.44,48.56 v2(127.87,48.14) ; 127.07,66.05 127.44,65.69 JDIMM2.199 v2(127.44,62.62)
  BOTTOM w0.381: Q343.6 40.63,106.05 R722.1 v3(40.61,105.35) ; v3(43.03,107.25) 43.04,107.25 Q343.3 ; QH4.5 38.91,84.77 39.32,85.18 39.32,85.69 ; C248.1 104.44,168.26 104.64,168.07 U3.5 ; R799.1 QH4.2 ; UC3.5 63.45,84.92 CH10.1
  BOTTOM w0.457: R78.1 287.4,67.4 v3(287.4,66.84)
  BOTTOM w0.508: 127.07,66.05 126.38,66.75 122.49,66.75 ; v3(280.24,69.56) 280.24,68.87 C497.1 ; C1159.1 78.13,151.88 v3(78.69,152.44) ; C1159.1 77.82,151.65 78.33,151.14 ; C1159.1 C1149.1 ; v3(279.37,77.31) 279.32,77.25 C496.1 ; C1181.1 91.57,102.15 v3(91.79,101.92) ; v3(60.7,77.71) 60.76,77.66 RH37.2 RH36.2 ; v3(277.7,71.46) 278.38,71.46 R80.1 ; RH200.1 61.34,73.44 v3(60.7,73.44) ; R118.2 R124.2 ; R124.2 R99.2 33.88,129.6 v3(33.27,130.21) ; R124.2 35.08,129.48 R117.2 34.54,130.9 33.32,130.9 v3(33.25,130.98) ; v3(31.85,130.09) R120.2 R119.2 ; R39.1 v3(182.85,30.09) ; v3(58.39,76.42) 58.55,76.26 RH228.2 ; R159.1 90.22,159.28 v3(90.44,159.07) ; R126.2 36.09,113.6 v3(35.66,114.03) ; CD87.1 CD88.1 127.52,46.39 v3(127.87,46.75) ; R1133.1 297.45,111.53 R1134.1 v3(296.74,111.52) ; v3(30.78,111.87) 30.76,111.87 30.33,112.31 R98.2 ; PR400.1 101.42,28.36 v3(101.19,28.13) ; v3(89.43,105.02) 90.12,105.02 R97.2 ; C748.1 v3(292.96,108.45) ; v3(184.89,30.09) R40.1 185.41,30.72 185.95,31.27 R84.1 ; R853.2 2.04,148.01 v3(2.36,147.69) 3.05,147.69 3.41,148.06 R852.2 ; R407.1 v3(235.36,80.58) ; v3(92.29,161.37) 93.47,161.37 93.94,160.9 93.94,156.69 93.09,155.84 R1123.1 ; R513.1 203.86,66.38 v3(203.53,66.71) ; v3(288.01,65.72) 287.83,65.55 R2191.1 286.1,65.55 284.07,63.51 284.07,59.78 284.68,59.17 R2190.1 ; R1197.1 R1118.1 v3(248.16,35.7) ; R415.1 291.2,67.54 v3(291.2,66.85) ; RH93.1 v3(69.01,83.58) ; R125.2 v4(88.53,106.36) 87.76,105.59 v3(87.76,104.64) ; v3(129.08,172.25) 129.01,172.25 128.24,171.49 R823.2 ; C359.1 v3(54.28,112.76) ; C499.1 v3(40.18,112.33) ; v3(117.27,142.13) 117.27,142.08 116.24,141.05 L60.2 ; R56.1 289.15,81.75 v3(289.13,81.78) ; R405.1 R403.1 R409.1 15.01,83.43 15.34,83.1 v3(16.1,83.1) ; R772.1 236.83,81.04 v3(236.96,81.17) ; C404.1 203.68,50.15 202.79,50.15 v3(202.74,50.2) ; v3(39.37,113.91) 38.81,113.35 R128.2 ; v3(58.39,74.36) RH224.1 59.08,74.36 RH208.2 ; R160.1 90.5,157.84 v3(90.61,157.95) ; v3(62.91,85.66) 63.42,85.15 CH10.1 ; R829.1 v3(233.78,44.77) R822.1 ; C494.1 30.96,118.35 v3(30.96,117.7) ; v2(130.3,157.51) 130.3,157.26 130.22,157.19 130.22,156.68 129.97,156.43 R824.2 ; RH229.2 60.7,71.44 v3(60.7,71.45) ; 39.32,85.69 v3(38.84,86.17) ; R41.1 v3(183.87,30.09) ; C783.1 39.33,126.61 C504.1 38.2,126.07 v3(38.43,125.84) ; v3(202.77,51.12) C403.1 R1635.1 ; RD36.2 v3(129.39,44.56) ; R408.1 235.43,81.6 v3(235.56,81.73) ; C248.1 104.47,168.95 v3(105.18,168.95) ; R1986.1 v3(249.53,36.69) ; RC19.1 v3(202.67,151.19) ; R1539.1 v3(71.22,108.83) ; R421.1 v3(96.45,100.19) ; C495.1 v3(31.42,124.65) ; R76.1 v3(277.7,72.33) ; v3(35.48,85.43) R799.1 ; RH225.2 v3(58.39,72.33) ; R1530.1 v3(74.78,112.79) ; R42.1 R46.1
  vias: v2(146.86,157.44) v2(147.52,157.44) v2(148.13,157.42) v3(6.83,116.4) v3(7.09,115.75) v3(13.44,116.4) v3(13.44,115.51) v3(14.07,115.76) v3(17.25,100.65) v3(17.88,99.89) v3(18.01,100.52) v3(20.78,65.77) v3(21.41,65.8) v3(22.07,65.81) v3(40,150.05) v3(40,149.42) v3(40.08,150.76) v3(64.18,152.87) v3(64.49,153.43) v3(64.79,154.01) v3(67.61,82.68) v3(67.61,82) v3(68.55,44.46) v3(69.26,44.46) v3(71.07,44.49) v3(71.7,44.49) v3(73.89,114.2) v3(74.26,151.4) v3(74.52,114.2) v3(76.25,152.49) v3(77.09,44.98) v3(77.72,44.98) v3(77.98,37.3) v3(78.36,44.98) v3(78.36,37.86) v3(78.64,37.28) v3(80.36,51.14) v3(82.35,51.18) v3(82.52,106.24) v3(82.9,93.82) v3(83.03,105.73) v3(83.06,94.88) v3(83.39,94.3) v3(83.54,105.09) v3(86.36,52.62) v3(86.97,52.92) v3(88.19,52.64) v3(90.45,52.77) v3(105.71,168.57) v3(106.27,168.95) v3(116.89,55.82) v3(117.35,55.36) v3(117.49,56.65) v3(117.49,56.02) v3(117.47,54.7) v3(119.48,103.57) v3(119.48,102.57) v3(119.48,101.93) v3(119.61,104.2) v3(119.99,62.68) v3(119.99,62.04) v3(120.12,103.57) v3(120.12,102.68) v3(120.37,64.07) v3(120.88,63.44) v3(120.88,61.79) v3(120.88,61.15) v3(121,71.44) v3(121.39,71.95) v3(121.51,63.06) v3(121.77,72.45) v3(123.29,74.49) v3(123.29,73.72) v3(123.29,73.09) v3(123.67,94.43) v3(123.67,93.79) v3(123.67,93.16) v3(123.93,76.39) v3(152.73,151.91) v3(153.39,151.91) v3(181.58,45.76) v3(182.35,45.76) v3(183.01,45.76) v3(203.22,67.37) v3(209.24,80.79) v3(209.68,80.25) v3(238.53,59.58) v3(239.34,59.58) v3(241.96,59.58) v3(246.4,79.87) v3(247.04,79.9) v3(259.82,57.09) v3(260.96,80.2) v3(261.59,80.23) v3(275.94,85.28) v3(275.94,84.52) v3(275.94,83.76) v3(286.57,135.61) v3(286.57,134.84) v3(286.57,134.08)
