# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C7.2 C8.2 C12.2 C13.2 C14.2 C15.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.1 C45.2 C46.2 C47.2 C48.2 C51.2 C54.2 C55.2 C56.2 C86.2 C87.2 C88.2 C90.2 C92.2 C94.2 C95.2 C96.2 C97.1 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C243.2 C244.2 C248.2 C249.1 C250.2 C274.2 C277.2 C287.2 C289.2 C290.2 C292.2 C296.2 C298.2 C299.2 C300.2 C301.2 C305.2 C310.2 C311.2 C313.2 C319.2 C320.2 C323.2 C324.2 C327.2 C328.2 C329.2 C330.2 C332.2 C343.2 C356.2 C359.2 C362.2 C364.2 C370.2 C391.2 C392.2 C395.2 C396.2 C400.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C415.2 C416.2 C417.1 C419.2 C420.2 C428.2 C429.2 C435.1 C436.2 C437.2 C449.2 C450.2 C453.2 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.1 C477.1 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C486.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C504.2 C513.2 C514.2 C536.2 C538.1 C539.2 C540.2 C541.2 C542.2 C543.1 C544.2 C545.1 C546.2 C547.2 C550.2 C551.2 C552.2 C553.2 C595.2 C601.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C621.2 C622.2 C623.2 C624.2 C628.2 C629.2 C630.2 C631.2 C633.2 C634.2 C637.1 C638.1 C639.2 C643.2 C645.2 C661.2 C662.2 C667.2 C668.2 C669.2 C670.2 C675.2 C676.2 C695.2 C696.2 C701.2 C702.2 C703.2 C704.2 C708.2 C709.2 C710.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C733.2 C734.2 C735.2 C736.2 C737.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C746.2 C747.2 C748.2 C753.2 C754.2 C756.2 C757.2 C758.2 C759.2 C762.2 C763.2 C764.2 C766.2 C767.2 C770.2 C772.2 C773.2 C774.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C793.2 C794.2 C1145.2 C1146.2 C1149.2 C1159.2 C1167.2 C1174.2 C1176.2 C1177.2 C1178.2 C1179.2 C1181.2 C1182.2 C1183.2 C1184.2 C1185.2 C1186.2 C1188.2 C1216.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1339.2 C1340.2 C1341.2 C1345.2 C1348.2 C1349.2 C1352.2 C1353.2 C1354.2 C1355.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC65.2 CC66.2 CC78.2 CC79.2 CC137.2 CC138.2 CC140.2 CC156.2 CC161.2 CC162.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC169.2 CC170.2 CC171.2 CC172.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD92.2 CE1.2 CE2.2 CE3.2 CE6.2 CE8.2 CE9.2 CH2.2 CH4.1 CH5.1 CH6.1 CH7.1 CH9.2 CH10.2 CH11.2 CH12.2 CH13.1 CH14.1 CH15.2 CH16.2 CH17.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH28.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH80.2 CH81.2 CH82.2 CH83.2 CMOS1.1 D14.3 D15.1 D16.3 D17.1 D33.1 D73.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) H27.1(TP-1) H28.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.17 JAPS1.18 JBT1.1 JBT1.10 JBT1.13 JBT1.14 JCAM1.5 JCAM1.9 JCAM1.10 JCAM1.12 JCAM1.14 JCAM1.15 JCAM1.21 JCAM1.22 JCPU1.A3 JCPU1.A4 JCPU1.A7 JCPU1.A10 JCPU1.A13 JCPU1.A16 JCPU1.A19 JCPU1.A22 JCPU1.A25 JCPU1.A27 JCPU1.A29 JCPU1.A31 JCPU1.A33 JCPU1.AA11 JCPU1.AA25 JCPU1.AA27 JCPU1.AA29 JCPU1.AA31 JCPU1.AA33 JCPU1.AA35 JCPU1.AB1 JCPU1.AB3 JCPU1.AB4 JCPU1.AB6 JCPU1.AB7 JCPU1.AB9 JCPU1.AB10 JCPU1.AC11 JCPU1.AC25 JCPU1.AC27 JCPU1.AC29 JCPU1.AC31 JCPU1.AC33 JCPU1.AC35 JCPU1.AD7 JCPU1.AD11 JCPU1.AE1 JCPU1.AE3 JCPU1.AE4 JCPU1.AE6 JCPU1.AE7 JCPU1.AE9 JCPU1.AE10 JCPU1.AE25 JCPU1.AE27 JCPU1.AE29 JCPU1.AE31 JCPU1.AE33 JCPU1.AE35 JCPU1.AF6 JCPU1.AF8 JCPU1.AF11 JCPU1.AG6 JCPU1.AG11 JCPU1.AG25 JCPU1.AG27 JCPU1.AG29 JCPU1.AG31 JCPU1.AG33 JCPU1.AG35 JCPU1.AH1 JCPU1.AH2 JCPU1.AH3 JCPU1.AH4 JCPU1.AH5 JCPU1.AH6 JCPU1.AH7 JCPU1.AH8 JCPU1.AH9 JCPU1.AH10 JCPU1.AJ5 JCPU1.AJ11 JCPU1.AK5 JCPU1.AK11 JCPU1.AK25 JCPU1.AK26 JCPU1.AK28 JCPU1.AK29 JCPU1.AK30 JCPU1.AK32 JCPU1.AK34 JCPU1.AL1 JCPU1.AL2 JCPU1.AL3 JCPU1.AL4 JCPU1.AL5 JCPU1.AL6 JCPU1.AL7 JCPU1.AL8 JCPU1.AL9 JCPU1.AL10 JCPU1.AL11 JCPU1.AL12 JCPU1.AL14 JCPU1.AL15 JCPU1.AL17 JCPU1.AL18 JCPU1.AL19 JCPU1.AL20 JCPU1.AL21 JCPU1.AL22 JCPU1.AL23 JCPU1.AL24 JCPU1.AL31 JCPU1.AL32 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM20 JCPU1.AM21 JCPU1.AM22 JCPU1.AM23 JCPU1.AM24 JCPU1.AM25 JCPU1.AM32 JCPU1.AN2 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN21 JCPU1.AN24 JCPU1.AN27 JCPU1.AN30 JCPU1.AN34 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP27 JCPU1.AP34 JCPU1.AP35 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AR26 JCPU1.AR28 JCPU1.AR31 JCPU1.AR34 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT21 JCPU1.AT24 JCPU1.AT27 JCPU1.AT30 JCPU1.AT32 JCPU1.AT33 JCPU1.AT34 JCPU1.B2 JCPU1.B4 JCPU1.B7 JCPU1.B10 JCPU1.B13 JCPU1.B16 JCPU1.B19 JCPU1.B22 JCPU1.B34 JCPU1.C1 JCPU1.C2 JCPU1.C4 JCPU1.C7 JCPU1.C10 JCPU1.C13 JCPU1.C16 JCPU1.C19 JCPU1.C22 JCPU1.C24 JCPU1.C26 JCPU1.C28 JCPU1.C30 JCPU1.C32 JCPU1.C34 JCPU1.D4 JCPU1.D7 JCPU1.D10 JCPU1.D13 JCPU1.D16 JCPU1.D19 JCPU1.D22 JCPU1.D25 JCPU1.D27 JCPU1.D29 JCPU1.D31 JCPU1.D33 JCPU1.D35 JCPU1.E1 JCPU1.E4 JCPU1.E7 JCPU1.E10 JCPU1.E13 JCPU1.E16 JCPU1.E19 JCPU1.E22 JCPU1.E25 JCPU1.F4 JCPU1.F6 JCPU1.F7 JCPU1.F8 JCPU1.F9 JCPU1.F10 JCPU1.F11 JCPU1.F12 JCPU1.F14 JCPU1.F15 JCPU1.F17 JCPU1.F18 JCPU1.F19 JCPU1.F20 JCPU1.F21 JCPU1.F23 JCPU1.F24 JCPU1.F26 JCPU1.F28 JCPU1.F30 JCPU1.F32 JCPU1.F34 JCPU1.G1 JCPU1.G2 JCPU1.G3 JCPU1.G4 JCPU1.G5 JCPU1.G11 JCPU1.G27 JCPU1.G29 JCPU1.G31 JCPU1.G33 JCPU1.G35 JCPU1.H6 JCPU1.H7 JCPU1.H10 JCPU1.H11 JCPU1.H26 JCPU1.J6 JCPU1.J11 JCPU1.J26 JCPU1.J28 JCPU1.J30 JCPU1.J32 JCPU1.J34 JCPU1.K1 JCPU1.K2 JCPU1.K3 JCPU1.K4 JCPU1.K5 JCPU1.K7 JCPU1.K8 JCPU1.K9 JCPU1.K10 JCPU1.K29 JCPU1.K31 JCPU1.K33 JCPU1.K35 JCPU1.L6 JCPU1.L11 JCPU1.L26 JCPU1.M6 JCPU1.M11 JCPU1.M26 JCPU1.M28 JCPU1.M30 JCPU1.M32 JCPU1.M34 JCPU1.N1 JCPU1.N2 JCPU1.N3 JCPU1.N4 JCPU1.N5 JCPU1.N6 JCPU1.N7 JCPU1.N9 JCPU1.N10 JCPU1.N29 JCPU1.N31 JCPU1.N33 JCPU1.N35 JCPU1.P5 JCPU1.P11 JCPU1.P26 JCPU1.R5 JCPU1.R10 JCPU1.R11 JCPU1.R26 JCPU1.R28 JCPU1.R30 JCPU1.R32 JCPU1.R34 JCPU1.T1 JCPU1.T3 JCPU1.T4 JCPU1.T6 JCPU1.T7 JCPU1.T9 JCPU1.T10 JCPU1.T26 JCPU1.T29 JCPU1.T31 JCPU1.T33 JCPU1.T35 JCPU1.U11 JCPU1.U27 JCPU1.V10 JCPU1.V11 JCPU1.V28 JCPU1.V30 JCPU1.V32 JCPU1.V34 JCPU1.W1 JCPU1.W3 JCPU1.W4 JCPU1.W6 JCPU1.W7 JCPU1.W9 JCPU1.W10 JCPU1.W25 JCPU1.W33 JCPU1.W35 JCPU1.Y11 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JCRT1.18 JCRT1.19 JDEG2.1 JDEG2.11 JDEG2.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDIMM3.2 JDIMM3.3 JDIMM3.8 JDIMM3.9 JDIMM3.11 JDIMM3.13 JDIMM3.14 JDIMM3.19 JDIMM3.20 JDIMM3.25 JDIMM3.26 JDIMM3.28 JDIMM3.31 JDIMM3.32 JDIMM3.37 JDIMM3.38 JDIMM3.43 JDIMM3.44 JDIMM3.46 JDIMM3.48 JDIMM3.49 JDIMM3.54 JDIMM3.55 JDIMM3.60 JDIMM3.61 JDIMM3.63 JDIMM3.65 JDIMM3.66 JDIMM3.71 JDIMM3.72 JDIMM3.127 JDIMM3.128 JDIMM3.133 JDIMM3.134 JDIMM3.136 JDIMM3.138 JDIMM3.139 JDIMM3.144 JDIMM3.145 JDIMM3.150 JDIMM3.151 JDIMM3.153 JDIMM3.155 JDIMM3.156 JDIMM3.161 JDIMM3.162 JDIMM3.167 JDIMM3.168 JDIMM3.170 JDIMM3.172 JDIMM3.173 JDIMM3.178 JDIMM3.179 JDIMM3.184 JDIMM3.185 JDIMM3.187 JDIMM3.189 JDIMM3.190 JDIMM3.195 JDIMM3.196 JDIMM3.205 JDIMM3.206 JDIMM4.2 JDIMM4.3 JDIMM4.8 JDIMM4.9 JDIMM4.11 JDIMM4.13 JDIMM4.14 JDIMM4.19 JDIMM4.20 JDIMM4.25 JDIMM4.26 JDIMM4.28 JDIMM4.31 JDIMM4.32 JDIMM4.37 JDIMM4.38 JDIMM4.43 JDIMM4.44 JDIMM4.46 JDIMM4.48 JDIMM4.49 JDIMM4.54 JDIMM4.55 JDIMM4.60 JDIMM4.61 JDIMM4.63 JDIMM4.65 JDIMM4.66 JDIMM4.71 JDIMM4.72 JDIMM4.127 JDIMM4.128 JDIMM4.133 JDIMM4.134 JDIMM4.136 JDIMM4.138 JDIMM4.139 JDIMM4.144 JDIMM4.145 JDIMM4.150 JDIMM4.151 JDIMM4.153 JDIMM4.155 JDIMM4.156 JDIMM4.161 JDIMM4.162 JDIMM4.167 JDIMM4.168 JDIMM4.170 JDIMM4.172 JDIMM4.173 JDIMM4.178 JDIMM4.179 JDIMM4.184 JDIMM4.185 JDIMM4.187 JDIMM4.189 JDIMM4.190 JDIMM4.195 JDIMM4.196 JDIMM4.205 JDIMM4.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JDP1.2 JDP1.5 JDP1.8 JDP1.11 JDP1.16 JDP1.19 JDP1.21 JDP1.22 JDP1.23 JDP1.24 JEDP1.9 JEDP1.10 JEDP1.11 JEDP1.19 JEDP1.23 JEDP1.25 JEDP1.28 JEDP1.31 JEDP1.34 JEDP1.37 JEDP1.40 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JESA1.4 JESA1.5 JESA1.8 JESA1.11 JESA1.12 JESA1.13 JESA1.14 JESA1.15 JFAN1.1 JFAN1.5 JFAN1.6 JFAN2.1 JFAN2.5 JFAN2.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.1 JIO1.4 JIO1.6 JIO1.7 JIO1.8 JIO1.12 JIO1.13 JIO1.18 JIO1.19 JIO1.24 JIO1.25 JIO1.30 JIO1.33 JIO1.39 JIO1.40 JIO1.45 JIO1.46 JIO1.51 JIO1.56 JIO1.62 JIO1.68 JIO1.74 JIO1.80 JIO1.82 JIO1.86 JIO1.87 JIO1.112 JIO1.118 JIO1.119 JIO1.121 JIO1.123 JIO1.125 JIO1.127 JIO1.130 JIO1.132 JIO1.134 JIO1.135 JIO1.137 JIO1.138 JIO1.139 JIO1.140 JIO1.141 JIO1.142 JKB1.15 JKB1.16 JKB1.19 JKB1.20 JLOM1.14 JLOM1.15 JLVDS1.9 JLVDS1.10 JLVDS1.11 JLVDS1.17 JLVDS1.20 JLVDS1.27 JLVDS1.30 JLVDS1.37 JLVDS1.40 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JLVDS1.45 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JMINI3.54 JMINI4.4 JMINI4.9 JMINI4.15 JMINI4.18 JMINI4.21 JMINI4.26 JMINI4.27 JMINI4.29 JMINI4.34 JMINI4.35 JMINI4.43 JMINI4.50 JMINI4.53 JMINI4.54 JMXM1.19 JMXM1.20 JMXM1.21 JMXM1.22 JMXM1.23 JMXM1.24 JMXM1.25 JMXM1.26 JMXM1.27 JMXM1.28 JMXM1.29 JMXM1.30 JMXM1.31 JMXM1.32 JMXM1.33 JMXM1.34 JMXM1.35 JMXM1.36 JMXM1.47 JMXM1.49 JMXM1.51 JMXM1.53 JMXM1.72 JMXM1.73 JMXM1.82 JMXM1.83 JMXM1.88 JMXM1.89 JMXM1.94 JMXM1.95 JMXM1.100 JMXM1.101 JMXM1.106 JMXM1.107 JMXM1.112 JMXM1.113 JMXM1.118 JMXM1.119 JMXM1.124 JMXM1.125 JMXM1.130 JMXM1.131 JMXM1.136 JMXM1.137 JMXM1.142 JMXM1.143 JMXM1.148 JMXM1.149 JMXM1.154 JMXM1.155 JMXM1.160 JMXM1.161 JMXM1.162 JMXM1.163 JMXM1.168 JMXM1.169 JMXM1.174 JMXM1.175 JMXM1.180 JMXM1.181 JMXM1.187 JMXM1.194 JMXM1.202 JMXM1.203 JMXM1.208 JMXM1.209 JMXM1.214 JMXM1.215 JMXM1.220 JMXM1.221 JMXM1.226 JMXM1.227 JMXM1.232 JMXM1.233 JMXM1.238 JMXM1.239 JMXM1.244 JMXM1.245 JMXM1.250 JMXM1.251 JMXM1.256 JMXM1.272 JMXM1.278 JMXM1.281 JMXM1.284 JMXM1.287 JMXM1.290 JMXM1.293 JMXM1.296 JMXM1.299 JMXM1.305 JMXM1.311 JMXM1.312 JODD1.1 JODD1.4 JODD1.7 JODD1.12 JODD1.13 JODD1.14 JODD1.15 JPB1.5 JPB1.6 JPB1.7 JPB1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.11 JSATA2.13 JSATA2.17 JSATA2.19 JSATA2.23 JSATA2.24 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSPI1.17 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSH1.1 JUSH1.4 JUSH1.18 JUSH1.19 JUSH1.21 JUSH1.22 JUSH1.23 JUSH1.24 JWL1.1 JWL1.4 JWL1.5 JXDP1.2 JXDP1.8 JXDP1.18 JXDP1.21 JXDP1.24 JXDP1.27 JXDP1.28 JXDP1.29 JXDP1.30 JXDP2.1 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 JXDP2.60 ME1.1 PBATT1.6 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC4.2 PC5.2 PC8.2 PC11.2 PC14.2 PC15.2 PC16.2 PC17.1 PC18.2 PC19.2 PC20.2 PC21.2 PC30.2 PC31.2 PC101.2 PC102.2 PC104.2 PC105.2 PC106.2 PC109.2 PC110.2 PC114.1 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC199.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC207.2 PC208.2 PC209.2 PC210.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC307.2 PC308.2 PC309.2 PC400.2 PC403.2 PC404.2 PC406.2 PC407.2 PC500.2 PC502.2 PC503.2 PC504.2 PC508.1 PC509.1 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC519.2 PC525.1 PC526.1 PC527.1 PC529.2 PC530.2 PC531.2 PC533.2 PC534.2 PC535.2 PC542.1 PC546.1 PC547.2 PC701.2 PC702.1 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC715.2 PC717.2 PC718.2 PC719.2 PC727.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC733.1 PC735.2 PC736.2 PC744.1 PC745.2 PC746.2 PC783.2 PC786.2 PC791.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1080.1 PC1081.1 PD2.1 PD3.1 PD8.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.11 PQ3.3 PQ7.3 PQ8.6 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.2 PQ104.3 PQ202.1 PQ202.2 PQ202.3 PQ204.1 PQ204.4 PQ205.1 PQ205.4 PQ303.1 PQ303.2 PQ303.3 PQ323.3 PQ500.8 PQ501.8 PQ502.8 PQ503.8 PQ504.8 PQ505.8 PQ705.1 PQ705.2 PQ705.3 PQ706.1 PQ706.4 PQ707.1 PQ707.4 PQ708.1 PQ708.4 PQ1010.3 PQ1011.3 PQ1071.1 PQ1071.4 PQ1080.1 PQ1080.4 PQ1082.3 PQ1083.6 PR12.1 PR18.2 PR19.2 PR22.2 PR26.2 PR102.1 PR104.1 PR105.2 PR106.2 PR207.1 PR217.2 PR220.2 PR224.2 PR225.2 PR302.1 PR305.2 PR307.1 PR404.2 PR405.2 PR507.1 PR509.1 PR514.1 PR515.2 PR521.2 PR525.1 PR529.1 PR542.2 PR554.2 PR558.1 PR717.2 PR732.1 PR744.2 PR745.2 PR746.2 PR748.2 PR758.2 PR1001.2 PR1003.2 PR1018.2 PR1026.1 PR1028.2 PR1031.1 PU1.2 PU2.4 PU101.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU400.11 PU500.33 PU501.4 PU501.9 PU700.4 PU700.14 PU700.21 PU701.1 PU701.2 PU703.4 PU704.3 PU1001.5 PU1001.14 PU1001.23 PU1001.32 PU1001.37 PU1080.3 PU1081.3 PWRSW1.2 Q22.3 Q29.1 Q29.4 Q45.3 Q47.3 Q52.3 Q55.3 Q70.3 Q81.4 Q87.3 Q110.1 Q110.4 Q304.1 Q304.4 Q318.4 Q326.3 Q336.1 Q336.4 Q338.3 Q339.1 Q339.4 Q347.1 Q347.4 QC1.3 QC5.3 QC6.3 QH3.3 R17.1 R45.1 R49.1 R51.2 R53.2 R54.2 R55.2 R57.1 R59.1 R60.2 R61.1 R62.1 R63.1 R66.1 R67.1 R69.1 R73.1 R74.1 R75.1 R77.2 R79.2 R81.2 R82.2 R85.1 R86.2 R87.2 R88.2 R89.2 R90.1 R96.1 R100.1 R101.1 R102.1 R103.1 R104.1 R105.1 R106.1 R107.1 R108.1 R115.2 R116.2 R121.2 R122.2 R123.2 R127.1 R131.1 R135.2 R222.1 R301.2 R336.1 R404.2 R406.2 R424.2 R425.2 R431.2 R432.1 R491.1 R492.1 R493.1 R514.2 R519.1 R557.2 R558.2 R561.2 R562.2 R657.2 R717.2 R720.2 R733.2 R739.2 R747.2 R757.2 R758.2 R773.1 R775.1 R783.2 R793.2 R801.1 R803.2 R804.2 R808.2 R809.1 R812.1 R836.2 R840.2 R843.1 R851.2 R869.1 R876.2 R879.1 R889.1 R892.1 R904.2 R931.2 R935.2 R1069.2 R1128.2 R1137.2 R1138.2 R1139.2 R1140.2 R1207.1 R1611.2 R1613.1 R1970.1 R1971.1 R1989.2 R1991.1 R1993.1 R1995.2 R2160.2 R2186.1 R2187.1 R2200.1 R2201.1 RC11.2 RC14.2 RC40.1 RC41.1 RC42.2 RC45.2 RC49.2 RC55.2 RC58.2 RC59.2 RC70.2 RC71.2 RC72.2 RC75.2 RC76.2 RC77.2 RC83.2 RC85.2 RC86.2 RC109.2 RC110.2 RC111.2 RC130.2 RD13.1 RD19.1 RD20.1 RD30.2 RD37.1 RD43.2 RD46.2 RD49.2 RH18.2 RH47.2 RH53.1 RH54.2 RH55.2 RH56.2 RH70.2 RH76.2 RH81.1 RH89.1 RH97.1 RH115.1 RH116.1 RH117.1 RH118.1 RH119.2 RH132.2 RH146.2 RH150.2 RH151.2 RH167.2 RH169.2 RH176.2 RH187.2 RH218.2 RH219.1 RH223.2 RH226.2 RH227.2 RH230.2 RH231.2 RP4.5 RP4.6 RP4.7 RP4.8 RP7.1 RP7.2 RP7.3 RP7.4 RP8.6 RP8.7 RP8.8 RPH3.5 RPH3.6 RPH3.7 RPH3.8 SW1.1 SW1.3 U2.9 U3.3 U5.2 U6.2 U9.26 U9.35 U9.38 U9.43 U9.57 U10.3 U11.11 U11.37 U12.3 U13.11 U13.37 U14.3 U15.3 U16.3 U17.3 U18.2 U19.10 U19.20 U19.30 U19.41 U20.7 U22.3 U22.18 U22.24 U22.31 U22.49 U23.6 U23.49 U25.3 U26.3 U26.13 U26.21 U27.3 U28.2 U29.2 U29.3 U29.6 U29.33 U30.2 U31.49 U32.43 U33.2 U34.5 U34.9 U35.5 U35.9 U36.11 U36.15 U37.11 U37.15 U39.1 U39.2 U39.3 U39.4 U39.8 U39.11 U39.18 U39.25 U40.11 U40.15 U42.5 U42.9 U43.5 U43.9 U44.3 U44.13 U44.17 U44.21 U45.1 U45.11 U46.B27 U46.C1 U48.1 U48.11 U49.5 U49.9 U50.3 U51.B11 U51.B18 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U54.3 U55.3 U57.5 U57.9 U58.3 U59.1 U59.2 U60.3 U63.5 U63.9 U88.5 U88.10 U88.12 U88.13 U88.15 U88.16 U625.10 U625.21 U625.25 U629.8 U629.18 U629.33 U629.41 U629.53 U629.57 U629.61 UC1.3 UC2.3 UC3.3 UH1.A2 UH1.A4 UH1.A5 UH1.A41 UH1.A43 UH1.A44 UH1.AA4 UH1.AA16 UH1.AA20 UH1.AA22 UH1.AA28 UH1.AB8 UH1.AB12 UH1.AB34 UH1.AB38 UH1.AC2 UH1.AC44 UH1.AD6 UH1.AD8 UH1.AD14 UH1.AD16 UH1.AD18 UH1.AD30 UH1.AD32 UH1.AD40 UH1.AE16 UH1.AE28 UH1.AF8 UH1.AF38 UH1.AG2 UH1.AG16 UH1.AG26 UH1.AG28 UH1.AG44 UH1.AJ6 UH1.AJ8 UH1.AJ16 UH1.AJ18 UH1.AJ20 UH1.AJ22 UH1.AJ24 UH1.AJ34 UH1.AJ38 UH1.AK14 UH1.AK16 UH1.AK24 UH1.AK43 UH1.AK45 UH1.AL2 UH1.AL8 UH1.AL12 UH1.AL34 UH1.AL38 UH1.AM14 UH1.AM16 UH1.AM24 UH1.AM26 UH1.AM28 UH1.AM30 UH1.AM32 UH1.AN8 UH1.AN36 UH1.AN40 UH1.AN42 UH1.AP13 UH1.AP24 UH1.AP31 UH1.AP43 UH1.AR2 UH1.AT10 UH1.AT15 UH1.AT17 UH1.AT20 UH1.AT26 UH1.AT29 UH1.AT36 UH1.AT38 UH1.AT43 UH1.AV6 UH1.AV7 UH1.AV13 UH1.AV22 UH1.AV24 UH1.AV31 UH1.AV33 UH1.AV40 UH1.AW2 UH1.AY7 UH1.AY10 UH1.AY15 UH1.AY20 UH1.AY26 UH1.AY29 UH1.AY36 UH1.B1 UH1.B2 UH1.B7 UH1.B11 UH1.B15 UH1.B19 UH1.B23 UH1.B27 UH1.B31 UH1.B35 UH1.B39 UH1.B44 UH1.B45 UH1.BA1 UH1.BA40 UH1.BB25 UH1.BB42 UH1.BC1 UH1.BC16 UH1.BC22 UH1.BC28 UH1.BD1 UH1.BD2 UH1.BD7 UH1.BD11 UH1.BD15 UH1.BD19 UH1.BD31 UH1.BD35 UH1.BD39 UH1.BD44 UH1.BD45 UH1.BE2 UH1.BE3 UH1.BE41 UH1.C45 UH1.D1 UH1.D4 UH1.D25 UH1.D42 UH1.E1 UH1.E45 UH1.F15 UH1.F20 UH1.F29 UH1.F33 UH1.F43 UH1.G2 UH1.G8 UH1.G38 UH1.G44 UH1.H7 UH1.H10 UH1.H13 UH1.H17 UH1.H22 UH1.H24 UH1.H26 UH1.H31 UH1.H36 UH1.H40 UH1.K10 UH1.K15 UH1.K20 UH1.K29 UH1.K33 UH1.K39 UH1.L2 UH1.L44 UH1.M17 UH1.M22 UH1.M24 UH1.N6 UH1.N10 UH1.N12 UH1.N35 UH1.N39 UH1.P22 UH1.P24 UH1.P26 UH1.P28 UH1.P30 UH1.P32 UH1.P43 UH1.R2 UH1.R8 UH1.R12 UH1.R14 UH1.R16 UH1.R34 UH1.R38 UH1.R44 UH1.T43 UH1.U6 UH1.U10 UH1.U16 UH1.U28 UH1.U34 UH1.U38 UH1.U39 UH1.U42 UH1.V14 UH1.V16 UH1.V26 UH1.V43 UH1.W2 UH1.W44 UH1.Y8 UH1.Y14 UH1.Y16 UH1.Y24 UH1.Y28 UH1.Y34 UH1.Y36 UH1.Y40 UH2.3 UH3.3 Y3.2 Y3.4 YH2.2 YH2.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
V1N: PR516.1 PR546.2
V2N: PR518.1 PR556.2
V3N: PR547.2 PR557.2
VCC_PGOOD: PR522.2 PU500.3
VCCPWRGOOD_0_R: JCPU1.AL34 RC25.2 RC130.1
VCCSENSE: PC520.1 PC542.2 PC544.1 PR536.1 RC66.2 RC67.2
VCCSENSE_R: JCPU1.AL35 RC67.1
VDD_1.35V: PC210.1 PR201.1 PR203.2 PU200.11
VDD_PWRGD: R389.2 U29.13
VSSSENSE: PC544.2 PC546.2 PU500.13 RC68.2 RC70.1
VSSSENSE_R: JCPU1.AK35 RC68.1
3301_ACAV_IN_NB: PR1019.1 PU1001.24
3301_DC_IN_SS: PR1010.2 PU1001.34
3301_PWRSRC: PR1029.1 PU1001.15
24737_BST_CHG_MODE#: PQ707.2 PR718.1 PR757.2 PU700.11
+ADDR_XEN: R393.1 U29.32
+BL_PWR_SRC: C249.2 C250.1 C296.1 JEDP1.4 JEDP1.5 JEDP1.6 JEDP1.7 JLVDS1.4 JLVDS1.5 JLVDS1.6 JLVDS1.7 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JCAM1.18 JCAM1.20 Q24.1
+CAP_LDO: C714.1 U46.B46
+CHAGER_SRC: PC705.1 PC706.1 PC707.1 PC708.1 PL700.1 PQ704.5
+CHG_VCC: PD701.1 PR775.2
+COINCELL: JRTC1.1 PR1.1
+CRT_VCC: C14.1 JCRT1.9 R47.1 R48.1 R50.1 R52.1 U6.3
+DC1_PWR_SRC: PC104.1 PC105.1 PC106.1 PC109.1 PC110.1 PC117.1 PL100.1 PQ101.5 PQ102.5 PU101.12
+DC_IN: PC9.2 PC15.1 PL4.2 PQ5.1 PQ5.2 PQ5.3 PQ8.3 PR16.1 PR19.1 PR736.1 PR1011.1
+DC_IN_SS: PC14.1 PD700.2 PD701.3 PQ5.5 PQ701.5 PR18.1 PR1010.1
+DCIN_JACK: PC11.1 PD8.1 PJPDC1.7 PJPDC1.8 PJPDC1.9 PJPDC1.10 PL4.1
+DIMM1_VREF_CA: CD15.1 CD16.1 JDIMM1.126 RD7.1
+DIMM1_VREF_DQ: CD1.1 CD6.1 JDIMM1.1 RD1.2 RD2.2
+DIMM2_VREF_CA: CD41.1 CD42.1 JDIMM2.126 RD16.1
+DIMM2_VREF_DQ: CD23.1 CD24.1 JDIMM2.1 RD14.2 RD15.2
+DIMM3_VREF_CA: CD63.1 CD64.1 JDIMM3.126 RD25.1
+DIMM3_VREF_DQ: CD45.1 CD49.1 JDIMM3.1 RD23.2 RD24.2
+DIMM4_VREF_CA: CD85.1 CD86.1 JDIMM4.126 RD34.1
+DIMM4_VREF_DQ: CD67.1 CD68.1 JDIMM4.1 RD32.2 RD33.2
+DOCK_PWR_BAR: C702.1 C703.1 CE6.1 D33.2 D33.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD701.2 PD1001.2 PD1001.3 PQ1001.5 PQ1008.5 PR1001.1 PR1007.1
+DP_VCC: C313.1 C482.1 F3.1 JDP1.20 U30.3
+EDPVDD: C305.1 C396.1 JEDP1.13 JEDP1.14 JEDP1.15 JEDP1.16 U33.1
+LCDVDD: C298.1 C540.1 JLVDS1.13 JLVDS1.14 JLVDS1.15 U28.1
+LOM_VCT: C701.1 JDOCK1.116 JDOCK1.118
+MXM_PWR: PJP78.1 PJP79.1 PR25.4 Q186.5 Q186.6 Q186.7 Q186.8
+MXM_PWR_R: PC6.2 PR14.2 R2180.1 U59.4
+MXM_PWR_SRC: C1.1 C2.1 C3.1 C4.1 C776.1 JMXM1.1 JMXM1.2 JMXM1.3 JMXM1.4 JMXM1.5 JMXM1.6 JMXM1.7 JMXM1.8 JMXM1.9 JMXM1.10 JMXM1.11 JMXM1.12 JMXM1.13 JMXM1.14 JMXM1.15 JMXM1.16 JMXM1.17 JMXM1.18 PJP78.2 PJP79.2 PR25.1 R935.1
+MXM_PWR_SRC_A0: R2185.1 R2187.2 U60.7
+MXM_PWR_SRC_A1: R2184.1 R2186.2 U60.8
+MXM_PWR_SRC_R: PC6.1 PR24.2 R2181.1 U59.5
+MXM_SRC_EN#: C774.1 Q186.4 R940.2 R944.1
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ1070.1 PR1024.2
+PCH_DCPRTC: CH54.1 UH1.P14 UH1.P16
+PCH_USB_DCPSUS1: CH39.1 RH234.2 UH1.Y12
+PCH_USB_DCPSUS2: CH58.1 RH239.2 UH1.Y35
+PCH_USB_DCPSUS3: CH41.1 CH42.1 RH236.1 UH1.AJ26 UH1.AJ28
+PCH_VCC: CH63.1 CH64.1 LH2.2 UH1.AP45
+PCH_VCCCFUSE: CH66.1 RH242.2 RH243.2 UH1.P18 UH1.P20
+PCH_VCCCLK: CH67.1 CH68.1 CH69.1 CH70.1 CH71.1 RH244.2 UH1.AA30 UH1.AA32 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AE30 UH1.AE32 UH1.AG30 UH1.AG32 UH1.Y32
+PCH_VCCCLK3_3: CH72.1 CH73.1 CH74.1 CH75.1 RH245.2 UH1.L26 UH1.L29 UH1.M26 UH1.M29 UH1.U32 UH1.V32
+PCH_VCCDSW: RH232.2 UH1.U14
+PCH_VCCDSW3_3: CC156.1 CH44.1 JAPS1.3 R835.1 RC18.1 RC47.1 RH78.1 RH80.1 RH112.1 RH216.2 RH217.2 RH237.2 RH238.2 UC2.5 UH1.A16
+PCH_VCCDSW_R: CH40.1 RH232.1
+PCH_VCCSST: CH46.1 UH1.AA14
+PECI_VREF: C740.1 R866.1 U51.B51
+PWR_SRC: C297.1 PC7.1 PC1001.1 PC1002.1 PC1003.1 PD1001.1 PD1002.1 PJP200.2 PJP300.1 PL1.1 PL100.2 PL510.2 PL700.2 PQ4.3 PQ1001.1 PQ1001.2 PQ1001.3 PQ1004.1 PQ1004.2 PQ1004.3 PR15.1 PR701.4 PR1029.2 Q21.4 R422.1 R933.1
+PWR_SRC_MXM: PC1.1 PC30.1 PC31.1 PL1.2 Q186.1 Q186.2 Q186.3 R940.1
+PWR_SRC_S: PC8.1 PQ4.1 R930.1
+RSVD_VCC3P3_2: R554.2 U31.1
+RTC_CELL: C274.1 C287.1 CH55.1 CH56.1 CH57.1 JIO1.136 PC2.1 PD1.1 R390.2 R810.1 R819.1 R870.1 R880.1 R1985.1 RH5.1 RH42.1 RH43.1 RH44.1 RH67.2 U10.5 U29.16 UH1.A6
+RTC_CELL_VBAT: C1353.1 R1985.2 U51.B64
+SA_DIMM1_VREFDQ: RD1.1 RD14.1 RD41.2 RD43.1 RD44.2
+SA_DIMM_VREFDQ: JCPU1.F16 QD6.1 RD9.1
+SA_DIMM_VREFDQ_Q: CD89.1 QD6.6 RD9.2 RD41.1
+SB_DIMM2_VREFDQ: RD23.1 RD32.1 RD48.2 RD49.1 RD50.2
+SB_DIMM_VREFDQ: JCPU1.F13 QD6.4 RD11.1
+SB_DIMM_VREFDQ_Q: CD91.1 QD6.3 RD11.2 RD48.1
+SDC_IN: PC700.1 PC701.1 PD700.1 PQ701.1 PQ701.2 PQ701.3 PR701.1 PR762.1 PR1015.1 PU701.3
+SIM_PWR: C616.1 C643.1 C645.1 JMINI1.8 JSIM1.1
+SM_VREF: JCPU1.AM3 QD7.3 RD10.1
+SM_VREF_DIMM: RD7.2 RD16.2 RD25.2 RD34.2 RD45.2 RD46.1 RD47.2
+SM_VREF_Q: CD90.1 QD7.1 RD10.2 RD45.1
+SW_LX: L62.2 R550.2 U23.17
+SWR_V12: C109.1 C110.1 C111.1 C112.1 L62.1 R550.1 U23.11 U23.15 U23.43
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C484.1 T156.9
+TRM_CT4: C486.1 T156.10
+UIM_VPP: C630.1 JMINI1.16 JSIM1.6
+USB1_REPEATER_VDD: C450.1 C453.1 PJP34.1 Q90.1 R12.1 R15.1 R16.1 R18.1 R21.1 R22.1 R23.1 R24.1 R25.1 R94.1 U625.1 U625.13
+UTLGND: R1989.1 U23.16
+V_DDR_REF: PC209.1 PU200.4 RD2.1 RD15.1 RD24.1 RD33.1
+VCHGR: PC715.1 PC718.1 PC719.1 PQ1005.1 PQ1005.2 PQ1005.3 PQ1009.5 PQ1083.3 PR723.4
+VCOMP_OUT: JCPU1.F22 RC1.1 RC2.1
+VDISPLAY_VCC: C46.1 C47.1 JHDMI1.18 R460.1 R461.1 U5.3
+VR_CAP: C779.1 U51.B12
+VTR_ADC: C736.1 C757.1 R845.2 U51.A58
A_ON: PR315.2 R432.2 R878.1 U51.B24
A_ON_R: R877.2 R878.2 U40.3
A_PRE0: R42.2 R88.1 U26.9
A_PRE1: R40.2 R89.1 U26.17
AC_DIS: PQ8.5 PR1030.2 U46.B12
AC_PRESENT: R835.2 U51.A54 UH1.E6
ACAV_DOCK_SRC#: JDOCK1.42 PR1013.2 PR1017.1
ACAV_IN: PQ707.3 PQ708.2 PR717.1 PR772.2 PR1021.1 U17.1 U29.21 U51.A64
ACAV_IN_NB: PR742.1 PR1019.2 U51.B20
ACAVDK_SRC: PR1017.2 PU1001.4
ACAVIN: PR1021.2 PU1001.8
ACDET: PC783.1 PR732.2 PR762.2 PU700.6
ACPRN: PQ707.5 PR771.2 PU700.5
ADP_I: PC746.1 PR702.1 PR704.1 PR743.1 R134.1
ADP_I_R: R134.2 U51.A12
ALERT#: PR503.1 PR506.2 PU500.32
ALW_PWRGD_3V_5V: PR118.1 U51.A1
ALWON: PR112.1 U51.A60
AUD_HP_NB_SENSE: JIO1.69 U46.A41
AUD_NB_MUTE#: JIO1.27 U46.A39
AUDIO_BACKLITE#: JIO1.71 U46.B68
AUX_EN_WOWL: R839.1 U46.B67
AUX_EN_WOWL_R: R717.1 R815.2 R839.2 U42.3
AUX_MOD_EN: RP8.1 U46.A45
B_PRE0: R46.2 R87.1 U26.8
B_PRE1: R39.2 R82.1 U26.19
BAT1_LED#: JIO1.104 U46.B64
BAT2_LED#: JIO1.102 U46.A9
BBS_BIT0_R: QH5.1 RH13.1 RH37.1 UH1.AU2
BBS_BIT1: RH119.1 UH1.C10
BC_CLK_ECE1117: JKB1.17 JKB1.18 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_DAT_ECE1117: JKB1.13 JKB1.14 R817.2 U51.B21
BC_DAT_ECE5048: R814.2 U46.B31 U51.B45
BC_INT#_ECE1117: JKB1.11 JKB1.12 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BCM5882_ALERT#: JUSH1.7 U46.B62
BEEP: JIO1.29 U51.B19
BIA_PWM_EC: D71.2 U51.B25
BIA_PWM_LVDS: D66.1 D68.1 D71.1 R207.2 R208.1 R1137.1
BIA_PWM_PCH: R1996.1 UH1.N36
BIA_PWM_PCH_R: R127.2 R1996.2 U23.21
BIA_PWM_SW: D66.2 U23.19
BLK_MOSFET_GC: PR1006.2 PU1001.30
BLKNG_MOSFET_GC: PR1009.2 PU1001.20
BLUE_CRT: C22.1 L3.1 R55.1 U19.31
BLUE_CRT_L: C13.1 JCRT1.3 L3.2
BLUE_DOCK: JDOCK1.45 U19.22
BOARD_ID: C744.1 R875.2 U51.B10
BOOT1: PR549.2 PU500.18
BOOT2: PR534.2 PU500.27
BOOT3: PR502.2 PU501.2
BOOT_1.35V: PR200.2 PU200.18
BQ24737_VDD: PC745.1 PD703.2 PR738.1 PR771.1 PR772.1 PU700.16
BREATH_LED#: JDOCK1.98 Q84.1 Q84.4 U46.B39
BREATH_LED#_Q: JIO1.98 R955.2
BREATH_WHITE_LED: JPB1.4 R956.2
BST1_3V: PC112.2 PR108.1
BST1_5V: PC111.1 PR107.2
BST_3V: PR108.2 PU101.9
BST_5V: PR107.1 PU101.17
BST_+1.05VSP: PR301.1 PU300.10
BST_CHG: PD703.1 PR765.1 PU700.17
BST_CHG_IMON: PR705.1 U51.B61
BST_CHG_MODE#: PR716.2 PR718.2 U46.B15
BT_ACTIVE: JBT1.6 Q318.5
BT_COEX_STATUS2: JBT1.4 R221.1 R1133.2
BT_LED: JIO1.92 R941.2
BT_LED#: JMINI2.46 Q89.3 R726.1
BT_LED#_R: Q89.1 Q318.1 Q318.3 R938.2
BT_PRI_STATUS: JBT1.5 JUSH1.12 R1134.2
BT_RADIO_DIS#: D28.1 D36.1 R694.1 R696.1 U46.A13
BT_RADIO_DIS#_CON: C754.1 D28.2 JBT1.7 R694.2
BT_RADIO_DIS#_R: D36.2 JMINI2.51 R696.2 R727.1
CAM_MIC_CBL_DET#: JCAM1.16 RH86.2 UH1.L15
CARD_SMBCLK: JIO1.48 U51.A49
CARD_SMBDAT: JIO1.50 U51.B52
CARDCLK_REQ#: JIO1.32 RH22.1 RH120.2 UH1.AF3
CCD_OFF: Q24.2 U46.B43
CD: R840.1 R853.1 U44.18
CD3301_DCIN: PC1006.1 PR1011.2 PU1001.1
CD3301_NBDOCK_DC_IN_SS: PR1024.1 PR1070.2 PU1001.19
CD3301_SDC_IN: PR1015.2 PU1001.6
CD_PBATT_OFF: PR1016.1 PU1001.26
CEXT: C86.1 U9.1
CEXT_8331: C97.2 U629.47
CFD_PWRBTN#_XDP: JXDP1.16 RC6.2
CFG0: JCPU1.AT20 RC21.1
CFG1: JCPU1.AR20 T90.1(TP-1)
CFG2: JCPU1.AP20 RC76.1 T103.1(TP-1)
CFG3: JCPU1.AP22 T104.1(TP-1)
CFG4: JCPU1.AT22 RC77.1 T105.1(TP-1)
CFG5: JCPU1.AN22 RC85.1 T107.1(TP-1)
CFG6: JCPU1.AT25 RC83.1 T106.1(TP-1)
CFG7: JCPU1.AN23 RC86.1 T108.1(TP-1)
CFG8: JCPU1.AR24 T109.1(TP-1)
CFG9: JCPU1.AT23 T117.1(TP-1)
CFG10: JCPU1.AN20 T111.1(TP-1)
CFG11: JCPU1.AP24 T116.1(TP-1)
CFG12: JCPU1.AP26 T119.1(TP-1)
CFG13: JCPU1.AN25 T128.1(TP-1)
CFG14: JCPU1.AN26 T127.1(TP-1)
CFG15: JCPU1.AP25 T135.1(TP-1)
CFG16: JCPU1.AR21 T137.1(TP-1)
CFG17: JCPU1.AP21 T138.1(TP-1)
CFG18: JCPU1.AR23 T139.1(TP-1)
CFG19: JCPU1.AP23 T140.1(TP-1)
CFG_RCOMP: JCPU1.AT31 RC58.1 T136.1(TP-1)
CHARGER_SMBCLK: PR766.2 RP5.5 U51.B50
CHARGER_SMBDAT: PR763.2 RP5.6 U51.A47
CHG: PL701.2 PR723.1
CLK_80H: RH159.2 UH1.F36
CLK_BCLK_ITP: RH156.1 UH1.AH45
CLK_BCLK_ITP#: RH154.1 UH1.AH43
CLK_BUF_BCLK: RPH3.3 UH1.AT24
CLK_BUF_BCLK#: RPH3.4 UH1.AR24
CLK_BUF_CKSSCD: RH169.1 UH1.BC6
CLK_BUF_CKSSCD#: RH167.1 UH1.BE6
CLK_BUF_DMI: RPH3.1 UH1.AW24
CLK_BUF_DMI#: RPH3.2 UH1.AY24
CLK_BUF_DOT96: RH151.1 UH1.G33
CLK_BUF_DOT96#: RH150.1 UH1.H33
CLK_CPU_DMI: RC13.2 UH1.AF40
CLK_CPU_DMI#: RC15.2 UH1.AF39
CLK_CPU_DPLL: RC52.2 UH1.AF36
CLK_CPU_DPLL#: RC51.2 UH1.AF35
CLK_CPU_ITP: RH107.2 RH156.2
CLK_CPU_ITP#: RH108.1 RH154.2
CLK_CPU_SSC_DPLL: RC22.2 UH1.AJ39
CLK_CPU_SSC_DPLL#: RC43.2 UH1.AJ40
CLK_DDC2_CRT: JCRT1.15 R48.2 U19.35
CLK_DDC2_DOCK: JDOCK1.48 U19.26
CLK_KBD: JDOCK1.78 RP6.6 U51.A38
CLK_MSE: JDOCK1.71 RP6.5 U51.A39
CLK_PCH_14M: RH146.1 UH1.F45
CLK_PCI_5048: CH15.1 R795.1 RH158.2 U46.A28
CLK_PCI_DOCK: CH76.1 JDOCK1.121 R756.1 RH162.2
CLK_PCI_LOOPBACK: CH77.1 RH164.2 UH1.D17
CLK_PCI_MEC: CH16.1 R885.1 RH160.2 U51.A29
CLK_PCI_TPM: RE5.1 RH155.1 U39.21
CLK_PCIE_CARD: JIO1.28 RH122.2
CLK_PCIE_CARD#: JIO1.26 RH121.2
CLK_PCIE_EXP: JIO1.60 RH139.2
CLK_PCIE_EXP#: JIO1.58 RH137.2
CLK_PCIE_LAN: RH92.2 U31.44
CLK_PCIE_LAN#: RH82.2 U31.45
CLK_PCIE_MINI1: JMINI1.13 RH308.2
CLK_PCIE_MINI1#: JMINI1.11 RH307.2
CLK_PCIE_MINI2: JMINI2.13 RH126.2
CLK_PCIE_MINI2#: JMINI2.11 RH127.2
CLK_PCIE_MINI3: JMINI3.13 RH135.2
CLK_PCIE_MINI3#: JMINI3.11 RH133.2
CLK_PCIE_NVR: JMINI4.13 RH142.2
CLK_PCIE_NVR#: JMINI4.11 RH144.2
CLK_PCIE_VGA: JMXM1.185 UH1.AB36
CLK_PCIE_VGA#: JMXM1.183 UH1.AB35
CLK_SIO_14M: CH79.1 R794.1 RH157.1 U46.A32
CLK_TP_SIO: JIO1.110 U51.A37
CLK_XDP: JXDP1.13 RH107.1
CLK_XDP#: JXDP1.12 RH108.2
CLKRUN#: RH90.2 U39.15 U46.B20 U51.A32 UH1.AN7
COEX1_BT_ACTIVE: JBT1.3 JMINI2.5
COEX2_WLAN_ACTIVE: C601.1 C753.1 JBT1.8 JMINI2.3 R904.1
COMP: PC525.2 PR541.2 PU500.7
CONTACTLESS_DET#: JUSH1.17 RPH8.7 UH1.C16
CPPE#: JMINI2.37 R823.1 UH1.B13
CPU1.5V_S3_GATE: R889.2 U51.A36
CPU_B+: PC502.1 PC503.1 PC504.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC529.1 PC530.1 PC531.1 PC533.1 PC534.1 PC535.1 PL510.1 PQ500.1 PQ501.1 PQ502.1 PQ503.1 PQ504.1 PQ505.1 PR526.2
CPU_DETECT#: JCPU1.AP32 RP2.8 U46.A3
CPU_DMI: JCPU1.E26 RC13.1
CPU_DMI#: JCPU1.D26 RC15.1
CPU_DPLL: JCPU1.H28 RC52.1
CPU_DPLL#: JCPU1.G28 RC51.1
CPU_EDP_HPD: QC6.2 RC75.1 U23.1
CPU_PLTRST#: RC53.2 UH1.AU4
CPU_PLTRST#_R: JCPU1.AT26 RC8.1 RC53.1 RC54.1
CPU_PWR_DEBUG: JCPU1.H27 RC69.2 RC71.1
CPU_SSC_DPLL: JCPU1.E27 RC22.1
CPU_SSC_DPLL#: JCPU1.F27 RC43.1
CPU_VTT_ON: RP4.1 U46.B17
CRT_11: JCRT1.11 T61.1(TP-1)
CRT_EN: R421.2 U19.2
CRT_IREF: RH97.2 UH1.U40
CRT_SWITCH: U19.38 U19.40 U46.B52
CS_1.35V: PR201.2 PU200.13
CSON_1: PC786.1 PC792.2 PR723.3 PR761.2
CSOP_1: PC792.1 PR723.2 PR759.2
CSS_GC: PR703.2 PU1001.10
CSSN_1: PQ702.3 PQ703.2 PR707.1 PR711.1 PR712.1
CSSN_2: PC703.2 PC704.1 PR706.1 PR711.2 PU700.1 PU701.5
CSSP_1: PQ700.3 PQ703.5 PR707.2 PR709.1 PR710.1
CSSP_2: PC702.2 PC703.1 PR708.1 PR710.2 PU700.2
D_CLKRUN#: JDOCK1.111 RP3.8 U46.A19
D_DLDRQ1#: JDOCK1.117 RP3.6 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 RP3.7 U46.A20
DAI_12MHZ#: JDOCK1.89 JIO1.63 RE11.1
DAI_BCLK#: JDOCK1.77 JIO1.77 RE12.1
DAI_DI: JDOCK1.83 JIO1.73
DAI_DO#: JDOCK1.85 JIO1.75
DAI_LRCK#: JDOCK1.79 JIO1.79
DAT_DDC2_CRT: JCRT1.12 R47.2 U19.34
DAT_DDC2_DOCK: JDOCK1.46 U19.25
DAT_KBD: JDOCK1.80 RP6.8 U51.B41
DAT_MSE: JDOCK1.73 RP6.7 U51.B42
DAT_TP_SIO: JIO1.108 U51.B40
DC_BLOCK_GC: PR700.1 PU1001.7
DDR3_DRAMRST#_CPU: JCPU1.AN3 QD9.3 RD6.2 RD30.1
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 JDIMM3.30 JDIMM4.30 RD51.2
DDR_1.35V_CNTRL0: PR216.2 PR219.1 U46.A49
DDR_1.35V_CNTRL1: PR222.2 PR223.1 U46.A16
DDR_A_BS0: JCPU1.V5 JDIMM1.109 JDIMM2.109
DDR_A_BS1: JCPU1.U5 JDIMM1.108 JDIMM2.108
DDR_A_BS2: JCPU1.AD1 JDIMM1.79 JDIMM2.79
DDR_A_CAS#: JCPU1.U8 JDIMM1.115 JDIMM2.115
DDR_A_D0: JCPU1.AR15 JDIMM1.7 JDIMM2.6
DDR_A_D1: JCPU1.AT14 JDIMM1.4 JDIMM2.5
DDR_A_D2: JCPU1.AM14 JDIMM1.16 JDIMM2.15
DDR_A_D3: JCPU1.AN14 JDIMM1.18 JDIMM2.17
DDR_A_D4: JCPU1.AT15 JDIMM1.5 JDIMM2.4
DDR_A_D5: JCPU1.AR14 JDIMM1.6 JDIMM2.7
DDR_A_D6: JCPU1.AN15 JDIMM1.17 JDIMM2.18
DDR_A_D7: JCPU1.AM15 JDIMM1.15 JDIMM2.16
DDR_A_D8: JCPU1.AM9 JDIMM1.21 JDIMM2.22
DDR_A_D9: JCPU1.AN9 JDIMM1.23 JDIMM2.24
DDR_A_D10: JCPU1.AM8 JDIMM1.36 JDIMM2.35
DDR_A_D11: JCPU1.AN8 JDIMM1.34 JDIMM2.33
DDR_A_D12: JCPU1.AR9 JDIMM1.24 JDIMM2.23
DDR_A_D13: JCPU1.AT9 JDIMM1.22 JDIMM2.21
DDR_A_D14: JCPU1.AR8 JDIMM1.35 JDIMM2.36
DDR_A_D15: JCPU1.AT8 JDIMM1.33 JDIMM2.34
DDR_A_D16: JCPU1.AJ9 JDIMM1.42 JDIMM2.41
DDR_A_D17: JCPU1.AK9 JDIMM1.40 JDIMM2.39
DDR_A_D18: JCPU1.AJ6 JDIMM1.52 JDIMM2.53
DDR_A_D19: JCPU1.AK6 JDIMM1.50 JDIMM2.51
DDR_A_D20: JCPU1.AJ10 JDIMM1.41 JDIMM2.42
DDR_A_D21: JCPU1.AK10 JDIMM1.39 JDIMM2.40
DDR_A_D22: JCPU1.AJ7 JDIMM1.53 JDIMM2.52
DDR_A_D23: JCPU1.AK7 JDIMM1.51 JDIMM2.50
DDR_A_D24: JCPU1.AF4 JDIMM1.58 JDIMM2.59
DDR_A_D25: JCPU1.AF5 JDIMM1.56 JDIMM2.57
DDR_A_D26: JCPU1.AF1 JDIMM1.70 JDIMM2.69
DDR_A_D27: JCPU1.AF2 JDIMM1.68 JDIMM2.67
DDR_A_D28: JCPU1.AG4 JDIMM1.59 JDIMM2.58
DDR_A_D29: JCPU1.AG5 JDIMM1.57 JDIMM2.56
DDR_A_D30: JCPU1.AG1 JDIMM1.69 JDIMM2.70
DDR_A_D31: JCPU1.AG2 JDIMM1.67 JDIMM2.68
DDR_A_D32: JCPU1.J1 JDIMM1.132 JDIMM2.131
DDR_A_D33: JCPU1.J2 JDIMM1.130 JDIMM2.129
DDR_A_D34: JCPU1.J5 JDIMM1.141 JDIMM2.140
DDR_A_D35: JCPU1.H5 JDIMM1.143 JDIMM2.142
DDR_A_D36: JCPU1.H2 JDIMM1.131 JDIMM2.132
DDR_A_D37: JCPU1.H1 JDIMM1.129 JDIMM2.130
DDR_A_D38: JCPU1.J4 JDIMM1.140 JDIMM2.141
DDR_A_D39: JCPU1.H4 JDIMM1.142 JDIMM2.143
DDR_A_D40: JCPU1.F2 JDIMM1.148 JDIMM2.149
DDR_A_D41: JCPU1.F1 JDIMM1.146 JDIMM2.147
DDR_A_D42: JCPU1.D2 JDIMM1.160 JDIMM2.159
DDR_A_D43: JCPU1.D3 JDIMM1.158 JDIMM2.157
DDR_A_D44: JCPU1.D1 JDIMM1.149 JDIMM2.148
DDR_A_D45: JCPU1.F3 JDIMM1.147 JDIMM2.146
DDR_A_D46: JCPU1.C3 JDIMM1.159 JDIMM2.160
DDR_A_D47: JCPU1.B3 JDIMM1.157 JDIMM2.158
DDR_A_D48: JCPU1.B5 JDIMM1.163 JDIMM2.164
DDR_A_D49: JCPU1.E6 JDIMM1.165 JDIMM2.166
DDR_A_D50: JCPU1.A5 JDIMM1.176 JDIMM2.177
DDR_A_D51: JCPU1.D6 JDIMM1.175 JDIMM2.174
DDR_A_D52: JCPU1.D5 JDIMM1.164 JDIMM2.163
DDR_A_D53: JCPU1.E5 JDIMM1.166 JDIMM2.165
DDR_A_D54: JCPU1.B6 JDIMM1.174 JDIMM2.175
DDR_A_D55: JCPU1.A6 JDIMM1.177 JDIMM2.176
DDR_A_D56: JCPU1.E12 JDIMM1.183 JDIMM2.182
DDR_A_D57: JCPU1.D12 JDIMM1.181 JDIMM2.180
DDR_A_D58: JCPU1.B11 JDIMM1.192 JDIMM2.191
DDR_A_D59: JCPU1.A11 JDIMM1.194 JDIMM2.193
DDR_A_D60: JCPU1.E11 JDIMM1.180 JDIMM2.181
DDR_A_D61: JCPU1.D11 JDIMM1.182 JDIMM2.183
DDR_A_D62: JCPU1.B12 JDIMM1.193 JDIMM2.194
DDR_A_D63: JCPU1.A12 JDIMM1.191 JDIMM2.192
DDR_A_DQS0: JCPU1.AP14 JDIMM1.12 JDIMM2.12
DDR_A_DQS1: JCPU1.AP9 JDIMM1.29 JDIMM2.29
DDR_A_DQS2: JCPU1.AK8 JDIMM1.47 JDIMM2.47
DDR_A_DQS3: JCPU1.AG3 JDIMM1.64 JDIMM2.64
DDR_A_DQS4: JCPU1.H3 JDIMM1.137 JDIMM2.137
DDR_A_DQS5: JCPU1.E3 JDIMM1.154 JDIMM2.154
DDR_A_DQS6: JCPU1.C6 JDIMM1.171 JDIMM2.171
DDR_A_DQS7: JCPU1.C12 JDIMM1.188 JDIMM2.188
DDR_A_DQS#0: JCPU1.AP15 JDIMM1.10 JDIMM2.10
DDR_A_DQS#1: JCPU1.AP8 JDIMM1.27 JDIMM2.27
DDR_A_DQS#2: JCPU1.AJ8 JDIMM1.45 JDIMM2.45
DDR_A_DQS#3: JCPU1.AF3 JDIMM1.62 JDIMM2.62
DDR_A_DQS#4: JCPU1.J3 JDIMM1.135 JDIMM2.135
DDR_A_DQS#5: JCPU1.E2 JDIMM1.152 JDIMM2.152
DDR_A_DQS#6: JCPU1.C5 JDIMM1.169 JDIMM2.169
DDR_A_DQS#7: JCPU1.C11 JDIMM1.186 JDIMM2.186
DDR_A_MA0: JCPU1.V8 JDIMM1.98 JDIMM2.98
DDR_A_MA1: JCPU1.AC6 JDIMM1.97 JDIMM2.97
DDR_A_MA2: JCPU1.V9 JDIMM1.96 JDIMM2.96
DDR_A_MA3: JCPU1.U9 JDIMM1.95 JDIMM2.95
DDR_A_MA4: JCPU1.AC5 JDIMM1.92 JDIMM2.92
DDR_A_MA5: JCPU1.AC4 JDIMM1.91 JDIMM2.91
DDR_A_MA6: JCPU1.AD6 JDIMM1.90 JDIMM2.90
DDR_A_MA7: JCPU1.AC3 JDIMM1.86 JDIMM2.86
DDR_A_MA8: JCPU1.AD5 JDIMM1.89 JDIMM2.89
DDR_A_MA9: JCPU1.AC2 JDIMM1.85 JDIMM2.85
DDR_A_MA10: JCPU1.V6 JDIMM1.107 JDIMM2.107
DDR_A_MA11: JCPU1.AC1 JDIMM1.84 JDIMM2.84
DDR_A_MA12: JCPU1.AD4 JDIMM1.83 JDIMM2.83
DDR_A_MA13: JCPU1.V7 JDIMM1.119 JDIMM2.119
DDR_A_MA14: JCPU1.AD3 JDIMM1.80 JDIMM2.80
DDR_A_MA15: JCPU1.AD2 JDIMM1.78 JDIMM2.78
DDR_A_RAS#: JCPU1.U6 JDIMM1.110 JDIMM2.110
DDR_A_WE#: JCPU1.U7 JDIMM1.113 JDIMM2.113
DDR_B_BS0: JCPU1.R7 JDIMM3.109 JDIMM4.109
DDR_B_BS1: JCPU1.P8 JDIMM3.108 JDIMM4.108
DDR_B_BS2: JCPU1.AA9 JDIMM3.79 JDIMM4.79
DDR_B_CAS#: JCPU1.P7 JDIMM3.115 JDIMM4.115
DDR_B_D0: JCPU1.AR18 JDIMM3.5 JDIMM4.4
DDR_B_D1: JCPU1.AT18 JDIMM3.7 JDIMM4.6
DDR_B_D2: JCPU1.AM17 JDIMM3.16 JDIMM4.15
DDR_B_D3: JCPU1.AM18 JDIMM3.18 JDIMM4.17
DDR_B_D4: JCPU1.AR17 JDIMM3.4 JDIMM4.5
DDR_B_D5: JCPU1.AT17 JDIMM3.6 JDIMM4.7
DDR_B_D6: JCPU1.AN17 JDIMM3.17 JDIMM4.18
DDR_B_D7: JCPU1.AN18 JDIMM3.15 JDIMM4.16
DDR_B_D8: JCPU1.AT12 JDIMM3.21 JDIMM4.22
DDR_B_D9: JCPU1.AR12 JDIMM3.23 JDIMM4.24
DDR_B_D10: JCPU1.AN12 JDIMM3.33 JDIMM4.34
DDR_B_D11: JCPU1.AM11 JDIMM3.36 JDIMM4.35
DDR_B_D12: JCPU1.AT11 JDIMM3.24 JDIMM4.23
DDR_B_D13: JCPU1.AR11 JDIMM3.22 JDIMM4.21
DDR_B_D14: JCPU1.AM12 JDIMM3.34 JDIMM4.33
DDR_B_D15: JCPU1.AN11 JDIMM3.35 JDIMM4.36
DDR_B_D16: JCPU1.AR5 JDIMM3.42 JDIMM4.41
DDR_B_D17: JCPU1.AR6 JDIMM3.40 JDIMM4.39
DDR_B_D18: JCPU1.AM5 JDIMM3.52 JDIMM4.53
DDR_B_D19: JCPU1.AM6 JDIMM3.50 JDIMM4.51
DDR_B_D20: JCPU1.AT5 JDIMM3.41 JDIMM4.42
DDR_B_D21: JCPU1.AT6 JDIMM3.39 JDIMM4.40
DDR_B_D22: JCPU1.AN5 JDIMM3.53 JDIMM4.52
DDR_B_D23: JCPU1.AN6 JDIMM3.51 JDIMM4.50
DDR_B_D24: JCPU1.AJ4 JDIMM3.58 JDIMM4.59
DDR_B_D25: JCPU1.AK4 JDIMM3.56 JDIMM4.57
DDR_B_D26: JCPU1.AJ1 JDIMM3.70 JDIMM4.69
DDR_B_D27: JCPU1.AJ2 JDIMM3.68 JDIMM4.67
DDR_B_D28: JCPU1.AM1 JDIMM3.59 JDIMM4.58
DDR_B_D29: JCPU1.AN1 JDIMM3.57 JDIMM4.56
DDR_B_D30: JCPU1.AK2 JDIMM3.69 JDIMM4.70
DDR_B_D31: JCPU1.AK1 JDIMM3.67 JDIMM4.68
DDR_B_D32: JCPU1.L2 JDIMM3.129 JDIMM4.130
DDR_B_D33: JCPU1.M2 JDIMM3.130 JDIMM4.129
DDR_B_D34: JCPU1.L4 JDIMM3.142 JDIMM4.143
DDR_B_D35: JCPU1.M4 JDIMM3.140 JDIMM4.141
DDR_B_D36: JCPU1.L1 JDIMM3.131 JDIMM4.132
DDR_B_D37: JCPU1.M1 JDIMM3.132 JDIMM4.131
DDR_B_D38: JCPU1.L5 JDIMM3.143 JDIMM4.142
DDR_B_D39: JCPU1.M5 JDIMM3.141 JDIMM4.140
DDR_B_D40: JCPU1.G7 JDIMM3.149 JDIMM4.148
DDR_B_D41: JCPU1.J8 JDIMM3.146 JDIMM4.147
DDR_B_D42: JCPU1.G8 JDIMM3.160 JDIMM4.159
DDR_B_D43: JCPU1.G9 JDIMM3.158 JDIMM4.157
DDR_B_D44: JCPU1.J7 JDIMM3.148 JDIMM4.149
DDR_B_D45: JCPU1.J9 JDIMM3.147 JDIMM4.146
DDR_B_D46: JCPU1.G10 JDIMM3.157 JDIMM4.158
DDR_B_D47: JCPU1.J10 JDIMM3.159 JDIMM4.160
DDR_B_D48: JCPU1.A8 JDIMM3.163 JDIMM4.164
DDR_B_D49: JCPU1.B8 JDIMM3.165 JDIMM4.166
DDR_B_D50: JCPU1.A9 JDIMM3.176 JDIMM4.177
DDR_B_D51: JCPU1.B9 JDIMM3.174 JDIMM4.175
DDR_B_D52: JCPU1.D8 JDIMM3.164 JDIMM4.163
DDR_B_D53: JCPU1.E8 JDIMM3.166 JDIMM4.165
DDR_B_D54: JCPU1.D9 JDIMM3.177 JDIMM4.176
DDR_B_D55: JCPU1.E9 JDIMM3.175 JDIMM4.174
DDR_B_D56: JCPU1.E15 JDIMM3.183 JDIMM4.182
DDR_B_D57: JCPU1.D15 JDIMM3.181 JDIMM4.180
DDR_B_D58: JCPU1.A15 JDIMM3.193 JDIMM4.194
DDR_B_D59: JCPU1.B15 JDIMM3.191 JDIMM4.192
DDR_B_D60: JCPU1.E14 JDIMM3.180 JDIMM4.181
DDR_B_D61: JCPU1.D14 JDIMM3.182 JDIMM4.183
DDR_B_D62: JCPU1.A14 JDIMM3.194 JDIMM4.193
DDR_B_D63: JCPU1.B14 JDIMM3.192 JDIMM4.191
DDR_B_DQS0: JCPU1.AP17 JDIMM3.12 JDIMM4.12
DDR_B_DQS1: JCPU1.AP12 JDIMM3.29 JDIMM4.29
DDR_B_DQS2: JCPU1.AP6 JDIMM3.47 JDIMM4.47
DDR_B_DQS3: JCPU1.AK3 JDIMM3.64 JDIMM4.64
DDR_B_DQS4: JCPU1.M3 JDIMM3.137 JDIMM4.137
DDR_B_DQS5: JCPU1.H8 JDIMM3.154 JDIMM4.154
DDR_B_DQS6: JCPU1.C9 JDIMM3.171 JDIMM4.171
DDR_B_DQS7: JCPU1.C15 JDIMM3.188 JDIMM4.188
DDR_B_DQS#0: JCPU1.AP18 JDIMM3.10 JDIMM4.10
DDR_B_DQS#1: JCPU1.AP11 JDIMM3.27 JDIMM4.27
DDR_B_DQS#2: JCPU1.AP5 JDIMM3.45 JDIMM4.45
DDR_B_DQS#3: JCPU1.AJ3 JDIMM3.62 JDIMM4.62
DDR_B_DQS#4: JCPU1.L3 JDIMM3.135 JDIMM4.135
DDR_B_DQS#5: JCPU1.H9 JDIMM3.152 JDIMM4.152
DDR_B_DQS#6: JCPU1.C8 JDIMM3.169 JDIMM4.169
DDR_B_DQS#7: JCPU1.C14 JDIMM3.186 JDIMM4.186
DDR_B_MA0: JCPU1.R8 JDIMM3.98 JDIMM4.98
DDR_B_MA1: JCPU1.Y5 JDIMM3.97 JDIMM4.97
DDR_B_MA2: JCPU1.Y10 JDIMM3.96 JDIMM4.96
DDR_B_MA3: JCPU1.AA5 JDIMM3.95 JDIMM4.95
DDR_B_MA4: JCPU1.Y7 JDIMM3.92 JDIMM4.92
DDR_B_MA5: JCPU1.AA6 JDIMM3.91 JDIMM4.91
DDR_B_MA6: JCPU1.Y6 JDIMM3.90 JDIMM4.90
DDR_B_MA7: JCPU1.AA7 JDIMM3.86 JDIMM4.86
DDR_B_MA8: JCPU1.Y8 JDIMM3.89 JDIMM4.89
DDR_B_MA9: JCPU1.AA10 JDIMM3.85 JDIMM4.85
DDR_B_MA10: JCPU1.R9 JDIMM3.107 JDIMM4.107
DDR_B_MA11: JCPU1.Y9 JDIMM3.84 JDIMM4.84
DDR_B_MA12: JCPU1.AF7 JDIMM3.83 JDIMM4.83
DDR_B_MA13: JCPU1.P9 JDIMM3.119 JDIMM4.119
DDR_B_MA14: JCPU1.AA8 JDIMM3.80 JDIMM4.80
DDR_B_MA15: JCPU1.AG7 JDIMM3.78 JDIMM4.78
DDR_B_RAS#: JCPU1.R6 JDIMM3.110 JDIMM4.110
DDR_B_WE#: JCPU1.P6 JDIMM3.113 JDIMM4.113
DDR_CKE0_DIMM2: JCPU1.AD9 JDIMM2.73
DDR_CKE1_DIMM2: JCPU1.AC9 JDIMM2.74
DDR_CKE2_DIMM4: JCPU1.AF10 JDIMM4.73
DDR_CKE3_DIMM4: JCPU1.AG10 JDIMM4.74
DDR_CKE4_DIMM1: JCPU1.AD8 JDIMM1.73
DDR_CKE5_DIMM1: JCPU1.AC8 JDIMM1.74
DDR_CKE6_DIMM3: JCPU1.AG9 JDIMM3.73
DDR_CKE7_DIMM3: JCPU1.AF9 JDIMM3.74
DDR_CS0_DIMM2#: JCPU1.M7 JDIMM2.114
DDR_CS1_DIMM2#: JCPU1.L9 JDIMM2.121
DDR_CS2_DIMM4#: JCPU1.P4 JDIMM4.114
DDR_CS3_DIMM4#: JCPU1.R2 JDIMM4.121
DDR_CS4_DIMM1#: JCPU1.M9 JDIMM1.114
DDR_CS5_DIMM1#: JCPU1.M10 JDIMM1.121
DDR_CS6_DIMM3#: JCPU1.P3 JDIMM3.114
DDR_CS7_DIMM3#: JCPU1.P1 JDIMM3.121
DDR_HVREF_RST_PCH: CD92.1 QD6.2 QD6.5 QD7.2 QD9.2 RC104.2 RH170.2 UH1.N8
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 JDIMM3.202 JDIMM4.202 QH4.1 R502.2 RH31.1 U23.13 U88.4
DDR_XDP_WAN_SMBCLK_R2: JXDP2.53 RH31.2
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 JDIMM3.200 JDIMM4.200 QH4.4 R501.2 RH30.1 U23.14 U88.6
DDR_XDP_WAN_SMBDAT_R2: JXDP2.51 RH30.2
DEVICE_DET#: JODD1.8 R1125.2 U51.B1
DEW1: R84.2 R90.2 U26.16
DEW2: R83.2 R85.2 U26.6
DGPU_ALERT#: Q5.1 RP3.5 U46.A42
DGPU_HOLD_RST#: R19.2 R51.1 RH148.2 U16.1 UH1.A12
DGPU_PEX_RST#: JMXM1.184 Q4.2 R19.1 R38.2 U16.4
DGPU_PWR_EN: JMXM1.44 QC5.1 RH113.2 RH132.1 U46.B45
DGPU_PWR_EN#: QC5.2 RH328.2 UH1.C12
DGPU_PWROK: JMXM1.42 R135.1 R1977.2 U14.1 U25.1 U27.1 U46.A56 UH1.C14
DGPU_SELECT#: U3.1 U11.27 U13.27 U19.39 U46.B14
DGPU_THERMTRIP#: Q4.1 Q115.3 R11.2 R400.2 R1181.2
DH_1.35V: PQ201.4 PU200.17
DH_CHG: PQ704.4 PU700.18
DIMM1_SA0: JDIMM1.197 RD8.1
DIMM1_SA1: JDIMM1.201 RD13.2
DIMM2_SA0: JDIMM2.197 RD19.2
DIMM2_SA1: JDIMM2.201 RD20.2
DIMM3_SA0: JDIMM3.197 RD26.1
DIMM3_SA1: JDIMM3.201 RD27.1
DIMM4_SA0: JDIMM4.197 RD37.2
DIMM4_SA1: JDIMM4.201 RD36.1
DIS_BAT_PROCHOT#: PR1081.1 U46.B51
DIS_PROCHOT#: PC735.1 PC736.1 PQ706.2 PR716.1 PR735.1 PR740.2 PU703.7
DISP_ON: D64.1 D65.1 D69.1 JEDP1.2 JLVDS1.2 R1138.1
DK_AC_OFF: PR1014.1 PU1001.25
DK_AC_OFF_EN: PR1020.1 PU1001.22
DK_CSS_GC: PR714.1 PU1001.11
DK_PWR_BAR: PR1007.2 PU1001.33
DL_1.35V: PQ202.4 PU200.15
DL_CHG: PQ705.4 PU700.15
DMI_CRX_PTX_N0: JCPU1.D21 UH1.BD21
DMI_CRX_PTX_N1: JCPU1.C21 UH1.BE20
DMI_CRX_PTX_N2: JCPU1.B21 UH1.BD17
DMI_CRX_PTX_N3: JCPU1.A21 UH1.BE18
DMI_CRX_PTX_P0: JCPU1.D20 UH1.BB21
DMI_CRX_PTX_P1: JCPU1.C20 UH1.BC20
DMI_CRX_PTX_P2: JCPU1.B20 UH1.BB17
DMI_CRX_PTX_P3: JCPU1.A20 UH1.BC18
DMI_CTX_PRX_N0: JCPU1.D18 UH1.AW22
DMI_CTX_PRX_N1: JCPU1.C17 UH1.AR20
DMI_CTX_PRX_N2: JCPU1.B17 UH1.AP17
DMI_CTX_PRX_N3: JCPU1.A17 UH1.AV20
DMI_CTX_PRX_P0: JCPU1.D17 UH1.AY22
DMI_CTX_PRX_P1: JCPU1.C18 UH1.AP20
DMI_CTX_PRX_P2: JCPU1.B18 UH1.AR17
DMI_CTX_PRX_P3: JCPU1.A18 UH1.AW20
DMI_IREF: RH98.1 UH1.BE16
DMI_RCOMP: RH100.2 UH1.AY17
DMIC0: JCAM1.13 JIO1.85
DMIC_CLK: JCAM1.11 JIO1.83
DOCK_AC_OFF: JDOCK1.2 PD1010.1 PR1031.2
DOCK_AC_OFF_EC: PR1018.1 PR1020.2 U46.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6 PR715.1
DOCK_DCIN_IS-: JDOCK1.136 PR713.2
DOCK_DET#: D32.2 R755.2 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: JIO1.65 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_LOM_TRD0+: JDOCK1.104 U32.22
DOCK_LOM_TRD0-: JDOCK1.106 U32.23
DOCK_LOM_TRD1+: JDOCK1.110 U32.26
DOCK_LOM_TRD1-: JDOCK1.112 U32.27
DOCK_LOM_TRD2+: JDOCK1.122 U32.31
DOCK_LOM_TRD2-: JDOCK1.124 U32.32
DOCK_LOM_TRD3+: JDOCK1.128 U32.35
DOCK_LOM_TRD3-: JDOCK1.130 U32.36
DOCK_MIC_DET: JIO1.67 U46.B8
DOCK_POR_RST#: C737.1 JDOCK1.140 RP7.8 U51.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: C733.1 JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R819.2 R825.1 U10.1 U51.A63
DOCK_SMB_ALERT#: JDOCK1.133 PQ1.3 R763.2 U46.A51
DOCK_SMB_CLK: JDOCK1.127 R841.2 U51.B4
DOCK_SMB_DAT: JDOCK1.129 R838.2 U51.A3
DOCKED: Q326.2 U32.13 U46.A38
DOCKED#: Q326.1 R518.2 U9.45
DP_A_MXM_AUX_Q: Q339.3 Q340.2 Q340.5 R2193.2
DP_CFG0: R61.2 R64.2 U9.44
DP_CFG1: R72.2 R73.2 U9.29
DP_MB_P14: JDP1.14 R801.2
DP_RP_CEXT: C87.1 U22.2
DP_RP_CFG0: R76.2 R77.1 U22.5
DP_RP_CFG1: R78.2 R79.1 U22.40
DP_RP_PEQ: R80.2 R81.1 U22.4
DP_RP_REXT: R75.2 U22.7
DPC_CA_DET: C1174.1 JDOCK1.6 Q110.2 R492.2 U20.1 U20.4
DPC_CA_DET#: Q110.5 Q110.6 R1532.2 U20.10 U20.13
DPC_DOCK_AUX: C387.1 U20.2
DPC_DOCK_AUX#: C388.1 U20.5
DPC_DOCK_LANE_C_N0: C438.1 R2173.2
DPC_DOCK_LANE_C_N1: C440.1 R2175.2
DPC_DOCK_LANE_C_N2: C442.1 R2177.2
DPC_DOCK_LANE_C_N3: C444.1 R2179.2
DPC_DOCK_LANE_C_P0: C431.1 R2172.2
DPC_DOCK_LANE_C_P1: C439.1 R2174.2
DPC_DOCK_LANE_C_P2: C441.1 R2176.2
DPC_DOCK_LANE_C_P3: C443.1 R2178.2
DPC_DOCK_LANE_N0_R: JDOCK1.12 R2173.1
DPC_DOCK_LANE_N1_R: JDOCK1.18 R2175.1
DPC_DOCK_LANE_N2_R: JDOCK1.24 R2177.1
DPC_DOCK_LANE_N3_R: JDOCK1.30 R2179.1
DPC_DOCK_LANE_P0_R: JDOCK1.10 R2172.1
DPC_DOCK_LANE_P1_R: JDOCK1.16 R2174.1
DPC_DOCK_LANE_P2_R: JDOCK1.22 R2176.1
DPC_DOCK_LANE_P3_R: JDOCK1.28 R2178.1
DPC_DOCK_SW_AUX: JDOCK1.34 Q113.1 U20.3 U20.11
DPC_DOCK_SW_AUX#: JDOCK1.36 Q113.4 U20.6 U20.8
DPD_CA_DET: C1332.1 JDOCK1.5 Q336.2 R491.2 U9.42
DPD_CPU_LANE_N0: C515.1 JCPU1.P29
DPD_CPU_LANE_N0_C: C515.2 U629.12
DPD_CPU_LANE_N1: C517.1 JCPU1.N28
DPD_CPU_LANE_N1_C: C517.2 U629.15
DPD_CPU_LANE_N2: C519.1 JCPU1.P31
DPD_CPU_LANE_N2_C: C519.2 U629.17
DPD_CPU_LANE_N3: C522.1 JCPU1.N30
DPD_CPU_LANE_N3_C: C522.2 U629.20
DPD_CPU_LANE_P0: C516.1 JCPU1.R29
DPD_CPU_LANE_P0_C: C516.2 U629.11
DPD_CPU_LANE_P1: C518.1 JCPU1.P28
DPD_CPU_LANE_P1_C: C518.2 U629.14
DPD_CPU_LANE_P2: C520.1 JCPU1.R31
DPD_CPU_LANE_P2_C: C520.2 U629.16
DPD_CPU_LANE_P3: C521.1 JCPU1.P30
DPD_CPU_LANE_P3_C: C521.2 U629.19
DPD_DOCK_AUX: JDOCK1.33 Q337.1 U9.55
DPD_DOCK_AUX#: JDOCK1.35 Q337.4 U9.54
DPD_DOCK_AUX_Q: Q335.2 Q335.5 Q336.3 Q337.2 Q337.5 R2153.2
DPD_DOCK_LANE_N0: C367.1 R2165.1
DPD_DOCK_LANE_N0_R: JDOCK1.11 R2165.2
DPD_DOCK_LANE_N1: C369.1 R2167.1
DPD_DOCK_LANE_N1_R: JDOCK1.17 R2167.2
DPD_DOCK_LANE_N2: C425.1 R2169.1
DPD_DOCK_LANE_N2_R: JDOCK1.23 R2169.2
DPD_DOCK_LANE_N3: C427.1 R2171.1
DPD_DOCK_LANE_N3_R: JDOCK1.29 R2171.2
DPD_DOCK_LANE_P0: C366.1 R2164.1
DPD_DOCK_LANE_P0_R: JDOCK1.9 R2164.2
DPD_DOCK_LANE_P1: C368.1 R2166.1
DPD_DOCK_LANE_P1_R: JDOCK1.15 R2166.2
DPD_DOCK_LANE_P2: C424.1 R2168.1
DPD_DOCK_LANE_P2_R: JDOCK1.21 R2168.2
DPD_DOCK_LANE_P3: C426.1 R2170.1
DPD_DOCK_LANE_P3_R: JDOCK1.27 R2170.2
DPD_GPU_HPD: C695.1 JDOCK1.39 R757.1 U9.32
DPD_GPU_LANE_N0: C367.2 U9.39
DPD_GPU_LANE_N1: C369.2 U9.36
DPD_GPU_LANE_N2: C425.2 U9.33
DPD_GPU_LANE_N3: C427.2 U9.30
DPD_GPU_LANE_P0: C366.2 U9.40
DPD_GPU_LANE_P1: C368.2 U9.37
DPD_GPU_LANE_P2: C424.2 U9.34
DPD_GPU_LANE_P3: C426.2 U9.31
DPD_PCH_HPD: U629.13 UH1.H39
DSCHRG_MOSFET_GC: PR1004.2 PU1001.29
DSWODVREN: RH67.1 RH81.2 UH1.C8
DYN_TUR_CURRNT_SET#: PQ708.5 R1980.2 U51.A35
DYN_TURB_GPU_PWR_ALRT#: D19.1 PR30.2 R14.2 U46.A46
EC5048_TX: JDEG2.2 JMINI2.17 R849.2 U46.B2
EC_32KHZ_ECE5048: U46.B35 U51.B62
EC_WAKE#: R846.1 RH216.1 U51.B23 UH1.R11
EDID_SELECT#: U19.1 U46.B61
EDP_COMP: JCPU1.E24 RC1.2
EDP_CPU_AUX: JCPU1.N27 R1995.1 R2198.1
EDP_CPU_AUX#: JCPU1.M27 R1994.2 R2199.1
EDP_CPU_AUX#_C: C105.1 U23.3
EDP_CPU_AUX#_R: C105.2 R2199.2
EDP_CPU_AUX_C: C104.1 U23.4
EDP_CPU_AUX_R: C104.2 R2198.2
EDP_CPU_LANE_N0: C101.2 JCPU1.P35
EDP_CPU_LANE_N0_C: C101.1 U23.8
EDP_CPU_LANE_N1: C118.2 JCPU1.N34
EDP_CPU_LANE_N1_C: C118.1 U23.10
EDP_CPU_LANE_P0: C100.2 JCPU1.R35
EDP_CPU_LANE_P0_C: C100.1 U23.7
EDP_CPU_LANE_P1: C103.2 JCPU1.P34
EDP_CPU_LANE_P1_C: C103.1 U23.9
EDP_HPD#: JCPU1.P27 QC6.1 RC65.1
EMBCLK_REQ#: JMINI4.7 RH140.1 UH1.Y3
EMC4021_BC_CLK: U29.8 U51.B49
EMC4021_BC_DAT: R1126.2 U29.7 U51.B48
EMC4021_BC_INT#: R385.2 R386.2 U29.9 U51.A34
EN_1.5VSP: PC406.1 PR403.2 PR404.1 PR406.2 PU400.5
EN_+1.05VSP: PC307.1 PR303.2 PR315.1 PU300.3
EN_DK_PWRBAR: PR1027.1 PR1028.1 PU1001.17
EN_DOCK_PWR_BAR: PR1027.2 U46.B37
EN_I2S_NB_CODEC#: JIO1.81 U46.B36
EN_INVPWR: Q22.2 RP7.6 U51.A25
EN_LCDPWR: D6.1 D53.1 JEDP1.17 JEDP1.24 R1140.1 U28.3 U33.3
ENVDD_PCH: RH118.2 U46.B38 U55.2 UH1.G36
ERC1: PC1007.1 PU1001.3
ERC2: PC1009.1 PU1001.13
ERC3: PC1008.1 PU1001.12
ESATA_PE1: R44.2 R49.2 U44.9
ESATA_PE2: R43.2 R45.2 U44.8
ESATA_PRX_DTX_N3: C665.1 U44.4
ESATA_PRX_DTX_N3_BP: C680.1 R842.2
ESATA_PRX_DTX_N3_C: C665.2 R842.1 UH1.BC12
ESATA_PRX_DTX_N3_RP: C673.1 U44.12
ESATA_PRX_DTX_P3: C666.1 U44.5
ESATA_PRX_DTX_P3_BP: C677.1 R844.2
ESATA_PRX_DTX_P3_C: C666.2 R844.1 UH1.BE12
ESATA_PRX_DTX_P3_RP: C674.1 U44.11
ESATA_PTX_DRX_N3: C664.1 U44.2
ESATA_PTX_DRX_N3_BP: C678.1 R828.2
ESATA_PTX_DRX_N3_C: C664.2 R828.1 UH1.AR13
ESATA_PTX_DRX_N3_RP: C672.1 U44.14
ESATA_PTX_DRX_P3: C663.1 U44.1
ESATA_PTX_DRX_P3_BP: C679.1 R827.2
ESATA_PTX_DRX_P3_C: C663.2 R827.1 UH1.AT13
ESATA_PTX_DRX_P3_RP: C671.1 U44.15
