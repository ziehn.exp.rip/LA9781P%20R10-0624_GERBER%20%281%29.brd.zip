# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUX_EN_WOWL: length 240.6
  TOP w0.102: R839.1 105.1,163.7 105.1,163.55 v1(105.7,162.95) 105.95,162.7 109.12,162.7 109.27,162.55 114.03,162.55 115.27,161.31 119.59,161.31 v2(119.92,161.65)
  IN4 w0.109: v2(119.92,161.65) 122.35,164.07 127.28,164.07 129.45,161.9 129.45,160.53 128.1,159.17 126.76,159.17 125.95,158.36 125.95,155.94 123.06,153.05 123.06,151.91 120.9,149.75 120.9,139.85 122.5,138.25 122.5,134.53 123.16,133.87 123.16,131.57 124.73,130 124.73,129.02 126.8,126.95 126.8,118.45 125.22,116.87 121.99,116.87 119.43,114.31 119.43,106.55 122.3,103.68 132.84,103.68 132.91,103.61 134.68,103.61 144.97,93.32 185.63,93.32 210.09,68.86 216.49,68.86 218.79,66.56 227.35,66.56 229.51,68.72 232.49,68.72 233.32,69.54 233.32,72.94 234.22,73.84 241.55,73.84 v2(242,73.39)
  BOTTOM w0.102: U46.B67 241.73,73.66 v2(242,73.39)
AUX_EN_WOWL_R: length 4.3
  TOP w0.102: v1(102.3,163.51) R717.1
  TOP w0.254: R717.1 R839.2 R815.2 103.5,165.56 103.23,165.83 U42.3
AUX_MOD_EN: length 11.9
  IN2 w0.127: v2(232.04,71.71) 232.97,70.78 232.97,67.07 230.69,64.79 v2(230.04,64.79)
  BOTTOM w0.102: v1(231.51,64.79) v2(230.04,64.79) RP8.1 ; U46.A45 232.09,71.66 v2(232.04,71.71)
B_PRE0: length 5.2
  BOTTOM w0.102: v1(183.35,43.32) 183.63,43.04 R46.2 R87.1 183.87,41.67 U26.8
B_PRE1: length 4
  BOTTOM w0.102: U26.19 183.37,33.02 R82.1 R39.2
BAT1_LED#: length 306.9
  TOP w0.102: JIO1.104 20.64,72.3 v2(20.83,72.11) ; v2(240.13,73.33) 240.76,72.71 241.12,72.71 241.45,72.38 242.16,72.38 243.58,70.96 243.58,69.19 244.27,68.5 244.27,67.22 244.63,66.87 247.75,66.87 249.91,64.71 249.91,57.68 250.32,57.28 250.32,55.77 250.78,55.3 250.78,50.98 252.02,49.74 252.02,44.4 250.04,42.41 250.04,41.77 250.37,41.44 v2(250.37,40.6)
  IN4 w0.109: v2(250.37,40.6) 250.14,40.37 248.89,40.37 248.03,39.51 248.03,38.47 247.29,37.73 245.58,37.73 245.03,37.19 245.03,33.88 244.39,33.24 235.99,33.24 235.22,34.01 232.56,34.01 232.25,34.33 231.21,34.33 226.79,38.76 225.26,38.76 222.5,41.52 221.37,41.52 219.78,43.12 208.56,43.12 208.28,43.4 200.4,43.4 197.59,40.59 190.01,40.59 188.58,39.15 177.48,39.15 176.94,39.69 176.33,39.69 173.78,37.14 167.99,37.14 167.3,37.83 121.8,37.83 119.57,40.06 103.58,40.06 102.3,41.35 99.17,41.35 98.55,41.97 82.78,41.97 82.16,42.59 76.45,42.59 76.14,42.27 74.23,42.27 73.69,42.81 62.46,42.81 61.22,44.06 61.22,44.57 56.86,48.93 56.03,48.93 52.86,52.11 52.86,53.3 49.04,57.12 49.04,64.87 45.46,68.45 44.4,68.45 40.61,72.25 25.9,72.25 25.27,71.62 23.4,71.62 22.5,72.52 21.24,72.52 v2(20.83,72.11)
  BOTTOM w0.102: v2(240.13,73.33) 240.23,73.43 U46.B64
BAT2_LED#: length 274.3
  TOP w0.102: v2(21.49,72.11) 20.7,72.9 JIO1.102
  IN3 w0.127: v2(205.36,42.15) 205.36,42.18 205.73,42.56 206.74,42.56 210.83,46.65 210.83,47.93 214.15,51.25 220.48,51.25 221.15,51.92 223.28,51.92 225.96,54.59 225.96,57.62 228.6,60.26 234.92,60.26 235.18,60.52 244.73,60.52 246.15,61.93 246.15,62.94 246.86,63.65 246.86,68.82 245.77,69.91 v2(245.44,69.91)
  IN4 w0.109: v2(205.36,42.15) 204.37,43.14 200.44,43.14 197.68,40.38 190.1,40.38 188.66,38.94 177.25,38.94 176.98,38.67 175.61,38.67 173.87,36.93 167.9,36.93 167.22,37.62 121.72,37.62 119.48,39.85 103.5,39.85 102.21,41.14 99.08,41.14 98.46,41.76 83.47,41.76 83.32,41.62 77.93,41.62 77.56,41.99 74.22,41.99 73.61,42.6 62.37,42.6 61.01,43.97 61.01,44.49 56.81,48.68 55.95,48.68 52.65,51.99 52.65,53.21 48.83,57.03 48.83,64.74 48.4,65.16 48.4,65.16 47,66.56 45.97,66.56 44.97,67.56 44.26,67.56 42.93,68.89 42.71,68.89 41.97,69.63 41.97,70.36 40.29,72.04 29.2,72.04 28.39,71.23 27.23,71.23 27.05,71.41 23.31,71.41 22.61,72.11 v2(21.49,72.11)
  BOTTOM w0.102: v2(205.36,42.15) 205.31,42.15 v1(204.81,41.66) ; v2(245.44,69.91) 245.41,69.94 244.43,69.94 244.35,69.86 244.35,69.48 244.02,69.16 U46.A9
BBS_BIT0_R: length 20.1
  BOTTOM w0.102: UH1.AU2 68.12,73.42 68.04,73.34 67.6,73.34 67.22,73.72 66.39,73.72 65.62,74.49 65.43,74.49 64.99,74.93 64.99,75.19 64.61,75.57 64.61,75.76 63.74,76.62 v1(63.32,76.62) RH37.1 61.8,78.14 60.38,78.14 59.72,78.8 59.36,78.8 57.83,77.28 56.4,77.28 56.16,77.52 56.16,78.75 55.84,79.07 QH5.1 54.32,79.07 53.39,78.14 RH13.1
BBS_BIT1: length 4.6
  BOTTOM w0.076: 71.93,57.65 71.93,58.1 72.13,58.31 72.13,58.59 71.8,58.92 71.8,59.31 UH1.C10
  BOTTOM w0.102: RH119.1 v1(72.11,55.99) 72.11,56.22 71.93,56.4 71.93,57.65
BC_CLK_ECE1117: length 153.5
  TOP w0.102: JKB1.17 JKB1.18 123.5,95.44 v2(123.72,95.21) ; v2(238.56,53.07) 238.12,53.51 237.43,53.51 236.03,54.9 235.84,54.9 235.74,54.8 235.74,53.07 235.61,52.95 235.36,52.95 235.23,53.07 235.23,54.8 235.13,54.9 234.82,54.9 234.72,54.8 234.72,53.63 234.62,53.53 234.32,53.53 234.21,53.63 234.21,54.8 234.11,54.9 229.44,54.9 225.14,59.2 219.41,59.2 213.94,64.66 213.94,66.62 213.16,67.4 v2(213.16,67.7)
  BOTTOM w0.102: v2(123.72,95.21) 124.2,94.73 124.2,92.88 134.01,83.07 147.7,83.07 148.87,84.24 166.06,84.24 168.96,81.34 178.49,81.34 180.93,78.91 183.92,78.91 186.99,75.83 v1(202.32,75.83) 203.45,75.83 211.73,67.55 213.01,67.55 v2(213.16,67.7) ; U51.A20 240.8,51.89 240.13,52.57 239.06,52.57 v2(238.56,53.07)
BC_CLK_ECE5048: length 86.8
  IN1 w0.109: v2(249.22,45.02) 248.94,45.02 248.81,45.15 248.81,45.58 248.68,45.71 248.49,45.71 248.36,45.58 248.36,45.2 248.24,45.07 247.95,45.07 247.82,45.2 247.82,45.59 247.7,45.72 247.45,45.72 247.32,45.59 247.32,45.31 247.2,45.18 245.87,45.18 245.65,45.4 240.09,45.4 239.92,45.57 238.03,45.57 237.53,45.07 236.31,45.07 235.5,45.87 233.27,45.87 232.83,46.31 230.21,46.31 229.73,45.83 221.81,45.83 220.44,44.46 206.63,44.46 v2(206.61,44.47)
  IN3 w0.127: v2(206.61,44.47) 206.61,45.09 213.85,52.33 219.98,52.33 220.63,52.98 222.78,52.98 224.54,54.73 224.54,57.69 228.23,61.39 233.2,61.39 233.76,61.94 233.76,62.57 234.14,62.95 v2(235.28,62.95)
  BOTTOM w0.102: v2(235.28,62.95) 235.48,63.15 U46.A30 ; v2(249.22,45.02) 249.12,44.92 U51.A43
BC_DAT_ECE1117: length 153.2
  TOP w0.102: v2(214.1,67.42) 214.09,67.42 214.09,67.23 215.72,65.6 215.9,65.6 221.89,59.6 225.42,59.6 228.6,56.43 239.47,56.43 240.13,55.77 v2(240.13,55.69) 240.56,55.26 240.56,52.87 241.5,51.93 241.5,49.87 241.14,49.51 v2(241.07,49.51) ; JKB1.13 JKB1.14 125.5,98.62 124.45,97.57 124.45,94.41 v2(124.81,94.04)
  BOTTOM w0.102: v2(214.1,67.42) 214.1,67.63 v1(213.61,68.11) 212.99,68.11 212.66,67.78 211.79,67.78 203.36,76.21 186.95,76.21 184.06,79.11 181.01,79.11 178.57,81.55 169.05,81.55 166.15,84.45 148.79,84.45 147.62,83.27 134.19,83.27 124.41,93.05 124.41,93.64 v2(124.81,94.04) ; v2(240.13,55.69) 240.13,56.25 R817.2 ; v2(241.07,49.51) 240.55,50.03 U51.B21
BC_DAT_ECE5048: length 94.2
  IN1 w0.109: v2(206.01,44.45) 206.01,44.52 206.41,44.92 220.6,44.92 221.72,46.04 229.64,46.04 230.12,46.52 232.92,46.52 233.36,46.08 235.59,46.08 236.4,45.28 237.44,45.28 237.94,45.78 240.31,45.78 240.48,45.62 v2(246.32,45.62)
  IN3 w0.127: v2(246.32,45.62) 246.32,45.74 246.67,46.09 249.58,46.09 249.68,45.99 v2(252.68,45.99) ; v2(206.01,44.45) 206.01,44.81 213.76,52.56 219.89,52.56 220.53,53.21 222.69,53.21 224.31,54.83 224.31,57.78 228.14,61.62 233.11,61.62 233.53,62.04 233.53,63.03 235.53,65.04 235.53,65.67 235.2,66 v2(235.2,66.01)
  BOTTOM w0.102: R814.2 252.75,45.91 v2(252.68,45.99) ; v2(235.2,66.01) 235.73,65.48 U46.B31 ; U51.B45 246.57,45.17 246.32,45.41 v2(246.32,45.62)
BC_INT#_ECE1117: length 148.2
  TOP w0.102: v2(212.55,68.24) 212.55,67.73 213.74,66.53 213.74,64.58 219.35,58.97 225.07,58.97 229.44,54.6 232.87,54.6 234.77,52.69 237.54,52.69 v2(237.95,53.1) ; v2(124.81,93.28) 125.2,93.28 125.32,93.41 125.32,94.3 124.66,94.96 124.66,97.5 126.5,99.34 JKB1.12 126.5,101.44 126.29,101.64 126.29,102.53 126.5,102.74 JKB1.11
  BOTTOM w0.102: v2(124.81,93.28) 127.41,93.28 137.21,83.48 147.53,83.48 148.7,84.65 166.23,84.65 169.13,81.75 178.66,81.75 181.1,79.31 184.14,79.31 187.04,76.42 203.52,76.42 206.72,73.22 207.59,73.22 210.13,70.68 210.13,69.76 211.35,68.54 v1(211.66,68.54) 212.24,68.54 v2(212.55,68.24) ; v2(237.95,53.1) 238.68,52.36 239.88,52.36 240.3,51.94 U51.A19
BC_INT#_ECE5048: length 32
  TOP w0.102: v2(249.25,45.63) 248.74,45.12 247.83,45.12 247.42,45.53 247.42,49.37 247.19,49.59 246.62,49.59 246.3,49.92 246.3,50.25 245.54,51.02 245.54,51.52 246.15,52.13 246.15,52.42 245.65,52.92 245.65,53.52 245.88,53.74 245.88,54.16 245.1,54.94 245.1,57.05 244.83,57.32 244.83,57.95 244.45,58.33 244.45,60.41 242.8,62.07 242.8,62.64 242.02,63.41 241.04,63.41 240.63,63.82 237.72,63.82 237.34,63.44 236.28,63.44 235.9,63.06 v2(235.9,62.94)
  BOTTOM w0.102: v2(249.25,45.63) 249.03,45.42 U51.A42 ; v2(235.9,62.94) 235.98,63.02 U46.A29
BCM5882_ALERT#: length 173.5
  TOP w0.102: v2(239.11,73.33) 239.52,72.93 239.52,71.34 240.36,70.5 242.37,70.5 242.98,69.89 242.98,68.94 243.66,68.25 243.66,66.92 244.32,66.26 245.95,66.26 247.6,64.61 248.46,64.61 249.5,63.56 249.5,61.1 v2(248.99,60.59) ; v2(119.79,36.39) 119.79,34.71 118.9,33.82 JUSH1.7
  IN3 w0.127: v2(119.79,36.39) 120.78,37.38 143.55,37.38 146.57,34.35 155.29,34.35 156.27,33.38 167.27,33.38 168.63,34.74 178.45,34.74 179.54,35.83 187.84,35.83 189.06,37.05 190.69,37.05 192.09,38.44 193.95,38.44 194.46,38.95 204.38,38.95 204.93,39.51 207.31,39.51 217.34,49.54 225.3,49.54 226.72,50.97 226.72,51.39 229.79,54.46 229.79,57.06 230.61,57.87 234.39,57.87 236.04,56.22 244.91,56.22 248.26,59.57 248.26,59.95 248.9,60.59 v2(248.99,60.59)
  BOTTOM w0.102: v2(239.11,73.33) 239.16,73.33 239.23,73.39 U46.B62
BEEP: length 293.1
  TOP w0.102: v1(10.43,89.28) 10.82,89.68 v2(10.82,89.99) 11.23,89.99 13,91.76 13,94.22 13.28,94.5 JIO1.29
  IN3 w0.127: v2(240,49.51) 239.86,49.66 238.5,49.66 236.76,51.4 231.16,51.4 226.48,46.72 218.36,46.72 208.69,37.05 196.99,37.05 193.41,33.46 v2(191.59,33.46)
  IN4 w0.109: v2(191.59,33.46) 190.55,32.42 172.49,32.42 171.97,32.95 169.15,32.95 168.77,32.56 109.59,32.56 108.48,33.67 103.41,33.67 103.14,33.4 98.66,33.4 97.03,31.76 80.23,31.76 79.62,32.37 75.12,32.37 74.72,32.77 67.19,32.77 66.27,33.68 60.7,33.68 56.67,37.7 55.25,37.7 51.39,41.56 51.11,41.56 47.42,45.26 47.42,50.08 45.53,51.96 38.08,51.96 34.77,55.28 34.77,61.65 30.3,66.12 29.36,66.12 29.23,66.25 26.38,66.25 24.51,68.12 22.42,68.12 21.8,67.5 19.31,67.5 14.71,72.1 10,72.1 7.73,74.36 7.73,81.05 8.9,82.22 8.9,88.06 v2(10.82,89.99)
  BOTTOM w0.102: v2(240,49.51) 239.55,49.96 U51.B19
BIA_PWM_EC: length 267.5
  TOP w0.102: v2(243,49.51) 242.64,49.51 241.96,48.83 240.82,48.83 240.41,49.24 240.41,50.41 238.53,52.29 234.57,52.29 233.63,53.23 231.31,53.23 231.01,52.92 230.8,52.92 225,58.71 219.32,58.71 213.54,64.5 213.54,66.32 210.03,69.83 210.03,71.27 208.08,73.23 208.08,75.61 208.23,75.76 v2(208.23,76.42)
  IN4 w0.109: v2(208.23,76.42) 207.48,77.17 204.21,77.17 183.29,98.08 148.97,98.08 148.11,97.22 143.59,97.22 135.39,105.42 133.58,105.42 133.52,105.36 123,105.36 121.11,107.25 121.11,112.51 121.83,113.22 124.58,113.22 128.5,117.14 128.5,129.58 128.61,129.69 128.61,136.45 127.2,137.86 127.2,141.37 125.86,142.71 125.61,142.71 125.13,143.18 125.13,147.66 127.52,150.05 128.53,150.05 130.82,152.34 130.82,154.96 134.04,158.17 134.04,163.21 131.46,165.79 130.46,165.79 126.7,169.55 126.7,171.02 126.62,171.11 126.62,172.66 v2(126.59,172.68)
  BOTTOM w0.102: v2(126.59,172.68) 125.43,172.68 124.34,171.59 120.37,171.59 v1(119.65,172.31) 118.72,173.24 113.18,173.24 111.91,171.97 110.76,171.97 110,171.21 106.74,171.21 105.17,172.78 103.75,172.78 102.88,171.92 102.88,169.13 102.07,168.31 99.18,168.31 D71.2 ; U51.B25 242.55,49.96 v2(243,49.51)
BIA_PWM_LVDS: length 56.9
  TOP w0.102: v2(121,169.86) 121.22,169.86 v1(122.38,168.71) 122.76,168.33 122.76,163.14 123.87,162.03 124.5,162.03 127.61,158.92 129.77,158.92 131,157.69 131,151.31 130.31,150.62 R208.1
  BOTTOM w0.102: R1137.1 R207.2 98.53,166.61 98.53,165.64 D71.1 D68.1 D66.1 103.39,167.12 105.1,167.12 106.91,165.32 110.36,165.32 111.05,164.63 112.19,164.63 112.88,165.32 117.45,165.32 119.61,167.48 119.61,168.72 120.75,169.86 v2(121,169.86)
BIA_PWM_PCH: length 134.9
  TOP w0.102: v2(83.06,64) 83.44,63.61 86.73,63.61 87.35,64.23 87.35,64.81 87.63,65.09 90.9,65.09 91.36,65.55 91.36,65.6 v2(91.67,65.9) ; v2(125.6,84.14) 126.01,84.54 128.37,84.54 136.32,92.49 136.32,106.72 135.91,107.13 135.91,148.1 139.14,151.32 v1(139.88,151.32) 143.48,151.32 144.12,151.96 R1996.1
  IN3 w0.127: v2(91.67,65.9) 92.58,66.82 94.74,66.82 96.39,68.47 97.84,68.47 101.5,72.12 110.82,72.12 112.9,74.21 112.9,78.35 118.31,83.76 124.48,83.76 124.87,84.14 v2(125.6,84.14)
  BOTTOM w0.102: UH1.N36 82.71,63.65 v2(83.06,64)
BIA_PWM_PCH_R: length 41.8
  TOP w0.102: R1996.2 R127.2 143.2,153.45 v1(143.2,156.01) 143.2,157.09 v2(143.41,157.29)
  IN1 w0.109: v2(143.41,157.29) 140.42,157.29 135.21,152.08 130.34,152.08 129.22,153.2 128.42,153.2 128.01,152.79 127.1,152.79 v2(127.02,152.87)
  IN4 w0.109: v2(127.02,152.87) 127.07,152.92 127.07,153.51 126.69,153.89 124.79,153.89 123.69,152.79 123.69,151.64 122.72,150.67 122.72,141.15 v2(122.71,141.14)
  BOTTOM w0.102: U23.21 122.93,141.35 v2(122.71,141.14)
BIA_PWM_SW: length 67.7
  IN4 w0.109: v2(123.87,141.14) 123.15,141.86 123.15,148.23 126.34,151.42 127.98,151.42 128.26,151.7 128.26,154.29 129.47,155.5 129.47,159.24 130.99,160.76 130.99,163.05 129.41,164.62 129.41,165.78 126.07,169.13 126.07,170.76 124.9,171.93 121.83,171.93 121.03,172.73 119.02,172.73 v2(118.82,172.53)
  BOTTOM w0.102: U23.19 123.73,141.28 v2(123.87,141.14) ; D66.2 103.08,168.92 103.08,171.83 103.83,172.58 104.85,172.58 v1(105.66,171.77) 106.42,171.01 110.08,171.01 110.84,171.77 111.99,171.77 113.26,173.04 118.31,173.04 v2(118.82,172.53)
BLK_MOSFET_GC: length 2.4
  BOTTOM w0.254: PU1001.30 265.22,32.18 265.96,31.43 PR1006.2
BLKNG_MOSFET_GC: length 2.7
  BOTTOM w0.254: PU1001.20 259.97,34.76 259.43,35.29
  BOTTOM w0.508: v1(259.43,35.31) 259.43,35.29 258.93,35.8 PR1009.2
BLUE_CRT: length 92.5
  IN4 w0.109: v2(103.99,108.12) 104.27,108.4 104.27,113.11 104.86,113.71 104.86,120.76 105.18,121.08 105.18,125.69 104.88,126 104.88,129.02 104.98,129.13 105.73,129.13 105.84,129.23 105.84,129.67 105.73,129.78 104.98,129.78 104.88,129.89 104.88,130.33 104.98,130.44 105.73,130.44 105.84,130.55 105.84,130.98 105.73,131.09 104.98,131.09 104.88,131.2 104.88,131.86 110.16,137.15 110.16,138.07 110.26,138.17 110.63,138.17 110.74,138.28 110.74,138.72 110.63,138.83 110.26,138.83 110.16,138.93 110.16,139.38 110.26,139.48 110.63,139.48 110.74,139.59 110.74,140.03 110.63,140.14 110.26,140.14 110.16,140.24 110.16,142.67 110.59,143.1 110.59,143.96 110.34,144.21 110.34,145.86 110.46,145.99 111.81,145.99 111.94,146.11 111.94,146.55 111.81,146.67 110.39,146.67 110.26,146.8 110.26,147.3 110.39,147.42 111.85,147.42 111.97,147.55 111.97,147.74 112.32,148.09 112.32,148.71 112.21,148.82 111.86,148.82 111.76,148.92 111.76,149.37 111.86,149.48 112.21,149.48 112.32,149.58 112.32,150 109.77,152.55 103.57,152.55 94.56,161.56 93.02,161.56 92.04,162.53 89.85,162.53 v2(89.76,162.62)
  BOTTOM w0.102: v2(103.99,108.12) v1(100.81,108.12) 99.31,108.12 98.53,107.34 U19.31 ; L3.1 89.67,161.01 C22.1 R55.1 v2(89.76,162.62)
BLUE_CRT_L: length 13.6
  BOTTOM w0.102: L3.2 88.95,162.22 C13.1 88.95,164.63 88.57,165.01 88.57,169.86 v1(88.29,170.14) 86.13,172.3 86.13,173.96 JCRT1.3
BLUE_DOCK: length 13.1
  IN3 w0.127: v2(94.31,108.93) 94.07,108.93 93.11,109.88 93.11,115.43 v2(93.78,116.09)
  BOTTOM w0.102: v2(94.31,108.93) U19.22 ; JDOCK1.45 92.74,117.81 92.99,117.56 92.99,117.05 93.32,116.72 93.32,116.52 93.75,116.09 v2(93.78,116.09) 93.78,116.05 v1(94.5,115.33)
BOARD_ID: length 12.5
  IN3 w0.127: v2(231.55,45.63) 232.36,46.44 238.77,46.44 238.94,46.62 239.31,46.62 239.54,46.39 239.54,46.38 v2(239.7,46.22)
  BOTTOM w0.102: v1(231.25,46.28) 231.55,45.99 v2(231.55,45.63) 232.15,45.63 R875.2 C744.1 ; U51.B10 238.81,46.67 238.87,46.6 239.28,46.6 239.29,46.6 239.33,46.6 v2(239.7,46.22)
BOOT1:
  vias: v1(154.65,165.51)
BOOT2:
  vias: v1(159.45,168.31)
BOOT3: length 5.3
  TOP w0.102: v2(200.84,167.51) 200.84,167.44 201.05,167.23 v1(201.48,167.23)
  TOP w0.254: PU501.2 v2(200.84,167.51)
  BOTTOM w0.635: PR502.2 202.12,169.8 202.21,169.71 202.21,169.14 200.84,167.78 v2(200.84,167.51)
BOOT_1.35V: length 4.2
  BOTTOM w0.102: PR200.2 145.1,22.1 v1(144.64,21.64)
  BOTTOM w0.203: PU200.18 147.58,22.46
  BOTTOM w0.508: PR200.2 146.04,22.1 146.45,22.51 147.53,22.51 147.58,22.46
BQ24737_VDD: length 47.3
  IN3 w0.508: v2(224.28,22.34) 225.02,21.6 231.72,21.6 232.1,21.22 235.51,21.22 237.88,18.85 237.88,18.33 v3(238.3,17.91) 238.3,17.18 239.24,16.24 241.06,16.24 243.42,13.88 v2(255.59,13.88)
  BOTTOM w0.254: 224.51,27.57 224.98,28.05 PU700.16
  BOTTOM w0.508: v2(255.59,13.88) 256.17,14.47 PR771.1 PR772.1 ; PR738.1 238.29,17.92 v3(238.3,17.91) ; v2(224.28,22.34) 223.53,22.34 222.73,23.14 PD703.2 223.36,24.51 224.44,24.51 224.93,25 PC745.1 224.51,25.43 v1(224.51,26.16) 224.51,27.57
BREATH_LED#: length 247.4
  TOP w0.102: v2(285.95,87.11) 285.95,87.11 Q84.1 ; v1(287.73,91.21) v2(287.25,90.73) Q84.4
  IN1 w0.109: v2(234.9,68.06) 240.6,68.06 241.13,68.59 242.66,68.59 243.53,69.46 243.91,69.46 244.88,70.42 245.9,70.42 247.01,69.32 247.01,68.84 247.31,68.54 248.97,68.54 250.11,69.69 261.95,69.69 262.29,69.35 276.83,69.35 277.52,70.04 278.32,70.04 278.93,70.65 278.93,78.95 280.77,80.79 280.77,85.26 282.62,87.11 v2(285.95,87.11) 287.25,88.41 v2(287.25,90.73)
  IN4 w0.109: v2(116.31,124.61) 116.31,124.22 117.42,123.1 117.42,121.32 117.35,121.25 117.35,106.97 118.35,105.97 118.5,105.97 121.75,102.72 121.75,102.16 125.32,98.59 125.32,96.53 130.88,90.97 168.51,90.97 172.97,86.5 174.55,86.5 183.36,77.69 198.15,77.69 208.22,67.61 208.22,67.12 211.48,63.86 218.28,63.86 219.4,64.99 228.12,64.99 230.36,67.23 230.36,67.97 230.86,68.47 233.73,68.47 233.78,68.52 234.45,68.52 v2(234.9,68.06)
  BOTTOM w0.102: v2(234.9,68.06) 234.9,68.07 234.36,67.53 234,67.53 233.88,67.41 U46.B39 ; v2(116.31,124.61) 114.77,124.61 114.15,123.99 114.15,123.67 113.88,123.41 112.43,123.41 111.62,122.59 109.22,122.59 107.74,124.07 JDOCK1.98
BREATH_LED#_Q: length 368.8
  TOP w0.102: v2(292.71,84.39) 292.07,85.03 286.87,85.03 v1(285.11,86.78) 284.83,87.06 R955.2 ; v2(20.73,74.13) 20.69,74.1 JIO1.98
  IN1 w0.109: v2(292.71,84.39) 292.66,84.34 292.66,76.42 295,74.07 295,62.71 281.63,49.33 268.13,49.33 254.84,36.04 253.28,36.04 251.25,34.01 246.78,34.01 244.83,32.06 234.35,32.06 233.79,32.63 223.01,32.63 219.51,36.13 200.99,36.13 192.71,27.85 178.59,27.85 177.65,26.91 161.64,26.91 159.99,25.26 150.39,25.26 147.75,27.9 139.06,27.9 137.39,29.58 125.5,29.58 123.7,27.78 119.71,27.78 110.46,18.53 99.49,18.53 92.2,25.82 70.2,25.82 66.47,29.55 66.47,30.27 56.94,39.8 55.72,39.8 54.33,41.2 54.33,42.42 49.13,47.62 49.13,62.14 48.8,62.46 48.8,64.22 47.2,65.82 45.63,65.82 42.69,68.76 42.32,68.76 39.27,71.82 36.64,71.82 35.9,71.08 29.16,71.08 28.5,70.42 27.28,70.42 26.39,71.31 26.39,72.49 25.3,73.57 22.43,73.57 21.87,74.13 v2(20.73,74.13)
BREATH_WHITE_LED: length 8.6
  TOP w0.102: R956.2 283.13,92.14 v2(280.22,92.14) 280.01,92.14 279.49,91.62 JPB1.4
  BOTTOM w0.102: v2(280.22,92.14) 279.54,91.45 v1(278.8,91.45)
BST1_3V: length 3
  BOTTOM w0.102: PR108.1 38.32,42.88 v1(38.89,42.32)
  BOTTOM w0.508: PC112.2 36.21,42.88 PR108.1
BST1_5V: length 3.3
  BOTTOM w0.102: PR107.2 37.02,33.05 38.84,33.05 v1(39.15,32.73)
BST_3V: length 4
  BOTTOM w0.102: PR108.2 38.13,41.48 v1(38.78,40.83)
  BOTTOM w0.203: PU101.9 36.33,40.1 36.6,40.37 36.6,40.5 36.75,40.66
  BOTTOM w0.508: PR108.2 37.5,41.41 36.75,40.66
BST_5V: length 3.2
  BOTTOM w0.203: v1(36.59,35.14) 36.33,35.4 PU101.17
  BOTTOM w0.254: v1(36.59,35.14) 37.68,34.05 PR107.1
BST_+1.05VSP:
  vias: v1(35.74,63.59) v3(35.28,61.15) v3(35.28,60.52)
BST_CHG: length 4.4
  BOTTOM w0.254: PU700.17 224.92,28.55 224.74,28.37 v1(224.34,28.37) 224.16,28.37 223.64,27.85 PR765.1 223.17,26.72 PD703.1
BST_CHG_IMON: length 27.4
  TOP w0.102: v2(242.01,42.81) 242.09,42.81 242.49,42.41 242.49,40.88 242.59,40.78 242.59,38.32 243.51,37.4 243.51,33.29 243.1,32.88 241.32,32.88 238.8,30.35 v2(238.8,30.07)
  BOTTOM w0.102: PR705.1 232.71,31.97 233.63,31.97 234.19,31.41 234.19,30.57 233.92,30.3 233.92,29.63 234.24,29.31 238.03,29.31 v1(238.35,29.63) v2(238.8,30.07) ; v2(242.01,42.81) 242.55,42.27 U51.B61
BST_CHG_MODE#: length 122.5
  TOP w0.102: v2(205.76,66.94) 207.19,65.52 207.19,60.85 214.65,53.38 218.29,53.38 224.23,47.44 225.75,47.44 227.22,45.96 228.44,45.96 228.88,45.52 228.88,42.52 227.53,41.18 227.53,40.04 228.47,39.1 228.47,37.44 235.86,30.05 235.86,25.41 235.53,25.08 235.51,25.08 v2(235.36,24.93)
  IN4 w0.109: v2(251.85,20.54) 251.85,22.25 251.14,22.97 238.93,22.97 236.97,24.93 v2(235.36,24.93) ; v2(241.56,66.05) 241.25,66.05 240.66,66.64 235.94,66.64 235.74,66.43 233.48,66.43 232.4,65.35 232.12,65.35 231.01,64.25 229.11,64.25 228.02,63.15 225.76,63.15 225.5,63.41 220.01,63.41 219.83,63.23 211.22,63.23 207.8,66.66 206.05,66.66 v2(205.76,66.94)
  BOTTOM w0.102: v2(241.56,66.05) 241.99,66.49 242.44,66.49 242.52,66.41 U46.B15 ; PR718.2 252.55,20.66 v1(252.47,20.74) 252.46,20.75 252.07,20.75 v2(251.85,20.54) ; PR716.2 234.69,24.27 v2(235.36,24.93)
BT_ACTIVE: length 6.4
  TOP w0.102: JBT1.6 v2(297.56,107.58)
  BOTTOM w0.102: Q318.5 v1(294.31,106.24) 296.24,106.24 297.56,107.56 v2(297.56,107.58)
BT_COEX_STATUS2: length 284.4
  TOP w0.102: JBT1.4 299.56,107.58 v2(299.59,107.61) ; v2(113.89,30.19) 113.47,29.77 112.28,29.77 111.43,30.62 111.43,31.33 R221.1
  IN3 w0.127: v2(287.12,56.96) 278.13,47.97 278.13,34.4 276.2,32.47 276.2,30.16 272.57,26.53 258.01,26.53 254.03,30.51 248.45,30.51 246.04,32.92 236.73,32.92 234.48,35.17 234.48,35.75 234,36.22 232.81,36.22 232.62,36.03 220.03,36.03 219.3,35.29 209.88,35.29 209.49,34.9 198.61,34.9 192.58,28.87 189.86,28.87 187.93,30.8 181.25,30.8 178.64,28.18 166.96,28.18 166.23,27.45 156.55,27.45 153.82,30.18 143.93,30.18 142.27,31.84 128.65,31.84 126.62,29.81 117.45,29.81 117.07,30.19 v2(113.89,30.19)
  IN4 w0.109: v2(299.59,107.61) 298.35,106.36 294.46,106.36 290.55,102.45 290.55,99 286.16,94.62 286.16,89.87 293.6,82.44 293.6,61.76 288.8,56.96 v2(287.12,56.96)
  BOTTOM w0.102: R1133.2 299.13,112.42 v1(299.89,111.66) 299.89,107.91 v2(299.59,107.61)
BT_LED: length 380.6
  TOP w0.102: JIO1.92 20.51,75.9 v2(20.65,76.04)
  IN1 w0.109: v2(292.3,102.35) 291.74,101.79 291.49,101.79 290.89,101.19 290.89,91.92 292.74,90.08 292.74,89 292.3,88.56 292.3,83.18 292.44,83.03 292.44,76.32 294.79,73.97 294.79,62.83 281.51,49.54 268.04,49.54 254.75,36.25 253.2,36.25 251.17,34.22 246.69,34.22 244.75,32.27 234.44,32.27 233.87,32.84 223.1,32.84 219.58,36.36 200.92,36.36 192.64,28.08 178.52,28.08 177.57,27.12 161.55,27.12 159.9,25.47 150.48,25.47 147.84,28.11 139.15,28.11 137.21,30.05 125.47,30.05 123.45,28.03 119.66,28.03 110.38,18.74 99.64,18.74 92.35,26.03 70.29,26.03 66.68,29.64 66.68,30.36 57.03,40.01 55.81,40.01 54.54,41.28 54.54,42.5 49.34,47.71 49.34,62.22 49.01,62.55 49.01,64.31 47.29,66.03 45.72,66.03 42.78,68.97 42.42,68.97 39.33,72.07 36.59,72.07 35.82,71.3 29.08,71.3 28.44,70.66 27.39,70.66 26.67,71.38 26.67,72.51 25.37,73.8 23.06,73.8 20.83,76.04 v2(20.65,76.04)
  BOTTOM w0.102: R941.2 291.86,102.79 v2(292.3,102.35)
BT_LED#: length 12
  TOP w0.102: Q89.3 137.28,168.01 134.8,168.01 v1(134.05,167.27) 133.5,166.71 R726.1 133.5,163.94 132.1,162.55 132.1,161.15 v2(132.13,161.13)
  BOTTOM w0.102: v2(132.13,161.13) 131.89,160.89 JMINI2.46
BT_LED#_R: length 269.5
  TOP w0.102: v2(134.62,117.56) 134.62,143.29 134.92,143.6 134.92,149.28 141.3,155.65 v1(141.3,159.54) 141.3,160.01 135.42,165.89 Q89.1
  IN1 w0.109: v2(291.69,104.94) 291.46,104.94 289.46,102.93 289.46,94.55 280.1,85.2 280.1,84.59 277.9,82.39 277.9,82.12 276.9,81.11 276.9,80.75 275.05,78.9 265.24,78.9 263.63,77.28 262.13,77.28 261.37,76.52 251.43,76.52 251.05,76.9 245.18,76.9 244.37,76.09 241.63,76.09 241.43,75.88 240.54,75.88 240.13,76.29 240.13,76.65 240.33,76.85 240.33,77.46 239.51,78.28 235.98,78.28 234.54,79.72 231.01,79.72 225.02,85.71 225.02,87.53 v2(223.82,88.72)
  BOTTOM w0.102: v2(223.82,88.72) 221.52,88.72 218.13,85.33 213.46,85.33 208.71,90.08 203.45,90.08 197.23,96.3 191.66,96.3 189.76,98.21 161.89,98.21 159.43,100.66 159.43,106.12 153.46,112.09 145.21,112.09 139.86,106.74 136.88,106.74 135.41,108.22 135.41,116.78 v2(134.62,117.56) ; v2(291.69,104.94) 291.64,104.94 291.34,104.64 291.34,104.37 291.27,104.31 R938.2 290.84,105.43 Q318.1 291.06,105.65 291.39,105.65 291.57,105.83 291.57,106.64 291.32,106.89 Q318.3
BT_PRI_STATUS: length 274.2
  TOP w0.102: JUSH1.12 118.45,31.32 118.87,31.74 121.39,31.74 v2(122.78,30.34) ; JBT1.5 v2(298.56,107.58)
  IN3 w0.127: v2(122.78,30.34) 126.26,30.34 128.04,32.12 142.4,32.12 144.12,30.4 153.91,30.4 156.63,27.69 166.14,27.69 166.87,28.41 178.49,28.41 181.1,31.03 188.09,31.03 190.02,29.1 192.43,29.1 198.5,35.17 209.43,35.17 209.79,35.52 219.2,35.52 219.94,36.26 232.52,36.26 232.71,36.45 234.1,36.45 234.71,35.84 234.71,35.27 236.83,33.15 246.14,33.15 248.55,30.73 254.12,30.73 258.07,26.78 272.46,26.78 275.87,30.19 275.87,32.68 277.87,34.69 277.87,48.43 v2(286.41,56.96)
  IN4 w0.109: v2(298.56,107.58) 297.6,106.62 294.42,106.62 290.34,102.53 290.34,99.09 285.95,94.7 285.95,87.72 293.39,80.28 293.39,61.88 288.9,57.39 286.84,57.39 v2(286.41,56.96)
  BOTTOM w0.102: R1134.2 299.26,110.64 v1(299.26,110.01) 299.26,108.28 v2(298.56,107.58)
BT_RADIO_DIS#: length 318
  TOP w0.102: v2(241.83,78.42) 242.35,78.42 244.32,76.45 244.32,75.43 246.18,73.57 246.18,71.53 246.4,71.3 246.4,68.36 v2(245.52,67.48) ; v2(134.72,171.34) 134.77,171.39 D36.1
  IN4 w0.109: v2(265.48,82.89) 262.08,79.5 248.59,79.5 247.21,78.12 242.26,78.12 241.96,78.42 v2(241.83,78.42) 241.76,78.35 232.5,78.35 230.24,76.1 230.24,71.99 228.66,70.4 227.59,70.4 226.64,69.45 226.64,68.78 226.2,68.35 221.3,68.35 213.56,76.09 210.74,76.09 209.09,77.74 206.6,77.74 184.71,99.63 143.08,99.63 136.42,106.29 133.83,106.29 133.12,105.58 123.09,105.58 121.33,107.34 121.33,112.4 121.93,113.01 124.67,113.01 128.72,117.05 128.72,129.49 128.83,129.61 128.83,136.53 127.41,137.94 127.41,141.46 126.39,142.48 126.39,148.61 127.61,149.84 128.62,149.84 131.03,152.25 131.03,154.87 134.25,158.08 134.25,163.3 132.97,164.58 132.97,169.58 v2(134.72,171.34)
  BOTTOM w0.102: v2(245.52,67.48) 245.11,67.07 244.52,67.07 244.44,67.16 U46.A13 ; R694.1 297.67,110 D28.1 298.1,110.37 298.5,109.97 298.5,108.47 298.14,108.12 298.14,106.82 296.77,105.45 295.5,105.45 293.52,103.47 293.52,102.2 293.11,101.79 291.63,101.79 289.01,99.17 283.47,99.17 282.38,98.08 281.87,98.08 279.87,96.09 279.87,95.91 276.46,92.51 276.46,91.58 276.02,91.14 276.02,87.2 276.78,86.44 v1(276.78,84.98) 276.78,83.68 275,81.9 266.47,81.9 v2(265.48,82.89) ; R696.1 134.34,170.96 v2(134.72,171.34)
BT_RADIO_DIS#_CON: length 5
  TOP w0.102: v2(296.16,107.61) 296.56,107.21 JBT1.7
  BOTTOM w0.102: v2(296.16,107.61) 296.01,107.76 v1(296.01,108.12) C754.1 R694.2 297.93,109.08 D28.2
BT_RADIO_DIS#_R: length 6.8
  TOP w0.102: R727.1 133.62,171.64 D36.2 134.09,171.39 v2(134.72,170.75) 135.04,170.75 v1(135.89,169.9)
  BOTTOM w0.102: JMINI2.51 133.89,169.85 R696.2 134.09,170.12 v2(134.72,170.75)
CAM_MIC_CBL_DET#: length 131.1
  TOP w0.076: v2(73.38,62.55) 73.79,62.14 73.79,60.31 74.04,60.06 74.04,59.65
  TOP w0.102: RH86.2 73.63,47.51 74.83,48.71 74.83,53.4 74.04,54.19 74.04,59.65 ; JCAM1.16 5.12,123.19 9.76,123.19 13.1,119.85 19.02,119.85 22.71,116.17 22.71,107.14 v1(25.94,103.9) 25.94,102.59 29.11,99.43 34.36,99.43 v2(41.78,92.01)
  IN4 w0.109: v2(41.78,92.01) 42.47,92.7 43.54,92.7 44.08,93.23 53.64,93.23 54.64,92.24 55.44,92.24 56.13,91.55 61.33,91.55 67.03,85.85 67.03,81.24 66.9,81.12 66.9,77.06 68.3,75.67 68.3,68.62 67.99,68.32 67.99,65.69 68.48,65.21 68.48,64.43 69.34,63.56 72.69,63.56 72.9,63.36 72.9,62.98 73.33,62.55 v2(73.38,62.55)
  BOTTOM w0.102: v2(73.38,62.55) 73.59,62.76 UH1.L15
CARD_SMBCLK: length 262.9
  TOP w0.102: JIO1.48 20.03,89.1 20.22,88.91 20.39,88.91 20.9,88.41 21.08,88.41 v2(21.18,88.51)
  IN4 w0.109: v2(21.18,88.51) 21.03,88.35 20.75,88.35 20.39,87.99 20.39,86.43 20.86,85.95 21.7,85.95 25.3,82.35 32.67,82.35 33.79,81.23 35.05,81.23 39.06,77.23 40.08,77.23 41.85,75.45 41.85,74.18 43.46,72.57 43.88,72.57 45.19,71.27 45.32,71.27 51,65.6 51,57.98 54.85,54.12 54.85,53.23 56.09,52 57.48,52 61.89,47.59 63.77,47.59 65.25,46.11 71.88,46.11 73.06,44.94 76.27,44.94 77.14,45.81 79.17,45.81 79.83,45.15 82.53,45.15 83.73,43.95 103.63,43.95 105.49,42.09 120.22,42.09 121.82,40.49 171.29,40.49 172.41,41.61 177.37,41.61 177.7,41.94 188.37,41.94 188.99,42.56 196.66,42.56 200.13,46.03 208.23,46.03 209.46,44.8 221.1,44.8 221.15,44.84 226.03,44.84 228.97,41.91 235.01,41.91 235.31,41.61 237.49,41.61 238.32,40.78 246.28,40.78 246.83,41.33 247.2,41.33 v2(247.45,41.09)
  BOTTOM w0.102: v2(247.45,41.09) 247.08,40.72 U51.A49
CARD_SMBDAT: length 262.2
  TOP w0.102: JIO1.50 20.06,88.5 20.24,88.69 20.3,88.69 20.81,88.18 20.93,88.18 v2(21.18,87.92)
  IN4 w0.109: v2(21.18,87.92) 20.99,88.12 20.85,88.12 20.62,87.89 20.62,86.53 20.96,86.19 21.8,86.19 25.4,82.59 32.77,82.59 33.89,81.47 35.15,81.47 39.16,77.47 40.17,77.47 42.09,75.55 42.09,74.28 43.56,72.81 43.98,72.81 45.28,71.51 45.42,71.51 51.24,65.69 51.24,58.07 55.09,54.22 55.09,53.33 56.19,52.24 57.58,52.24 61.99,47.82 63.87,47.82 65.35,46.35 71.98,46.35 73.15,45.17 76.17,45.17 77.04,46.05 79.26,46.05 79.92,45.39 82.63,45.39 83.83,44.19 103.73,44.19 105.59,42.33 120.32,42.33 121.92,40.73 171.19,40.73 172.31,41.85 177.27,41.85 177.6,42.18 188.27,42.18 188.89,42.8 196.56,42.8 200.03,46.27 208.33,46.27 209.56,45.04 221.01,45.04 221.05,45.08 226.13,45.08 229.07,42.15 235.11,42.15 235.41,41.85 237.59,41.85 238.42,41.02 246.18,41.02 246.73,41.57 247.57,41.57 v2(247.65,41.64)
  BOTTOM w0.102: v2(247.65,41.64) 247.57,41.57 U51.B52
CARDCLK_REQ#: length 68.8
  TOP w0.102: v2(27.25,91.99) 27.15,92.09 27.15,92.37 25.7,93.82 24.18,93.82 24.09,93.9 JIO1.32 ; v2(65.59,69.81) 65.59,70.06 65.3,70.35 65.05,70.35 62.33,73.06 RH120.2 61.77,74.16 60.96,74.16 60.93,74.13 60.58,74.13 RH22.1 58.83,74.82 57.89,74.82 57.66,74.59 56.06,74.59 53.77,76.88 53.77,80.07 53.54,80.3 53.54,83.47 53.14,83.88 v1(53.14,87.92) v2(53.14,89.01)
  IN1 w0.109: v2(53.14,89.01) 53.08,89.01 52.55,88.48 44.83,88.48 42.65,90.67 38.96,90.67 38.81,90.51 36.4,90.51 35.89,91.02 31.11,91.02 29.56,92.57 27.79,92.57 27.25,92.04 v2(27.25,91.99)
  BOTTOM w0.102: UH1.AF3 68.62,69.07 68.15,69.07 67.94,69.28 66.48,69.28 66.23,69.53 65.88,69.53 v2(65.59,69.81)
CCD_OFF: length 284.5
  TOP w0.102: Q24.2 25.52,113.84 24.17,112.49 v1(24.17,111.61) 24.17,106.14 29.57,100.75 v2(29.57,99.84)
  IN3 w0.127: v2(29.57,99.84) 29.37,99.64 29.37,91.21 27.56,89.4 27.56,84.3 31.61,80.25 34.89,80.25 37.61,77.53 37.61,73.94 41.86,69.7 41.86,68.64 42.91,67.59 42.91,64.67 43.55,64.03 43.55,62.55 45.57,60.53 45.57,58.19 54.48,49.27 57.66,49.27 59.41,47.52 63.5,47.52 63.93,47.09 66.01,47.09 67.74,45.36 69.64,45.36 70.07,44.93 71.89,44.93 72.55,44.27 75.68,44.27 76.11,43.84 79.77,43.84 80.21,44.27 99.6,44.27 102.06,41.82 121.21,41.82 122.76,40.27 144.68,40.27 147.67,37.28 166.66,37.28 168.09,38.71 170.65,38.71 172.34,40.4 177.52,40.4 178.23,41.11 187.88,41.11 188.39,41.62 192.11,41.62 197.57,47.08 203.73,47.08 207.64,50.99 207.64,51.43 224.55,68.34 226.37,68.34 227.79,69.76 228.62,69.76 229.99,71.13 233.63,71.13 233.93,70.83 234.62,70.83 235.01,70.44 v2(235.01,70.3)
  BOTTOM w0.102: U46.B43 233.88,69.41 234.06,69.58 234.28,69.58 235.01,70.3 v2(235.01,70.3)
CD: length 3.7
  TOP w0.254: U44.18 2.79,149.42 v2(2.78,149.4)
  BOTTOM w0.102: v1(1.05,150.18) R840.1
  BOTTOM w0.254: v2(2.78,149.4) 2.67,149.29 R853.1 R840.1
CD3301_DCIN: length 5.9
  BOTTOM w0.102: v1(267.05,26.47) 266.52,25.93 PR1011.2
  BOTTOM w0.203: PU1001.1 263.47,27.33 263.7,27.09
  BOTTOM w0.508: PR1011.2 265.5,25.91 PC1006.1 264.01,26.79 263.7,27.09
CD3301_NBDOCK_DC_IN_SS: length 20.7
  TOP w0.102: v2(256.74,22.7) 257.63,23.58 257.63,26.07 256.54,27.17 256.54,35.88 256.03,36.39 v2(255.95,36.39)
  BOTTOM w0.102: v2(256.74,22.7) 257.1,22.34 PR1070.2 ; PR1024.1 v1(257.05,36.31) 256.03,36.31 v2(255.95,36.39)
  BOTTOM w0.254: PU1001.19 259.47,34.53 258.04,35.95 PR1024.1
CD3301_SDC_IN: length 2.6
  BOTTOM w0.254: PU1001.6 v1(260.97,26.96) 260.97,26.56 260.45,26.05 PR1015.2
CD_PBATT_OFF: length 2.8
  BOTTOM w0.254: PR1016.1 264.26,36.11 v1(263.52,35.36) 262.97,34.81 PU1001.26
CEXT: length 4.6
  TOP w0.102: C86.1 v1(34.54,149.95) 33.74,150.75 33.74,151.4 33.5,151.64 U9.1
CEXT_8331: length 3.4
  BOTTOM w0.102: C97.2 31.42,122.52 v1(30.75,121.84)
  BOTTOM w0.203: C97.2 32.36,122.87 32.55,122.68 U629.47
CFD_PWRBTN#_XDP: length 1.7
  TOP w0.102: RC6.2 212.67,120.94 JXDP1.16
CFG0: length 9.8
  TOP w0.102: JCPU1.AT20 199.01,123.84 200.33,122.52 202.03,122.52 v1(202.94,121.6) 203.45,121.1 RC21.1
CFG1: length 6.1
  TOP w0.102: T90.1 199.99,121.69 198.37,123.3 196.06,123.3 195.59,123.78 JCPU1.AR20
CFG2: length 8
  TOP w0.102: JCPU1.AP20 194.59,123.87 195.05,124.32 199.08,124.32 200.02,123.38 T103.1 RC76.1
CFG3: length 21.9
  TOP w0.102: JCPU1.AP22 v2(195.06,126.31)
  BOTTOM w0.102: v2(195.06,126.31) 195.06,126.19 195.43,125.82 197.38,125.82 198.5,124.7 198.5,117.62 202.27,113.84 204.21,113.84 204.86,114.49 206.06,114.49 T104.1
CFG4: length 5.8
  TOP w0.102: RC77.1 T105.1 198.3,124.91 197.36,125.84 JCPU1.AT22
CFG5: length 19.9
  TOP w0.102: JCPU1.AN22 v2(194.06,126.31)
  IN1 w0.109: v2(194.06,126.31) 194.06,126.3 194.54,125.82 200.66,125.82 201.32,125.16 204.42,125.16 204.95,125.69 v2(206.09,125.69)
  BOTTOM w0.102: v2(206.09,125.69) 206.3,125.49 207.34,125.49 208.56,124.27 210.08,124.27 T107.1 RC85.1
CFG6: length 14.3
  TOP w0.102: v2(197.05,129.3) 196.59,128.84 JCPU1.AT25
  IN1 w0.109: v2(205.84,127.52) 205.69,127.37 200.35,127.37 198.42,129.3 v2(197.05,129.3)
  BOTTOM w0.102: RC83.1 208.74,126.94 T106.1 206.15,127.22 v2(205.84,127.52)
CFG7: length 17.4
  TOP w0.102: JCPU1.AN23 v2(194.06,127.31)
  IN1 w0.109: v2(194.06,127.31) 193.65,126.9 193.65,123.89 194.49,123.05 198.07,123.05 v2(202.18,118.94)
  BOTTOM w0.102: v2(202.18,118.94) 202.18,118.4 T108.1 203.73,117.79 RC86.1
CFG8: length 23
  TOP w0.102: JCPU1.AR24 v2(196.06,128.31)
  BOTTOM w0.102: v2(196.06,128.31) 196.16,128.31 196.62,127.85 197.53,127.85 199.19,126.2 199.19,117.87 201.65,115.41 204.53,115.41 205.06,115.94 207.16,115.94 T109.1
CFG9: length 4.5
  TOP w0.102: JCPU1.AT23 197.5,126.84 198.06,126.29 T117.1
CFG10: length 11.3
  TOP w0.102: v2(201.42,121.91) 201.42,120.5 T111.1 ; JCPU1.AN20 v2(194.06,124.31)
  IN1 w0.109: v2(194.06,124.31) 194.73,123.64 199.69,123.64 v2(201.42,121.91)
CFG11: length 19.5
  TOP w0.102: JCPU1.AP24 v2(195.06,128.31)
  BOTTOM w0.102: v2(195.06,128.31) 195.17,128.31 196.01,127.47 197.38,127.47 198.93,125.92 198.93,117.82 201.88,114.87 T116.1
CFG12: length 20
  TOP w0.102: v2(195.06,130.31) JCPU1.AP26
  BOTTOM w0.089: v2(195.06,130.31) 195.15,130.31 195.55,129.91 197.36,129.91 199.85,127.42 199.85,118.2 201.27,116.78 203.05,116.78 T119.1
CFG13: length 10.2
  TOP w0.102: T128.1 202.3,127.61 v2(201.93,127.98) ; v2(194.06,129.31) JCPU1.AN25
  IN1 w0.109: v2(201.93,127.98) 200.2,129.71 194.46,129.71 v2(194.06,129.31)
CFG14: length 23.2
  TOP w0.102: v2(194.06,130.31) JCPU1.AN26
  BOTTOM w0.089: v2(194.06,130.31) 194.29,130.31 194.88,129.72 197.28,129.72 199.64,127.35 199.64,118.1 201.85,115.89 204.29,115.89 T127.1
CFG15: length 23.1
  TOP w0.102: v2(195.06,129.31) JCPU1.AP25
  BOTTOM w0.102: T135.1 205.97,116.14 204.98,116.14 204.52,115.68 201.78,115.68 199.43,118.03 199.43,126.82 197.38,128.87 195.48,128.87 195.06,129.29 v2(195.06,129.31)
CFG16: length 17.9
  TOP w0.102: JCPU1.AR21 v2(196.06,125.31)
  BOTTOM w0.102: v2(196.06,125.31) 196.29,125.31 196.29,125.29 198.3,123.28 198.3,117.51 202.21,113.6 T137.1
CFG17: length 20.2
  TOP w0.102: JCPU1.AP21 v2(195.06,125.31)
  BOTTOM w0.102: v2(195.06,125.31) 195.06,125.22 198.09,122.19 198.09,117.31 202.18,113.22 206.18,113.22 T138.1
CFG18: length 6
  TOP w0.102: JCPU1.AR23 195.59,126.85 196.01,127.27 198.88,127.27 200.14,128.52 T139.1
CFG19: length 20.8
  TOP w0.102: v2(195.07,127.32) 194.59,126.84 JCPU1.AP23
  BOTTOM w0.102: v2(195.07,127.32) 195.15,127.32 195.53,126.94 197.16,126.94 198.73,125.36 198.73,117.69 202.23,114.19 204.27,114.19 T140.1
CFG_RCOMP: length 6.1
  TOP w0.102: RC58.1 T136.1 200,134.56 199.49,134.56 199.21,134.84 JCPU1.AT31
CHARGER_SMBCLK: length 39.4
  IN3 w0.127: v2(246.94,42.74) 247.24,42.74 248.13,41.85 248.13,41.31 250.75,38.69 250.75,35.11 250.95,34.91 250.95,33.31 251.56,32.7 252.07,32.7 252.32,32.96 252.32,33.21 v2(252.53,33.41)
  BOTTOM w0.102: PR766.2 232.69,28.87 237.73,28.87 239.37,27.23 v3(246.85,27.23) 247.43,27.23 252.33,32.13 252.33,33.22 v2(252.53,33.41) 252.3,33.64 252.3,33.75 252.44,33.88 RP5.5 ; v2(246.94,42.74) 247.01,42.67 U51.B50
CHARGER_SMBDAT: length 38.2
  IN3 w0.127: v2(249.3,42.28) 248.74,42.28 248.39,41.93 248.39,41.42 250.43,39.37 251,38.8 251,35.22 251.2,35.01 251.2,33.42 251.67,32.96 251.96,32.96 252.07,33.06 252.07,33.21 v2(251.88,33.4)
  BOTTOM w0.102: PR763.2 232.76,29.1 237.82,29.1 239.46,27.46 v3(241.53,27.46) 247.33,27.46 252.1,32.23 252.1,33.18 v2(251.88,33.4) 252.07,33.6 252.07,33.68 251.94,33.82 RP5.6 ; U51.A47 248.79,42.92 249.3,42.41 v2(249.3,42.28)
CHG:
  vias: v1(203.54,13.5)
CLK_80H: length 7.7
  TOP w0.102: RH159.2 v1(85.18,55.93) 85.11,56 85.11,56.13 83.01,58.23 83.01,60.4 v2(82.78,60.63)
  BOTTOM w0.102: v2(82.78,60.63) 82.53,60.38 UH1.F36
CLK_BCLK_ITP: length 5
  BOTTOM w0.089: UH1.AH45 86.44,69.75 86.51,69.68 86.76,69.68 86.92,69.84 87.2,69.84 87.21,69.85 87.22,69.85
  BOTTOM w0.102: 87.22,69.85 87.61,69.85 87.71,69.96 88.02,69.96 88.12,69.85 88.43,69.85 88.53,69.96 88.84,69.96 88.94,69.85 89.19,69.85 89.46,70.12 90.34,70.12 90.42,70.2 90.42,70.4 90.28,70.55 RH156.1
CLK_BCLK_ITP#: length 5
  BOTTOM w0.089: UH1.AH43 85.62,69.7 86.11,69.7 86.39,69.43 86.86,69.43 87.02,69.59 87.2,69.59 87.21,69.58 87.22,69.58
  BOTTOM w0.102: 87.22,69.58 89.3,69.58 89.57,69.85 89.94,69.85 RH154.1
CLK_BUF_BCLK: length 9.7
  TOP w0.076: 78.24,75.22 78.24,75.2 78.29,75.15 78.29,72.93 78.13,72.76 77.98,72.76 77.85,72.89 77.85,73.01 v2(77.89,73.05)
  TOP w0.102: 78.24,75.22 78.24,76.01 78.46,76.22 v3(78.46,77) 78.46,79.15 78.1,79.51 78.1,80.6 77.95,80.76 RPH3.3
  BOTTOM w0.089: UH1.AT24 77.59,73.34 v2(77.89,73.05)
CLK_BUF_BCLK#: length 9.8
  TOP w0.076: v2(77.92,72.4) 78.12,72.6 78.19,72.6 78.46,72.86 78.46,75.16 78.51,75.21 78.51,75.22
  TOP w0.102: RPH3.4 78.45,80.75 78.37,80.67 78.37,79.62 78.73,79.26 v3(78.73,78.51) 78.73,76.11 78.51,75.9 78.51,75.22
  BOTTOM w0.089: UH1.AR24 77.57,72.75 v2(77.92,72.4)
CLK_BUF_CKSSCD: length 10.6
  BOTTOM w0.089: UH1.BC6 70.22,76.61 69.87,76.95 69.87,77.19 69.47,77.58 69.46,77.58 69.45,77.6
  BOTTOM w0.102: RH169.1 62.47,81.54 62.77,81.54 63.31,81 64.25,81 v3(65.04,80.21) 66.03,79.22 67.25,79.22 68.83,77.64 69.41,77.64 69.45,77.6
CLK_BUF_CKSSCD#: length 10.6
  BOTTOM w0.089: 69.64,77.79 69.65,77.78 69.65,77.77 69.96,77.46 70.03,77.46 70.05,77.47 70.16,77.47 70.24,77.39 70.24,77.28 70.15,77.19 70.15,77.12 UH1.BE6
  BOTTOM w0.102: 69.64,77.79 69.51,77.92 68.93,77.92 67.36,79.49 66.14,79.49 64.36,81.27 v3(63.71,81.27) 63.42,81.27 62.88,81.81 62.35,81.81 62.21,81.94 62.21,82.16 RH167.1
CLK_BUF_DMI: length 7.7
  TOP w0.102: RPH3.1 76.95,80.63 76.95,80.63 76.95,79.86 77.35,79.45 77.35,78.21 77.6,77.96 77.6,75.38 77.51,75.29 77.51,74.74 77.89,74.37 v2(77.89,74.3)
  BOTTOM w0.089: v2(77.89,74.3) 77.65,74.54 UH1.AW24
CLK_BUF_DMI#: length 7.6
  TOP w0.102: v2(77.9,74.91) 77.89,74.91 77.79,75.01 77.79,75.18 77.89,75.28 77.94,75.28 78.04,75.38 78.04,75.51 77.87,75.68 77.87,76.4 77.97,76.5 77.97,76.81 77.87,76.91 77.87,77.22 77.97,77.32 77.97,77.62 77.87,77.73 77.87,78.07 77.62,78.32 v3(77.62,79.34) 77.62,79.56 77.22,79.97 77.22,80.24 77.3,80.32 77.45,80.32 77.52,80.4 77.52,80.52 77.45,80.6 RPH3.2
  BOTTOM w0.089: UH1.AY24 77.66,74.91 v2(77.9,74.91)
CLK_BUF_DOT96: length 3.9
  TOP w0.102: RH151.1 82.38,58.61 82.21,58.61 82.03,58.79 82.03,59.23 81.48,59.78 81.48,60.64 81.62,60.78 81.74,60.78 81.86,60.66 v2(81.86,60.56)
  BOTTOM w0.089: UH1.G33 81.44,60.97 v2(81.86,60.56)
CLK_BUF_DOT96#: length 4
  TOP w0.102: RH150.1 81.76,58.88 81.76,59.12 81.21,59.67 81.21,60.75 81.51,61.04 81.74,61.04 v2(81.87,61.18)
  BOTTOM w0.089: UH1.H33 81.71,61.21 81.86,61.21 81.89,61.18 81.87,61.16 81.86,61.18 81.86,61.18 v2(81.87,61.18)
CLK_CPU_DMI: length 107.3
  IN3 w0.089: v2(84.22,69.56) 84.15,69.48 84.05,69.48 83.99,69.54 83.99,69.71 83.95,69.76 83.95,69.86 84.05,69.96 85.28,69.96 85.34,69.9 85.35,69.9
  IN3 w0.127: 85.35,69.9 86.54,69.9 87.68,71.04 87.84,71.04 88.14,71.34 88.14,71.5 88.41,71.77 88.57,71.77 88.87,72.07 88.87,72.23 89.25,72.62 89.25,73.57 91.72,76.04 92.73,76.04 93.98,77.28 96.01,77.28 97.23,78.5 102.13,78.5 104.77,81.14 112.8,81.14 117.75,86.09 121.46,86.09 130.66,95.29 130.66,101.79 133.37,104.51 133.37,106.34 136.3,109.26 137.41,109.26 137.58,109.09 137.58,108.69 v2(137.56,108.67)
  BOTTOM w0.089: UH1.AF40 84.22,69.32 v2(84.22,69.56)
  BOTTOM w0.102: RC13.2 155.85,125.29 155.4,125.29 154.7,124.59 154.7,117.45 150.06,112.81 v3(146.89,112.81) 144.27,112.81 139.94,108.48 137.95,108.48 137.76,108.67 v2(137.56,108.67)
CLK_CPU_DMI#: length 107.3
  IN3 w0.089: 85.35,70.21 85.34,70.21 85.28,70.14 83.97,70.14 83.77,69.94 83.77,69.71 v2(83.62,69.56)
  IN3 w0.127: v2(138,109.11) 137.84,109.26 137.54,109.57 136.17,109.57 133.07,106.46 133.07,104.64 130.35,101.92 130.35,95.42 121.33,86.4 117.63,86.4 112.67,81.45 104.65,81.45 102.01,78.8 97.1,78.8 95.88,77.58 93.85,77.58 92.61,76.34 91.59,76.34 88.95,73.7 88.95,72.74 86.41,70.21 85.35,70.21
  BOTTOM w0.089: v2(83.62,69.56) 83.62,69.33 UH1.AF39
  BOTTOM w0.102: RC15.2 156.11,125.73 155.93,125.55 155.29,125.55 154.43,124.7 154.43,117.56 149.95,113.08 144.16,113.08 139.83,108.75 138.06,108.75 137.9,108.92 137.9,109 v2(138,109.11)
CLK_CPU_DPLL: length 114.1
  IN3 w0.089: 85,69.12 84.99,69.12 84.92,69.05 84.7,69.05 84.63,69.13 82.29,69.13 82.12,69.3 82.12,69.38 82.14,69.4 82.14,69.47 82.14,69.48 82.22,69.56 v2(82.37,69.56)
  IN3 w0.127: v2(137.12,108.13) 136.97,108.13 136.77,108.33 136.21,108.33 135.86,107.99 135.86,106.24 131.16,101.54 131.16,95.03 121.72,85.59 117.98,85.59 113,80.61 105.21,80.61 101.09,76.49 98.8,76.49 98.07,77.23 96.82,77.23 95.96,76.37 93.8,76.37 92.53,75.09 92.53,73.52 89.25,70.24 87.68,70.24 86.55,69.12 85,69.12
  BOTTOM w0.089: v2(82.37,69.56) 82.71,69.22 UH1.AF36
  BOTTOM w0.102: v2(137.12,108.13) 137.12,108 137.06,107.94 136.96,107.94 136.75,108.14 136.75,109.13 142.2,114.58 149.03,114.58 152.94,118.5 152.94,127.64 155.2,129.89 155.86,129.89 155.98,129.77 155.98,129.6 RC52.2
CLK_CPU_DPLL#: length 114.1
  IN3 w0.089: v2(81.76,69.56) 81.94,69.38 81.94,69.23 82.22,68.95 84.56,68.95 84.63,68.87 84.92,68.87 84.99,68.81 85,68.81
  IN3 w0.127: 85,68.81 86.68,68.81 87.81,69.94 89.38,69.94 92.84,73.39 92.84,74.97 93.93,76.06 96.09,76.06 96.95,76.92 97.94,76.92 98.68,76.19 101.22,76.19 105.33,80.3 113.13,80.3 118.11,85.28 121.84,85.28 131.47,94.91 131.47,101.41 136.17,106.11 136.17,107.86 136.33,108.03 136.64,108.03 136.75,107.91 136.75,107.76 v2(136.65,107.65)
  BOTTOM w0.089: UH1.AF35 82.12,69.2 v2(81.76,69.56)
  BOTTOM w0.102: RC51.2 155.64,130.16 155.09,130.16 152.68,127.75 152.68,118.61 148.92,114.85 142.09,114.85 136.48,109.24 136.48,108.03 136.65,107.87 v2(136.65,107.65)
CLK_CPU_ITP: length 213.9
  TOP w0.102: v2(205.76,121.78) 205.26,122.29 RH107.2
  IN3 w0.127: v2(205.46,58.79) 205.31,58.94 204.8,58.94 204.06,59.68 204.06,62.93 206.6,65.47 206.6,69.02 209.93,72.35 209.93,74.16 212.98,77.2 212.98,79.36 213.92,80.3 213.92,87.17 211.81,89.28 211.81,92.54 214.96,95.69 214.96,101.05 211.33,104.69 211.33,105.96 210.95,106.34 210.95,116.65 208.96,118.63 208.96,121.5 208.3,122.16 206.15,122.16 v2(205.76,121.78)
  IN4 w0.117: v2(99.34,81.57) 99.4,81.51 99.4,79.76 101.14,78.03 101.14,77.21 114.37,63.98 114.37,63.88 117.48,60.77 120.07,60.77 122.51,58.33 200.52,58.33 200.95,57.89 203.27,57.89 204.37,58.99 205.25,58.99 v2(205.46,58.79)
  BOTTOM w0.102: RH156.2 91.04,70.23 91.15,70.12 91.61,70.12 91.69,70.2 92.02,70.2 92.12,70.3 92.42,70.3 92.53,70.2 96.91,70.2 99.16,72.45 99.16,79.26 99.62,79.72 99.62,81.29 v2(99.34,81.57)
CLK_CPU_ITP#: length 213.7
  TOP w0.102: v2(212.06,123.69) 212.06,123.97 RH108.1
  IN3 w0.127: v2(212.06,123.69) 210.89,123.69 209.27,122.06 209.27,118.76 211.25,116.78 211.25,106.46 211.63,106.08 211.63,104.81 215.26,101.18 215.26,95.57 212.11,92.42 212.11,89.41 214.22,87.3 214.22,80.18 213.28,79.24 213.28,77.08 210.23,74.03 210.23,72.23 206.91,68.9 206.91,65.34 204.37,62.8 204.37,59.8 204.93,59.25 205.31,59.25 v2(205.48,59.42)
  IN4 w0.117: v2(205.48,59.42) 205.34,59.28 204.25,59.28 203.15,58.18 201.07,58.18 200.63,58.61 122.63,58.61 120.19,61.05 117.6,61.05 114.65,64 114.65,64.1 101.42,77.33 101.42,78.14 99.69,79.88 99.69,81.34 99.75,81.4 99.75,81.49 99.84,81.57 v2(99.92,81.57)
  BOTTOM w0.102: RH154.2 91.24,69.86 91.72,69.86 91.8,69.93 97.02,69.93 99.43,72.34 99.43,79.15 99.89,79.61 99.89,81.54 v2(99.92,81.57)
CLK_CPU_SSC_DPLL: length 108.1
  IN3 w0.089: v2(83.65,70.52) 83.65,70.56 84.18,71.08 84.66,71.08 84.73,71.01 85.17,71.01 85.23,71.07 85.24,71.07
  IN3 w0.127: 85.24,71.07 85.59,71.07 88.06,73.54 88.06,74.02 91.19,77.15 91.64,77.15 92.94,78.45 95.5,78.45 98.02,80.96 102.97,80.96 104.27,82.26 112.32,82.26 117.27,87.21 120.98,87.21 129.54,95.77 129.54,102.35 132.26,105.07 132.26,106.82 136.19,110.76 138.96,110.76 139.22,110.5 v2(139.37,110.5)
  BOTTOM w0.089: UH1.AJ39 83.91,70.27 v2(83.65,70.52)
  BOTTOM w0.102: RC22.2 155.66,127.76 155.06,127.76 153.55,126.26 153.55,117.99 149.53,113.97 143.8,113.97 139.79,109.96 139.38,109.96 139.22,110.12 139.22,110.35 v2(139.37,110.5)
CLK_CPU_SSC_DPLL#: length 108.2
  IN3 w0.089: v2(84.24,70.52) 84.12,70.52 84.07,70.57 84.07,70.73 84.25,70.9 84.58,70.9 84.66,70.83 85.17,70.83 85.23,70.77 85.24,70.77
  IN3 w0.127: 85.24,70.77 85.71,70.77 88.36,73.41 88.36,73.9 91.31,76.85 91.77,76.85 93.06,78.14 95.63,78.14 98.14,80.66 103.1,80.66 104.39,81.95 112.44,81.95 117.4,86.91 121.11,86.91 129.84,95.64 129.84,102.22 132.56,104.94 132.56,106.69 136.32,110.45 136.8,110.45 136.93,110.32 137.31,110.32 137.44,110.45 137.82,110.45 137.95,110.32 138.33,110.32 138.46,110.45 138.84,110.45 139,110.29 139,110.06 138.91,109.97 v2(138.83,109.97)
  BOTTOM w0.089: v2(84.24,70.52) 84.19,70.48 84.19,70.33 84.5,70.02 UH1.AJ40
  BOTTOM w0.102: v2(138.83,109.97) 138.99,109.97 139.27,109.69 139.9,109.69 143.91,113.7 149.64,113.7 153.82,117.88 153.82,126.15 155.17,127.5 155.68,127.5 RC43.2
CLK_DDC2_CRT: length 97.2
  TOP w0.102: JCRT1.15 91.67,171.24 v1(91.67,168.97) R48.2 92.35,166.98 92.35,166.69 92.76,166.28 92.76,165.35 v2(92.76,165.27)
  IN4 w0.109: v2(92.76,165.27) 92.77,165.26 93.32,165.26 94.19,164.38 95.59,164.38 95.82,164.15 97.51,164.15 98.06,163.6 100.85,163.6 102.44,162.01 105.53,162.01 109.56,157.98 110.69,157.98 113.04,155.63 113.04,153.18 115.09,151.13 115.09,140.73 113.5,139.14 113.5,136.64 109.71,132.85 109.71,130.57 111,129.28 111,123.38 110.44,122.82 110.44,117.07 107.62,114.24 107.62,112.58 107.02,111.98 107.02,106.65 105.38,105.02 104.82,105.02 v2(104.57,105.27)
  BOTTOM w0.102: v2(104.57,105.27) 100.1,105.27 99.64,105.74 U19.35
CLK_DDC2_DOCK: length 21.5
  IN3 w0.127: v2(95.12,125.01) 96.19,123.94 96.19,122.91 96.77,122.33 96.77,119.51 97.03,119.25 97.03,114.78 96.21,113.97 96.21,109.84 96.34,109.72 96.34,109.28 95.99,108.93 v2(95.91,108.93)
  BOTTOM w0.102: U19.26 v2(95.91,108.93) ; JDOCK1.48 93.24,125.87 93.57,125.54 94.59,125.54 v2(95.12,125.01)
CLK_KBD: length 225.4
  TOP w0.102: v2(219.91,68.82) 219.91,68.77 221.03,67.65 228.52,67.65 228.9,67.27 233.3,67.27 233.68,67.65 235.33,67.65 236.12,68.44 236.51,68.44 236.95,68.87 240.57,68.87 240.84,68.59 242.46,68.59 243.25,67.8 243.25,66.56 243.96,65.85 245.24,65.85 248.11,62.99 248.11,59.45 249.15,58.41 249.15,57.58 249.71,57.02 249.71,55.51 249.97,55.25 249.97,53.05 249.38,52.46 249.38,51.05 250.37,50.06 250.37,48.27 250.44,48.2 v2(250.44,48.17)
  BOTTOM w0.102: U51.A38 249.41,47.42 250.16,48.17 v2(250.44,48.17) 250.85,48.58 RP6.6 ; v2(219.91,68.82) 220,68.91 v1(220,69.44) 220,69.75 214.12,75.64 214.12,79.52 212.6,81.05 212.6,84.36 207.74,89.22 202.67,89.22 196.95,94.93 191.31,94.93 188.74,97.5 161.78,97.5 157.89,101.4 157.89,105.98 152.97,110.9 145.71,110.9 140.24,105.42 136.45,105.42 132.82,109.06 132.82,117.01 131.8,118.03 131.8,126.82 130.01,128.61 130.01,129.85 126.46,133.39 120.86,133.39 119,131.53 115.82,131.53 113.99,133.36 106.58,133.36 101.74,128.53 JDOCK1.78
CLK_MSE: length 216.7
  IN1 w0.109: v2(249.22,46.79) 248.84,46.4 246.06,46.4 243.52,48.94 243.52,50.35 243,50.86 238.99,50.86 237.78,49.65 236.56,49.65 236.31,49.4 234.48,49.4 234.31,49.56 218.38,49.56 215.97,47.16 213.23,47.16 v2(212.98,46.9)
  BOTTOM w0.102: v2(212.98,46.9) 211.96,47.92 v1(211.96,61.53) 211.96,63.59 214.2,65.82 214.92,65.82 217.24,68.15 217.24,71.1 216.5,71.84 215.53,71.84 211.7,75.68 210.76,75.68 207.53,78.91 206.98,78.91 206.37,79.52 198.6,79.52 192.58,85.54 189.62,85.54 186.57,88.58 167.74,88.58 165.86,90.47 153.77,90.47 152.81,89.5 149.3,89.5 147.34,91.45 135.55,91.45 126.51,100.5 124.87,100.5 123.96,101.41 118.97,101.41 116.89,103.49 116.89,106.45 116.89,107.3 113.21,110.98 111.75,110.98 110.74,111.99 100.82,111.99 99.81,112.99 99.21,112.99 98.68,113.53 98.68,114.92 99.39,115.63 99.42,115.63 99.67,115.89 99.67,115.91 100.24,116.49 JDOCK1.71 ; U51.A39 249.1,46.92 v2(249.22,46.79) 249.84,47.41 250.29,47.41 250.96,48.08 RP6.5
CLK_PCH_14M: length 4.7
  BOTTOM w0.102: RH146.1 89.93,58.95 v1(89.38,58.95) 89.19,58.95 87.32,60.83 UH1.F45
CLK_PCI_5048: length 167.1
  TOP w0.102: v2(89.61,56.45) 90.27,57.11 v1(90.27,58.14) 90.27,58.56 89.84,58.99 88.75,58.99 CH15.1 87.3,59.75 RH158.2
  IN1 w0.109: v2(89.61,56.45) 89.97,56.81 93.55,56.81 93.87,57.12 95.84,57.12 96.15,56.81 101.72,56.81 103.09,55.44 114.02,55.44 116.18,53.28 117.58,53.28 118.46,52.39 118.46,51.1 119.86,49.7 122.1,49.7 122.73,49.07 154.31,49.07 154.84,49.59 158.75,49.59 159.28,49.07 191.39,49.07 196.62,54.3 197.4,54.3 199.45,56.35 210.47,56.35 212.95,58.83 226.29,58.83 226.76,59.3 229.13,59.3 229.41,59.02 236.11,59.02 v2(236.22,59.13)
  BOTTOM w0.102: U46.A28 236.48,62.63 236.31,62.46 236.31,61.87 R795.1 236.22,60.88 v2(236.22,59.13)
