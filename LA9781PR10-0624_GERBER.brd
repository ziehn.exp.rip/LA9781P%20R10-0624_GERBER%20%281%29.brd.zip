# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDSE_CON_P2: length 7.1
  TOP w0.102: JHDMI1.1 28.35,168.23 28.35,167.81 28.22,167.68 26.49,167.68 25.98,167.17 25.96,167.17 25.56,166.77 25.56,166.75 25.39,166.58 25.39,166.12 C1340.1 25.33,165.54 L25.3 25.33,164.31 R459.2
TMDSE_RP_CLK: length 10.1
  TOP w0.102: U9.16 31,158.25 31.09,158.34 31.09,158.54 31.35,158.8 v3(32.66,158.8) 35.17,158.8 36.06,159.7 36.06,161.32 36.05,161.33 36.05,161.86 36.06,161.87 36.06,162.12 35.74,162.44 L19.4 35.74,163.23 R451.1
TMDSE_RP_CLK#: length 10.1
  TOP w0.102: R452.1 36.59,163.23 L19.1 36.59,162.44 36.28,162.12 v3(36.28,161.6) 36.28,159.61 35.25,158.59 32.94,158.59 32.93,158.57 32.4,158.57 32.38,158.59 31.44,158.59 31.31,158.45 31.31,158.33 31.4,158.24 U9.15
TMDSE_RP_N0: length 6.9
  TOP w0.102: U9.18 30.2,158.39 30.11,158.48 30.11,159.31 v3(30.62,159.82) 31.58,160.78 31.6,160.78 31.98,161.16 31.98,161.18 32.72,161.92 32.72,162.12 33.04,162.44 L23.1 33.04,163.23 R454.1
TMDSE_RP_N1: length 5.9
  TOP w0.102: R456.1 29.48,163.23 L24.1 29.48,162.44 29.16,162.12 29.16,161.99 29.18,161.98 29.18,161.44 29.16,161.43 29.16,161 28.91,160.75 v3(28.91,160.41) 28.91,158.48 29,158.39 U9.21
TMDSE_RP_N2: length 6.6
  TOP w0.102: R458.1 26.18,163.23 L25.1 26.18,162.57 25.86,162.25 25.86,162.06 25.93,161.99 26.03,161.99 26.9,161.13 26.9,159.91 27.71,159.09 27.71,158.48 27.8,158.39 U9.24
TMDSE_RP_P0: length 6.9
  TOP w0.102: R453.1 32.19,163.23 L23.4 32.19,162.44 32.5,162.12 32.5,162.01 v3(31.63,161.13) 30.67,160.17 30.65,160.17 30.27,159.79 30.27,159.78 29.89,159.4 29.89,158.48 29.8,158.39 U9.19
TMDSE_RP_P1: length 5.9
  TOP w0.102: R455.1 28.63,163.23 L24.4 28.63,162.44 28.95,162.12 v3(28.95,161.71) 28.95,161.09 28.69,160.84 28.69,160.69 28.68,160.68 28.68,160.15 28.69,160.14 28.69,158.48 28.6,158.39 U9.22
TMDSE_RP_P2: length 6.6
  TOP w0.102: R459.1 25.33,163.23 L25.4 25.33,162.54 25.65,162.22 25.65,161.97 25.84,161.77 25.94,161.77 26.68,161.04 26.68,159.82 27.49,159 27.49,158.48 27.4,158.39 U9.25
TOUCH_SCREEN_PD#: length 307.4
  TOP w0.102: JCAM1.7 11.61,124.02 12.06,124.02 12.52,124.47 12.8,124.47 R426.2 v1(12.19,124.78) 12.04,124.78 v2(11.76,124.5)
  IN3 w0.127: v2(236.17,72.75) 236,72.75 235.74,73.01 235.74,73.6 235.56,73.77 234.11,73.77 232.48,72.15 230.68,72.15 228.52,69.99 227.7,69.99 226.28,68.57 224.46,68.57 207.63,51.74 205.51,51.74 204.82,51.06 204.82,48.58 203.55,47.31 197.47,47.31 192.01,41.85 188.29,41.85 187.78,41.34 178.14,41.34 177.42,40.63 172.06,40.63 170.37,38.94 168,38.94 166.56,37.5 147.77,37.5 144.77,40.5 122.89,40.5 121.34,42.05 102.15,42.05 99.7,44.5 80.11,44.5 79.68,44.07 76.2,44.07 75.77,44.5 72.64,44.5 71.98,45.16 70.16,45.16 69.73,45.59 67.83,45.59 66.11,47.32 64.02,47.32 63.59,47.75 59.5,47.75 57.75,49.5 54.58,49.5 45.79,58.29 45.79,60.63 43.78,62.65 43.78,64.13 43.14,64.76 43.14,70.37 42.2,71.31 40.57,71.31 37.84,74.04 37.84,77.62 34.98,80.48 33.16,80.48 28.88,84.76 28.88,88.25 29.16,88.53 29.97,88.53 31.88,90.44 31.88,96.65 29.99,98.54 29.99,101.42 17.18,114.24 17.18,116.96 11.76,122.38 v2(11.76,124.5)
  BOTTOM w0.102: v2(236.17,72.75) 235.72,73.19 235.72,73.59 235.73,73.59 U46.B55
TP_LAN_JTAG_TCK: length 2.7
  TOP w0.102: R546.2 107.52,89.6 108,90.09 U31.35
TP_LAN_JTAG_TDI: length 1.6
  TOP w0.102: U31.32 107.32,91.29 T142.1
TP_LAN_JTAG_TDO: length 1.6
  TOP w0.102: T143.1 107.92,90.49 U31.34
TP_LAN_JTAG_TMS: length 2.7
  TOP w0.102: U31.33 108.03,90.89 107.64,90.49 R545.2
TP_VSS_NCTF: length 8.7
  BOTTOM w0.089: UH1.BE5 69.52,77.22 69.32,77.43 68.57,77.43 68.26,77.74 68.05,77.74
  BOTTOM w0.102: 68.05,77.74 68.02,77.74 67.11,78.65 65.58,78.65 64.68,79.55 v1(63.63,79.55) 63.18,79.55 RH219.2
TPM_ID0: length 10.7
  TOP w0.076: 68.34,74.98 68.41,74.91 v1(68.9,74.91) 69.1,74.91 69.71,74.3 69.71,74.19 70.21,73.7 v2(70.21,73.44)
  TOP w0.102: RPH10.8 65.9,79.81 67.08,78.63 67.08,77.16 67.68,76.56 67.68,75.64 68.34,74.98
  BOTTOM w0.102: UH1.AT7 70.34,73.31 v2(70.21,73.44)
TPM_ID1: length 7.5
  BOTTOM w0.076: 65.84,71.9 66.06,71.9 66.67,71.29 67.49,71.29 67.64,71.13 67.99,71.13 68.15,71.29 68.59,71.29 UH1.AM3
  BOTTOM w0.102: RH200.2 63.09,73.47 v1(63.75,72.82) 64.67,71.9 65.84,71.9
TRIP_+1.05VSP: length 3.3
  TOP w0.102: PR302.2 38.58,67.6 v2(38.28,67.91) v1(37.49,67.91)
  BOTTOM w0.102: PU300.2 38.6,67.23 38.23,67.6 38.23,67.86 v2(38.28,67.91)
UG_3V: length 9.3
  TOP w0.102: v3(37.51,40.5) v1(38.2,40.5)
  IN1 w1.016: 34.52,48.83 34.64,48.71 34.64,46.67 37.18,44.13 37.18,41.34
  vias: v3(32.66,48.96) v3(33.3,48.96) v3(37.26,39.89)
UG_5V: length 11.2
  TOP w0.102: v3(37.24,36.21) v1(36.55,36.21)
  IN4 w1.016: 34.09,26.35 36.27,28.54 36.27,35.95
  vias: v2(33.42,25.36) v2(34.01,25.36) v3(37.21,35.57)
UG_+1.05VSP:
  vias: v1(38.26,62.62) v3(36.35,60.33) v3(36.68,60.87)
UGATE1: length 18.8
  IN1 w1.016: 174.6,166.69 174.24,167.04 169.62,167.04 169.39,166.82
  IN2 w1.016: 168.32,163.72 168.32,163.77 168.07,164.02 155.42,164.02 155.19,164.25
  vias: v3(155.2,165.8) v3(155.19,165.16) v3(169.11,164.97) v3(175.22,165.61) v3(175.22,164.97) v5(169.11,165.62)
UGATE2: length 29
  IN2 w1.016: 160.63,167.83 161.39,167.07 181.58,167.07 182.22,166.43
  IN4 w1.016: 181.96,166.43 182.62,167.09 186.89,167.09 187.43,166.56
  BOTTOM w0.102: v3(159.54,167.22) v1(160.4,167.22)
  vias: v3(158.98,167.83) v3(181.57,165.61) v3(181.57,164.97) v3(187.67,165.61) v3(187.67,164.97)
UGATE3: length 9.7
  TOP w0.762: PQ501.2 201.4,163.96 201.4,166.05 200.82,166.62 199,166.62 v1(197.98,165.61) 197.23,164.86 196.42,164.86 195.66,164.1 PQ500.2
UIM_CLK: length 49.2
  TOP w0.102: v2(262.96,60.97) 262.96,60.95 269.72,54.19 269.72,43.34 270.48,42.58 270.48,37.78 269.24,36.54 269.24,25.46 269.75,24.96 269.75,24.4 v2(269.31,23.97)
  BOTTOM w0.102: JMINI1.12 262.59,60.6 v2(262.96,60.97) ; v2(269.31,23.97) 268.32,22.97 v1(267.94,22.97) 267.71,22.97 267.33,22.59 267.33,21.48 C628.1 266.24,20.38 JSIM1.3
UIM_DATA: length 49.6
  TOP w0.102: v2(269.34,23.13) 270.43,24.22 270.43,25.24 269.92,25.74 269.92,33.49 270.43,34 270.43,36.36 270.97,36.89 270.97,42.78 270.22,43.52 270.22,54.4 263.73,60.9 v2(263.73,60.97)
  BOTTOM w0.102: v2(263.73,60.97) 263.73,61.1 263.31,61.51 262.56,61.51 262.44,61.4 JMINI1.10 ; JSIM1.7 266.94,19.55 C631.1 v1(269.34,21.96) v2(269.34,23.13)
UIM_RESET: length 49.8
  TOP w0.102: v2(269.34,24.68) 268.73,25.29 268.73,36.92 267.84,37.81 267.84,42.53 268.58,43.27 268.58,54.65 263.35,59.88 v2(262.96,59.88)
  BOTTOM w0.102: JSIM1.2 264.84,20.11 C629.1 264.74,21.17 264.74,22.57 v1(264.87,22.7) 265.45,23.28 266.85,23.28 268.45,24.88 269.14,24.88 v2(269.34,24.68) ; v2(262.96,59.88) 262.88,59.8 JMINI1.14
USB1_A_DE0: length 6.7
  BOTTOM w0.102: R23.2 R104.2 273.12,69.1 273.12,70.35 272.8,70.67 v1(272.23,70.67) 272.1,70.8 271.55,70.8 270.61,71.74 U625.16
USB1_A_DE1: length 5.6
  BOTTOM w0.102: U625.18 v1(269.61,71.08) 269.61,70.58 R809.2 R25.2
USB1_A_EQ0: length 6.2
  BOTTOM w0.102: U625.17 270.11,71.69 v1(270.9,70.9) 271.21,70.6 271.75,70.6 272.16,70.19 272.16,69.05 R106.2 R24.2
USB1_A_EQ1: length 7.3
  BOTTOM w0.102: U625.15 271.11,71.62 271.68,71.06 273.37,71.06 v1(273.54,70.9) 273.77,70.66 273.77,70.66 274.17,70.27 274.17,69.08 R108.2 R22.2
USB1_B_DE0: length 5.5
  BOTTOM w0.102: R103.2 R16.2 269.64,79.79 269.64,77.59 270.06,77.18 270.43,77.18 270.61,77 U625.3
USB1_B_DE1: length 5.4
  BOTTOM w0.102: U625.6 272.11,77.16 272.69,77.74 272.69,78.93 R773.2 R21.2 273.77,80.25 v1(274.17,79.86)
USB1_B_EQ0: length 6.9
  BOTTOM w0.102: R18.2 268.38,80.25 v1(268.15,80.48) ; R18.2 268.6,79.77 268.6,77.64 268.88,77.36 269.59,77.36 270.11,76.84 U625.2 ; R18.2 R105.2
USB1_B_EQ1: length 4.2
  BOTTOM w0.102: R15.2 R107.2 270.61,78.88 270.61,77.64 271.11,77.13 U625.4
USB1_TEST: length 7.7
  BOTTOM w0.102: R12.2 v1(275.69,69.04) 275.69,69.3 275.16,69.84 275.16,70.3 274.88,70.57 274.39,70.57 273.71,71.26 272.16,71.26 271.61,71.81 U625.14
USB3_RX1_N_D-: length 16.6
  BOTTOM w0.102: JUSB1.5 291.02,123.1 289.7,123.1 288.29,121.7 288.29,117.14 288.28,117.13 288.28,116.6 288.29,116.59 v3(288.29,114.55) 288.29,113.63 288.15,113.49 D14.6 288.15,112.95 288.3,112.8 288.3,112.63 288.15,112.48 D14.5 288.15,111.94 288.26,111.82 288.26,111.75 288.03,111.51 288.03,111.13 287.71,110.81 L40.4 287.71,110.08 R746.2
USB3_RX1_P_D+: length 16.5
  BOTTOM w0.102: JUSB1.6 291.76,122.2 291.07,122.89 289.79,122.89 288.51,121.61 v3(288.51,116.87) 288.51,114.83 288.52,114.82 288.52,114.29 288.51,114.28 288.51,113.63 288.65,113.49 D14.7 288.65,112.9 288.52,112.76 288.52,112.66 288.65,112.53 D14.4 288.65,112.02 288.48,111.85 288.48,111.66 288.24,111.42 288.24,111.13 288.56,110.82 L40.1 288.56,110.08 R745.2
USB3_RX2_N_D-: length 8.1
  TOP w0.102: JUSB2.5 290.91,99.9 290.36,99.9 290.12,100.14 288.97,100.14 288.82,100.3 D16.5 D16.6 287.25,100.3 287.11,100.16 v3(286.56,100.16) 286.35,100.16 285.96,99.77 285.82,99.77 285.5,100.08 L43.1 284.72,100.08 R752.2
USB3_RX2_P_D+: length 8.1
  TOP w0.102: JUSB2.6 290.83,99.68 290.27,99.68 290.03,99.92 288.97,99.92 288.85,99.8 D16.4 D16.7 287.25,99.8 287.11,99.94 286.86,99.94 286.84,99.93 286.43,99.93 286.05,99.55 285.82,99.55 285.5,99.23 L43.4 284.67,99.23 R753.2
USB3_TX1_N_D-: length 9.4
  BOTTOM w0.102: JUSB1.8 291,117.08 290.6,117.08 v3(290.34,116.82) 289.79,116.27 289.79,114.82 289.77,114.81 289.77,114.28 289.79,114.26 289.79,113.61 289.65,113.48 D14.8 289.65,112.95 289.79,112.81 289.79,112.69 289.65,112.55 D14.2 289.65,111.96 289.79,111.82 289.79,111.63 290.06,111.36 290.06,111.18 289.74,110.87 L42.4 289.74,110.08 R743.2
USB3_TX1_P_D+: length 9.4
  BOTTOM w0.102: R744.2 290.59,110.08 L42.1 290.59,110.87 290.28,111.18 290.28,111.45 290,111.72 290,111.85 290.15,112 D14.1 290.15,112.55 290,112.7 290,112.81 290.15,112.96 D14.9 290.15,113.42 290,113.56 v3(290,114.54) 290,116.16 290.71,116.87 291.1,116.87 291.76,116.2 JUSB1.9
USB3_TX2_N_D-: length 12.8
  TOP w0.102: R750.2 284.73,97.75 L44.1 285.52,97.75 285.83,97.43 286.06,97.43 286.4,97.77 286.4,98.3 v3(286.57,98.48) 286.75,98.65 287.09,98.65 287.24,98.8 D16.8 D16.2 288.93,98.8 289.07,98.66 289.39,98.66 290.12,97.93 290.12,94.17 290.43,93.85 290.87,93.85 290.96,93.94 290.96,93.95 JUSB2.8
USB3_TX2_P_D+: length 12.8
  TOP w0.102: JUSB2.9 291.76,92.76 290.88,93.64 290.35,93.64 289.9,94.08 289.9,97.84 289.3,98.44 289.07,98.44 288.93,98.3 D16.1 D16.9 287.24,98.3 287.1,98.44 286.86,98.44 286.61,98.19 286.61,97.68 286.15,97.21 285.83,97.21 285.52,96.9 L44.4 284.68,96.9 R751.2
USB3RN1: length 220.6
  IN3 w0.089: 78.32,75.64 78.32,75.62 78.28,75.58 78.28,75.35 78.48,75.15 78.48,72.88 78.57,72.8 78.7,72.8 78.91,73.01 v2(78.91,73.01)
  IN3 w0.127: v2(93.6,85.94) 93.41,86.12 93.19,86.12 92.92,86.4 92.92,86.93 92.69,87.16 91.03,87.16 89.81,85.94 86.26,85.94 82.32,82.01 81.2,82.01 80.26,81.06 80.26,77.1 79.68,76.52 79.03,76.52 78.32,75.8 78.32,75.64
  IN4 w0.117: v2(263.88,73.3) 264.1,73.09 264.31,73.09 264.57,72.84 264.57,72.17 260.44,68.05 253.79,68.05 249.51,63.77 248.87,63.77 248.42,63.32 248.42,63.27 247.03,61.88 246.5,61.88 245.18,60.56 234.13,60.56 233.42,59.85 208.31,59.85 205.64,62.51 200.64,62.51 199.29,63.86 197.52,63.86 188.96,72.42 154.84,72.42 147.47,79.79 129.46,79.79 129.01,80.24 106.1,80.24 102.18,84.16 98.45,84.16 97.98,83.7 95.38,83.7 94.03,85.05 94.03,86.01 93.93,86.11 93.77,86.11 v2(93.6,85.94)
  BOTTOM w0.089: v2(78.91,73.01) 78.65,72.75 UH1.AR26
  BOTTOM w0.102: v2(263.88,73.3) 264.06,73.13 264.2,73.13 264.3,73.23 264.3,74.35 264.99,75.04 265.63,75.04 C487.1
USB3RN1_C: length 2.2
  BOTTOM w0.102: U625.23 268.35,75.24 268.21,75.1 267.82,75.1 267.76,75.04 267.21,75.04 C487.2
USB3RN1_RP: length 41.5
  IN3 w0.127: v2(276.35,75.45) 276.35,75.29 276.46,75.18 276.67,75.18 276.97,75.48 276.97,89.84 281.17,94.05 281.17,97.72 284.54,101.09 284.54,104.17 v2(284.36,104.34)
  BOTTOM w0.102: v2(276.35,75.45) 276.35,75.43 276.08,75.17 275.98,75.17 R830.1 ; v2(284.36,104.34) 284.53,104.51 284.53,105.12 285.27,105.86 285.27,106.39 285.28,106.4 285.28,106.94 286.18,107.84 287.98,107.84 288.03,107.88 288.03,108.05 287.71,108.36 L40.3 287.71,109 R746.1
USB3RN1_RP_R: length 2.1
  BOTTOM w0.102: R830.2 274.39,75.17 273.97,75.17 273.9,75.09 273.5,75.09 273.36,75.24 U625.8
USB3RN2: length 246.8
  TOP w0.102: R752.1 283.59,100.08 L43.2 282.85,100.08 282.53,99.77 282.34,99.77 v2(282.17,99.94)
  IN3 w0.089: 80.61,76.76 80.59,76.74 80.59,76.69 80.19,76.29 79.83,76.29 79.45,75.91 79.45,75.4 79.32,75.27 79.32,74.89 79.17,74.74 79.06,74.74 78.91,74.89 v2(78.91,74.92)
  IN3 w0.127: 80.61,76.76 80.92,77.07 80.92,80.78 81.51,81.37 82.7,81.37 86.28,84.95 97.51,84.95 98.66,86.09 105.99,86.09 v2(106.2,86.3)
  IN4 w0.117: v2(282.17,99.94) 282.01,99.78 281.73,99.78 281.37,99.43 281.37,98.46 276.33,93.41 276.33,91.38 276.05,91.1 276.05,87.97 267.64,79.57 266.67,79.57 261.4,74.29 249.71,74.29 246.9,71.49 246.9,66.6 246,65.7 246,64.25 244.98,63.23 242.57,63.23 241.95,63.85 234.88,63.85 234.47,63.44 232.08,63.44 231.78,63.13 229.48,63.13 228.42,62.07 210.79,62.07 207.51,65.35 204.03,65.35 201.74,67.64 200.06,67.64 198.76,68.95 197.97,68.95 192.25,74.66 160.98,74.66 156.01,79.64 153.29,79.64 150.85,82.08 149.99,82.08 149.28,82.79 116.18,82.79 113.6,85.37 107.5,85.37 106.77,86.1 106.39,86.1 v2(106.2,86.3)
  BOTTOM w0.076: UH1.AW26 78.43,74.54 78.81,74.92 v2(78.91,74.92)
USB3RN3: length 75.4
  IN4 w0.117: v2(80.87,74.28) 80.99,74.4 81.21,74.4 81.59,74.02 82.08,74.02 82.48,74.42 82.48,77.87 83.21,78.6 83.21,83.17 85.83,85.79 85.83,104.86 83.5,107.2 83.5,111.32 88.42,116.24 88.42,119.19 89.01,119.78 89.01,122.34 88.59,122.75 88.38,122.75 v2(88.19,122.95)
  BOTTOM w0.076: v2(80.87,74.28) 80.62,74.54 UH1.AW31
  BOTTOM w0.102: v2(88.19,122.95) 88.09,122.85 88.09,122.7 88.24,122.54 88.75,122.54 88.94,122.35 92.37,122.35 93.28,121.44 97.67,121.44 98.8,122.57 100.3,122.57 100.81,123.08 100.81,123.36 102.96,125.5 103.29,125.5 103.36,125.58 103.36,125.71 103.24,125.83 JDOCK1.84
USB3RN5: length 87.6
  TOP w0.102: v2(18.06,98.67) 17.87,98.48 15.22,98.48 15,98.7 JIO1.15
  IN4 w0.089: 80.05,76.92 80.08,76.9 80.08,76.22 80.49,75.81 80.49,75.32 80.31,75.15 80.31,74.79 80.19,74.66 80.06,74.66 79.88,74.84 v2(79.88,74.95)
  IN4 w0.117: v2(18.06,98.67) 17.87,98.48 17.64,98.48 17.4,98.23 17.4,97.94 17.4,97.94 17.4,97.73 19.61,95.52 22.58,95.52 24.94,97.88 31.9,97.88 32.29,97.49 37.58,97.49 37.96,97.87 67.44,97.87 79.98,85.34 79.98,78.96 80.05,78.88 80.05,76.92
  BOTTOM w0.076: UH1.AW29 79.4,74.54 79.81,74.95 v2(79.88,74.95)
USB3RN6: length 89.5
  TOP w0.102: v2(27.93,93.61) 27.89,93.66 27.89,94.17 27.37,94.69 27.37,99.92 23.16,104.13 18.64,104.13 16.81,102.3 15.01,102.3 15.01,102.3 14.14,102.3 JIO1.3
  IN4 w0.089: 79.5,76.01 79.5,76 79.48,75.97 79.48,72.73 79.54,72.67 79.64,72.67 79.89,72.92 v2(79.89,72.98)
  IN4 w0.117: 79.5,76.01 79.5,76.56 77.6,78.47 77.6,79.74 77.04,80.3 77.04,81.47 63.85,94.65 55.17,94.65 54.76,95.07 43.16,95.07 42.67,94.59 38.76,94.59 38,93.82 31.54,93.82 31.44,93.92 31.04,93.92 30.95,93.82 30.6,93.82 30.5,93.92 30.1,93.92 30.01,93.82 29.52,93.82 28.85,93.16 27.99,93.16 27.79,93.35 27.79,93.47 v2(27.93,93.61)
  BOTTOM w0.076: v2(79.89,72.98) 79.87,72.98 79.63,72.75 UH1.AR29
USB3RP1: length 220.6
  IN3 w0.089: v2(78.91,72.42) 78.91,72.43 78.72,72.62 78.49,72.62 78.31,72.81 78.31,75.07 78.1,75.28 78.1,75.58 78.07,75.62 78.07,75.64
  IN3 w0.127: 78.07,75.64 78.07,75.91 78.93,76.77 79.58,76.77 80.01,77.21 80.01,81.17 81.1,82.25 82.22,82.25 86.15,86.19 89.71,86.19 90.93,87.41 92.79,87.41 93.17,87.03 93.17,86.5 93.29,86.37 93.39,86.37 v2(93.62,86.6)
  IN4 w0.117: v2(93.62,86.6) 93.88,86.35 94.03,86.35 94.27,86.11 94.27,85.15 95.48,83.93 97.89,83.93 98.35,84.4 102.28,84.4 106.2,80.48 129.11,80.48 129.56,80.03 147.57,80.03 154.94,72.66 189.05,72.66 197.61,64.1 199.39,64.1 200.73,62.75 205.74,62.75 208.41,60.08 233.32,60.08 234.03,60.8 245.08,60.8 246.4,62.12 246.93,62.12 248.18,63.36 248.18,63.42 248.77,64 249.41,64 253.69,68.28 260.34,68.28 264.33,72.27 264.33,72.74 264.21,72.85 264.05,72.85 v2(263.88,72.68)
  BOTTOM w0.089: v2(78.91,72.42) 78.82,72.33 78.59,72.33 UH1.AP26
  BOTTOM w0.102: C465.1 265.63,74.82 265.08,74.82 264.51,74.26 264.51,73.14 264.29,72.91 264.11,72.91 v2(263.88,72.68)
USB3RP1_C: length 2.2
  BOTTOM w0.102: U625.22 268.35,74.74 268.2,74.88 267.91,74.88 267.85,74.82 267.21,74.82 C465.2
USB3RP1_RP: length 41.7
  IN3 w0.127: v2(284.95,104.35) 284.79,104.19 284.79,100.99 281.42,97.62 281.42,93.94 277.21,89.74 277.21,75.38 276.77,74.93 276.52,74.93 v2(276.35,74.77)
  BOTTOM w0.102: v2(284.95,104.35) 284.75,104.55 284.75,105.03 285.49,105.78 v3(285.49,106.01) 285.49,106.85 286.27,107.62 288.07,107.62 288.24,107.79 288.24,108.07 288.56,108.39 L40.2 288.56,109 R745.1 ; R831.1 275.98,74.95 276.17,74.95 v2(276.35,74.77)
USB3RP1_RP_R: length 2.1
  BOTTOM w0.102: R831.2 274.39,74.95 274.06,74.95 273.99,74.88 273.5,74.88 273.36,74.74 U625.9
USB3RP2: length 246.8
  TOP w0.102: v2(282.17,99.35) 282.36,99.55 282.49,99.55 282.81,99.23 L43.3 283.64,99.23 R753.1
  IN3 w0.089: 80.78,76.58 80.77,76.57 80.72,76.57 80.26,76.11 79.91,76.11 79.63,75.83 79.63,75.32 79.5,75.2 79.5,74.82 79.25,74.56 79.14,74.56 78.92,74.34 v2(78.92,74.3)
  IN3 w0.127: v2(106.2,85.64) 105.99,85.84 98.76,85.84 97.61,84.7 86.38,84.7 82.81,81.12 81.61,81.12 81.17,80.68 81.17,76.97 80.78,76.58
  IN4 w0.117: v2(106.2,85.64) 106.42,85.87 106.67,85.87 107.4,85.14 113.5,85.14 116.09,82.55 149.18,82.55 149.89,81.84 150.75,81.84 153.19,79.41 155.91,79.41 160.89,74.43 192.15,74.43 197.87,68.71 198.66,68.71 199.97,67.41 201.64,67.41 203.94,65.11 207.41,65.11 210.7,61.83 228.51,61.83 229.58,62.9 231.88,62.9 232.18,63.2 234.56,63.2 234.98,63.61 241.85,63.61 242.47,63 245.08,63 246.23,64.16 246.23,65.6 247.14,66.51 247.14,71.39 249.81,74.05 261.5,74.05 266.77,79.33 267.74,79.33 276.28,87.88 276.28,91 276.56,91.28 276.56,93.31 281.61,98.36 281.61,99.33 281.83,99.55 281.97,99.55 v2(282.17,99.35)
  BOTTOM w0.076: UH1.AV26 78.55,73.94 v2(78.92,74.3)
USB3RP3: length 75.3
  IN4 w0.117: v2(88.19,122.11) 88.09,122.11 88.01,122.19 88.01,122.34 88.19,122.52 88.49,122.52 88.77,122.24 88.77,121.88 88.64,121.75 88.64,121.4 88.77,121.27 88.77,119.88 88.18,119.29 88.18,116.34 83.26,111.42 83.26,107.1 85.6,104.76 85.6,85.89 82.97,83.27 82.97,78.69 82.24,77.97 82.24,74.52 81.99,74.26 81.69,74.26 81.3,74.64 81.05,74.64 80.87,74.82 v2(80.87,74.89)
  BOTTOM w0.076: v2(80.87,74.89) 80.63,75.13 UH1.AY31
  BOTTOM w0.102: JDOCK1.86 103.74,125.85 103.58,125.69 103.58,125.49 103.38,125.29 103.05,125.29 101.03,123.27 101.03,122.99 100.38,122.34 98.88,122.34 97.76,121.22 93.19,121.22 92.28,122.14 88.85,122.14 88.68,122.3 88.38,122.3 v2(88.19,122.11)
USB3RP5: length 87.5
  TOP w0.102: v2(18.06,98.09) 17.88,98.27 15.19,98.27 15.03,98.1 JIO1.17
  IN4 w0.089: v2(79.88,74.3) 80.07,74.49 80.26,74.49 80.49,74.72 80.49,75.07 80.67,75.25 80.67,75.88 80.26,76.29 80.26,76.9 80.29,76.92
  IN4 w0.117: v2(18.06,98.09) 17.9,98.25 17.74,98.25 17.63,98.14 17.63,98.04 17.63,98.04 17.63,97.83 18.07,97.39 18.16,97.39 18.22,97.39 18.49,97.12 18.49,96.97 18.74,96.72 18.83,96.72 18.89,96.72 19.16,96.45 19.16,96.3 19.71,95.75 22.48,95.75 24.84,98.12 32,98.12 32.38,97.73 37.49,97.73 37.87,98.11 67.54,98.11 80.21,85.43 80.21,79.06 80.29,78.98 80.29,76.92
  BOTTOM w0.076: v2(79.88,74.3) 79.75,74.3 79.4,73.94 UH1.AV29
USB3RP6: length 89.4
  TOP w0.102: v2(27.35,93.61) 27.35,93.61 27.67,93.93 27.67,94.08 27.15,94.6 27.15,99.83 23.07,103.91 18.73,103.91 16.9,102.08 15.31,102.08 14.93,101.7 JIO1.5
  IN4 w0.089: v2(79.89,72.37) 79.8,72.47 79.49,72.47 79.3,72.66 79.3,75.97 79.27,76 79.27,76.01
  IN4 w0.117: v2(27.35,93.61) 27.56,93.4 27.56,93.26 27.9,92.92 28.95,92.92 29.62,93.59 38.1,93.59 38.86,94.35 42.77,94.35 43.25,94.83 54.66,94.83 55.07,94.42 63.76,94.42 76.8,81.37 76.8,80.2 77.36,79.65 77.36,78.38 79.27,76.47 79.27,76.01
  BOTTOM w0.076: v2(79.89,72.37) 79.67,72.15 UH1.AP29
USB3TN1: length 218.1
  IN4 w0.117: v2(92.51,85.51) 92.56,85.56 92.86,85.56 93.01,85.41 93.01,84.65 94.82,82.83 97.97,82.83 98.58,82.23 100.18,82.23 102.48,79.93 102.48,77.16 113.53,66.1 120.54,66.1 122.94,63.71 190.27,63.71 192.35,61.63 205.23,61.63 208,58.87 234.25,58.87 234.95,59.57 237.36,59.57 238.07,58.87 243.76,58.87 244.27,59.37 246.15,59.37 247.6,60.82 247.6,61.18 248.92,62.5 249.96,62.5 253.71,66.25 261.01,66.25 265.99,71.23 265.99,72.94 265.66,73.27 265.4,73.27 v2(265.23,73.44)
  BOTTOM w0.076: UH1.BE24 77.53,76.91 77.44,76.82 77.29,76.82 77.21,76.9 77.21,77.15 77.51,77.44 77.51,77.85 77.53,77.88 77.53,77.89
  BOTTOM w0.102: C452.2 265.63,73.13 265.54,73.13 v2(265.23,73.44) ; 77.53,77.89 77.53,79.12 77.38,79.27 77.38,80.65 82.57,85.84 86.36,85.84 86.37,85.83 86.9,85.83 86.92,85.84 92.2,85.84 92.51,85.54 v2(92.51,85.51)
USB3TN1_C: length 2.4
  BOTTOM w0.102: C452.1 267.21,73.13 267.52,73.13 267.98,73.59 268.23,73.59 268.37,73.74 U625.20
USB3TN1_RP: length 45.9
  IN3 w0.127: v2(285.56,104.36) 285.57,104.36 285.79,104.14 285.79,101.21 283.89,99.3 283.89,95.63 281.51,93.26 281.51,90.16 277.72,86.37 277.72,83.5 278.74,82.49 278.74,78.93 278.48,78.68 278.48,75.12 278.31,74.95 278.21,74.95 278.21,74.95 278.11,74.95 277.84,74.68 277.84,74.58 277.84,74.48 277.57,74.21 277.47,74.21 277.47,74.21 277.37,74.21 277.1,73.94 277.1,73.84 277.1,73.74 276.86,73.5 276.86,73.34 276.73,73.21 276.58,73.21 276.35,73.44 v2(276.35,73.55)
  BOTTOM w0.102: R743.1 289.74,109 L42.3 289.74,108.26 290.06,107.94 290.06,107.83 289.89,107.66 288.97,107.66 288.31,107 v3(286.89,107) 286.61,107 286.12,106.5 286.12,105.5 285.75,105.13 285.75,104.55 v2(285.56,104.36) ; C488.1 275.98,73.26 276.07,73.26 276.35,73.54 v2(276.35,73.55)
USB3TN1_RP_C: length 2.2
  BOTTOM w0.102: U625.11 273.36,73.74 273.5,73.59 273.74,73.59 274.07,73.26 274.39,73.26 C488.2
USB3TN2: length 249.5
  TOP w0.102: v2(282.28,95.9) 282.46,96.08 282.46,96.21 282.37,96.3 282.09,96.3 281.74,95.95 280.36,95.95 279.92,96.39 279.92,97.35 280.2,97.63 280.43,97.63 C456.2
  IN4 w0.117: v2(95.15,87.03) 95.02,87.03 94.88,86.89 94.88,86.73 95.15,86.45 95.15,85.79 95.29,85.65 95.47,85.65 95.72,85.4 95.72,85.22 95.93,85.01 96.22,85.01 96.32,85.1 96.6,85.1 96.7,85.01 97.69,85.01 98.47,85.79 103.48,85.79 107.9,81.37 129.64,81.37 130.08,81.81 148.38,81.81 149.78,80.4 150.75,80.4 152.4,78.75 154.66,78.75 155.52,77.89 156.54,77.89 160.65,73.77 191.44,73.77 197.31,67.91 198.55,67.91 201.95,64.51 206.57,64.51 209.75,61.33 233.12,61.33 233.46,61.67 244.54,61.67 246.99,64.12 246.99,65.52 250.05,68.59 250.05,70.14 253.11,73.2 262.31,73.2 265.79,76.68 265.92,76.68 276.88,87.64 276.88,90.54 277.44,91.1 277.44,93.24 279.3,95.09 282.28,95.09 282.62,95.43 282.62,95.55 282.28,95.9 v2(282.28,95.9)
  BOTTOM w0.076: UH1.BD25 77.92,76.53 77.98,76.47 78.13,76.47 78.21,76.54 78.21,76.75 77.98,76.98 77.98,77.4 78.11,77.53 78.11,77.74 78.13,77.77 78.13,77.79
  BOTTOM w0.102: 78.13,77.79 78.13,78.88 78.22,78.97 78.22,80.29 82.59,84.66 93.23,84.66 94.97,86.4 94.97,86.86 v2(95.15,87.03)
USB3TN2_C: length 2.4
  TOP w0.102: C456.1 282.01,97.66 282.4,97.66 282.63,97.43 282.73,97.43 283.05,97.75 L44.2 283.6,97.75 R750.1
USB3TN3: length 77.1
  IN4 w0.117: v2(86.74,121.32) 86.94,121.13 87.05,121.13 87.46,120.72 87.46,118.05 87,117.6 87,116.96 81.62,111.57 81.62,106.11 85.04,102.68 85.04,88.78 82.47,86.22 82.47,79.7 82.23,79.46 81.91,79.46 v2(81.74,79.29)
  BOTTOM w0.076: 80.75,77.94 80.75,77.93 80.72,77.91 80.72,77.69 80.66,77.63 80.66,77.45 80.69,77.41 80.82,77.41 80.9,77.33 80.9,77.15 80.81,77.07 UH1.BE32
  BOTTOM w0.102: v2(86.74,121.32) 86.69,121.27 86.69,121.07 86.89,120.87 88.19,120.87 88.22,120.9 92.51,120.9 92.8,120.61 97.15,120.61 97.57,120.19 100.57,120.19 100.84,120.46 103.61,120.46 104.88,121.74 104.88,125.66 104.74,125.8 JDOCK1.90 ; v2(81.74,79.29) 81.81,79.21 82.02,79.21 82.14,79.34 82.14,79.62 82.04,79.72 81.41,79.72 81.14,79.45 81.14,78.97 80.75,78.58 80.75,77.94
USB3TN5: length 82.1
  TOP w0.102: v2(16.84,96.82) 16.69,96.67 15.18,96.67 14.95,96.9 JIO1.21
  IN4 w0.117: v2(79.55,80.43) 79.38,80.26 79.29,80.26 78.79,80.76 78.79,85.72 67.15,97.35 38.28,97.35 37.9,96.97 32.08,96.97 31.69,97.35 25.25,97.35 22.83,94.93 19.3,94.93 17.59,96.65 17.01,96.65 v2(16.84,96.82)
  BOTTOM w0.076: UH1.BE26 78.21,77.07 78.15,77.13 78.15,77.33 78.21,77.38 78.46,77.38 78.5,77.42 78.5,77.62 78.45,77.67 78.45,77.82 78.42,77.85 78.42,77.86
  BOTTOM w0.102: 78.42,77.86 78.42,78.72 78.83,79.12 78.83,79.83 79.06,80.06 79.18,80.06 v2(79.55,80.43)
USB3TN6: length 87.1
  TOP w0.102: JIO1.9 15.01,100.5 15.23,100.28 16.32,100.28 v2(16.51,100.47)
  IN4 w0.117: v2(16.51,100.47) 16.68,100.3 16.94,100.3 17.32,99.92 17.32,99.02 16.31,98.01 16.31,95.36 16.69,94.98 18.21,94.98 19.02,94.18 23.38,94.18 25.28,96.08 29.92,96.08 30.04,95.96 37.57,95.96 37.82,96.21 38.41,96.21 38.81,96.62 66.56,96.62 77.39,85.79 77.39,82.44 77.88,81.95 77.88,80.64 78.49,80.02 78.49,78.84 78.88,78.45 79.35,78.45 v2(79.58,78.68)
  BOTTOM w0.076: v2(79.58,78.68) 79.36,78.46 79.04,78.46 78.84,78.26 78.84,76.68 UH1.BD27
USB3TP1: length 218.1
  IN4 w0.117: v2(265.23,72.58) 265.2,72.61 265.2,72.94 265.29,73.03 265.56,73.03 265.75,72.84 265.75,72.36 265.63,72.24 265.63,71.89 265.75,71.77 265.75,71.33 265.61,71.18 265.43,71.18 265.18,70.94 265.18,70.76 260.91,66.49 253.61,66.49 249.86,62.73 248.82,62.73 247.36,61.27 247.36,60.92 246.05,59.61 244.17,59.61 243.66,59.1 238.16,59.1 237.46,59.8 234.85,59.8 234.15,59.1 208.1,59.1 205.33,61.87 192.45,61.87 190.37,63.95 123.04,63.95 120.64,66.34 113.63,66.34 102.72,77.25 102.72,80.03 100.27,82.47 98.67,82.47 98.07,83.07 94.92,83.07 93.24,84.75 93.24,85.51 92.96,85.8 92.83,85.8 v2(92.51,86.12)
  BOTTOM w0.076: UH1.BD23 77.05,76.67 77.05,77.22 77.34,77.51 77.34,77.85 77.32,77.88 77.32,77.89
  BOTTOM w0.102: v2(92.51,86.12) 92.44,86.06 v3(86.64,86.06) 82.48,86.06 77.16,80.74 77.16,79.19 77.32,79.03 77.32,77.89 ; C454.2 265.63,72.92 265.56,72.92 v2(265.23,72.58)
USB3TP1_C: length 2.4
  BOTTOM w0.102: C454.1 267.21,72.92 267.61,72.92 268.07,73.38 268.23,73.38 268.37,73.24 U625.19
USB3TP1_RP: length 45.8
  IN3 w0.127: v2(286.14,104.37) 286.04,104.27 286.04,101.11 284.14,99.2 284.14,95.53 281.76,93.16 281.76,90.06 277.97,86.27 277.97,83.61 278.99,82.59 278.99,78.83 278.73,78.57 278.73,75.02 277.11,73.39 277.11,73.24 276.83,72.96 276.45,72.96 v2(276.35,72.86)
  BOTTOM w0.102: C489.1 275.98,73.04 276.17,73.04 v2(276.35,72.86) ; v2(286.14,104.37) 285.96,104.55 285.96,105.04 286.33,105.41 286.33,106.41 286.69,106.77 287.16,106.77 287.17,106.78 288.4,106.78 289.06,107.44 289.98,107.44 290.28,107.74 290.28,107.92 290.59,108.24 L42.2 290.59,109 R744.1
USB3TP1_RP_C: length 2.2
  BOTTOM w0.102: C489.2 274.39,73.04 273.98,73.04 273.65,73.38 273.5,73.38 273.36,73.24 U625.12
USB3TP2: length 249.5
  TOP w0.102: v2(282.86,95.9) 282.68,96.08 282.68,96.3 282.46,96.52 282,96.52 281.65,96.16 280.45,96.16 280.14,96.48 280.14,97.26 280.29,97.41 280.47,97.41 C457.2
  IN4 w0.117: v2(94.49,87.03) 94.64,86.88 94.64,86.63 94.91,86.36 94.91,85.69 95.83,84.77 97.79,84.77 98.57,85.55 103.38,85.55 107.8,81.13 129.74,81.13 130.18,81.57 148.28,81.57 149.68,80.17 150.65,80.17 152.3,78.52 154.56,78.52 155.42,77.65 156.44,77.65 160.56,73.54 191.34,73.54 197.21,67.67 198.46,67.67 201.85,64.28 206.47,64.28 209.65,61.09 233.21,61.09 233.56,61.44 244.64,61.44 247.22,64.02 247.22,65.43 250.29,68.49 250.29,70.04 253.21,72.96 262.41,72.96 265.89,76.44 266.02,76.44 277.12,87.54 277.12,90.44 277.68,91 277.68,93.14 279.4,94.86 282.38,94.86 282.86,95.33 v2(282.86,95.9)
  BOTTOM w0.076: 77.92,77.79 77.92,77.78 77.94,77.75 77.94,77.6 77.81,77.47 77.81,76.94 77.54,76.67 77.54,76.18 UH1.BC24
  BOTTOM w0.102: 77.92,77.79 77.92,78.97 78,79.06 78,80.38 82.5,84.87 93.14,84.87 94.75,86.49 94.75,86.77 v2(94.49,87.03)
USB3TP2_C: length 2.4
  TOP w0.102: R751.1 283.65,96.9 L44.3 283.07,96.9 282.76,97.21 282.54,97.21 282.31,97.45 282.05,97.45 C457.1
USB3TP3: length 77.1
  IN4 w0.117: v2(81.79,80.1) 81.79,79.77 81.86,79.69 82.13,79.69 82.24,79.79 82.24,86.31 84.8,88.88 84.8,102.59 81.38,106.01 81.38,111.67 86.77,117.06 86.77,117.7 87.22,118.15 87.22,119.51 87.1,119.64 87.1,119.99 87.22,120.12 87.22,120.62 86.95,120.89 86.77,120.89 86.64,120.76 86.64,120.59 v2(86.74,120.49)
  BOTTOM w0.076: 80.53,77.94 80.53,77.93 80.55,77.91 80.55,77.76 80.49,77.7 80.49,76.92 80.69,76.72 80.69,76.25 UH1.BC32
  BOTTOM w0.102: v2(81.79,80.1) 81.62,79.93 81.32,79.93 80.92,79.54 80.92,79.06 80.53,78.67 80.53,77.94 ; v2(86.74,120.49) 86.9,120.65 88.28,120.65 88.31,120.69 92.42,120.69 92.71,120.4 97.06,120.4 97.48,119.98 100.66,119.98 100.93,120.24 103.69,120.24 105.1,121.65 105.1,125.66 105.24,125.8 JDOCK1.92
USB3TP5: length 82.2
  TOP w0.102: JIO1.23 15.01,96.3 15.17,96.46 16.62,96.46 v2(16.84,96.24)
  IN4 w0.117: v2(79.55,79.85) 79.37,80.02 79.2,80.02 78.55,80.67 78.55,85.62 67.05,97.12 38.38,97.12 38,96.74 31.98,96.74 31.6,97.12 25.35,97.12 22.93,94.7 19.2,94.7 17.49,96.41 17.01,96.41 v2(16.84,96.24)
  BOTTOM w0.076: UH1.BC26 78.38,76.2 78.38,76.7 78.67,76.98 78.67,77.69 78.61,77.74 78.61,77.82 78.64,77.85 78.64,77.86
  BOTTOM w0.102: 78.64,77.86 78.64,78.63 79.04,79.03 79.04,79.74 79.15,79.85 v2(79.55,79.85)
USB3TP6: length 87.1
  TOP w0.102: v2(16.51,99.89) 16.33,100.07 15.18,100.07 15.01,99.9 JIO1.11
  IN4 w0.117: v2(16.51,99.89) 16.68,100.06 16.84,100.06 17.09,99.82 17.09,99.12 16.07,98.1 16.07,95.27 16.59,94.75 18.11,94.75 18.92,93.94 23.48,93.94 25.37,95.84 29.83,95.84 29.95,95.72 37.67,95.72 37.92,95.97 38.51,95.97 38.91,96.38 66.47,96.38 77.16,85.69 77.16,82.34 77.64,81.86 77.64,80.54 78.26,79.92 78.26,78.74 78.78,78.22 79.32,78.22 79.55,77.99 79.55,77.97 v2(79.58,77.94)
  BOTTOM w0.076: v2(79.58,77.94) 79.68,77.94 79.83,78.09 79.83,78.19 79.73,78.3 79.11,78.3 79.01,78.19 79.01,77.47 79.08,77.39 79.16,77.39 79.22,77.33 79.22,77.13 UH1.BE28
USB_MCARD1_DET#: length 180.4
  TOP w0.102: v2(127.51,153.23) 127.58,153.23 127.94,152.87 127.94,152.5 128.37,152.07 128.37,150.4 129.12,149.64 130.54,149.64 131.62,148.56 131.62,144.49 132.76,143.35 132.76,131.38 129.79,128.41 129.79,126.67 132.74,123.72 132.74,116.48 133.98,115.24 133.98,104.26 134.34,103.91 134.34,93.02 130.76,89.44 127.62,86.3 125.98,86.3 125.02,85.33 115.06,85.33 113.28,83.55 102.55,83.55 99.04,87.06 99.04,87.1 97.92,88.23 v2(97.86,88.23)
  IN1 w0.109: v2(85.52,54.5) 85.8,54.78 85.8,55.36 88.29,57.85 93.27,57.85 97.39,61.97 97.39,65.79 97.71,66.11 97.71,69.53 99.26,71.08 99.26,76.04 98.63,76.67 98.63,79.58 97.6,80.62 97.6,83.69 98.68,84.77 98.68,87.41 v2(97.86,88.23)
  IN3 w0.127: v2(85.52,54.5) 83.95,52.92 78.39,52.92 77.01,54.31 75.75,54.31 74.42,55.64 71.75,55.64 v2(70.89,56.5)
  BOTTOM w0.076: 71.41,57 71.41,57.27 71.69,57.55 71.69,58.23 71.84,58.38 UH1.A10
  BOTTOM w0.102: 71.41,57 71.41,56.92 70.99,56.5 v2(70.89,56.5) ; v2(127.51,153.23) 129.21,153.23 129.41,153.43 129.41,154.89 129.08,155.22 129.08,156.88 R824.1 129.54,158.59 129.49,158.63 JMINI2.40
USB_OC0#: length 299.9
  IN1 w0.109: v2(294.13,64.4) 294.13,62.83 285.01,53.7 273.56,53.7 273.03,54.24 264.36,54.24 263.78,53.66 258.94,53.66 256.82,51.55 256.82,48.6 256.19,47.97 256.19,43.04 254.07,40.93 251.56,40.93 250.42,39.79 247.06,39.79 246.66,39.38 233.23,39.38 232.22,40.39 220.27,40.39 219.88,40.79 205.16,40.79 203.82,39.45 199.02,39.45 193.7,34.13 187.96,34.13 185.91,32.08 176.13,32.08 174.6,30.54 157.4,30.54 154.7,33.25 117.33,33.25 116.04,34.53 112.04,34.53 111.91,34.4 110.41,34.4 109.55,35.26 81.54,35.26 81.41,35.4 69.33,35.4 67.91,36.81 64.68,36.81 54.58,46.91 54.58,60.9 55.42,61.74 v2(55.42,64.35)
  IN3 w0.127: v2(298.02,65.09) 297.33,64.4 v2(294.13,64.4)
  BOTTOM w0.102: v2(298.02,65.09) 298.02,65.14 297.92,65.04 U45.10 ; RH189.2 62.03,63.18 59.89,63.18 59.84,63.13 58.21,63.13 57.03,64.31 56.83,64.31 v1(56.59,64.55) 56.42,64.71 55.78,64.71 v2(55.42,64.35) ; U45.6 294.77,65.04 v2(294.13,64.4)
USB_OC0#_R: length 36.7
  IN1 w0.109: v2(42.09,76.52) 42.74,76.52 44.8,74.46 44.8,73.5 49.14,69.15 49.78,69.15 50.99,67.94 50.99,66.63 v2(51.92,65.7)
  BOTTOM w0.076: 66.52,64.2 67.46,64.2 67.64,64.38 67.99,64.38 68.15,64.22 68.59,64.22 UH1.P3
  BOTTOM w0.102: v2(42.09,76.52) 41.73,76.16 40.77,76.16 RH3.1 ; 66.52,64.2 65.84,64.2 65.56,63.92 63.32,63.92 63.07,64.17 62.1,64.17 RH189.1 61.49,63.56 60.2,63.56 RPH6.4 59.51,63.97 59.41,63.87 59.41,63.67 59.13,63.39 58.25,63.39 56.7,64.94 54.8,64.94 54.09,65.65 v1(53.75,65.65) 51.97,65.65 v2(51.92,65.7)
USB_OC1#: length 56.2
  TOP w0.102: v2(17.52,92.98) 17.17,92.62 16.18,92.62 16.1,92.7 JIO1.35
  IN1 w0.109: v2(17.52,92.98) 18.94,91.56 18.94,81.45 23.81,76.58 24.83,76.58 29.17,72.24 35.57,72.24 36.24,72.91 39.67,72.91 41.91,70.67 43.11,70.67 45.52,68.26 v2(45.52,67.73)
  BOTTOM w0.102: v2(45.52,67.73) 45.57,67.68 v1(51.19,67.68) 52.68,67.68 RH190.2
USB_OC1#_R: length 37.3
  IN1 w0.109: v2(39.64,78.49) 39.7,78.43 43.33,78.43 47.33,74.43 47.33,71.86 49.38,69.82 50.01,69.82 51.71,68.11 v2(51.94,68.11)
  BOTTOM w0.076: 66.57,65.44 66.7,65.44 67,65.75 67.79,65.75 UH1.V1
  BOTTOM w0.102: v2(39.64,78.49) 39.64,78.18 RH4.1 ; v2(51.94,68.11) 53.16,68.11 RH190.1 53.77,67.04 55.22,65.6 56,65.6 56.68,66.28 v1(56.89,66.28) 57.77,66.28 58.07,65.98 59.28,65.98 RPH6.1 60.22,65.47 60.3,65.55 65.52,65.55 65.62,65.44 66.57,65.44
USB_OC2#: length 41
  IN1 w0.109: v2(51.94,66.89) 51.41,67.42 51.41,68.12 49.92,69.61 49.28,69.61 45.24,73.65 45.24,75.04 42.39,77.89 39.5,77.89 38.53,78.85 v2(38.53,79.64)
  BOTTOM w0.076: 66.47,64.96 66.72,64.96 67,65.24 68.21,65.24 UH1.U2
  BOTTOM w0.102: v2(38.53,79.64) v1(39.15,79.02) 39.71,79.02 40.28,78.45 RH6.1 ; v2(51.94,66.89) 53.63,66.89 55.18,65.34 56.51,65.34 57.22,66.05 57.71,66.05 57.99,65.77 59,65.77 59.28,65.49 59.28,65.34 59.65,64.97 RPH6.2 60.16,64.97 60.53,64.61 63.5,64.61 63.96,65.06 65.43,65.06 65.53,64.96 66.47,64.96
USB_OC3#: length 43.7
  IN1 w0.109: v2(51.92,65.09) 50.77,66.23 50.77,67.86 49.69,68.94 49.06,68.94 44.59,73.41 44.59,74.2 43.05,75.73 42.19,75.73 40.49,77.43 39.29,77.43 37.77,78.96 37.77,80.2 v2(37.84,80.28)
  BOTTOM w0.076: UH1.P1 67.64,64.1 67.51,63.97 66.6,63.97
  BOTTOM w0.102: RH7.1 40.23,79.31 39.27,80.28 v1(38.62,80.28) v2(37.84,80.28) ; v2(51.92,65.09) 54.36,65.09 54.76,64.69 54.76,64.35 55.24,63.87 57.12,63.87 58.08,62.9 59.26,62.9 59.82,62.35 RPH7.1 59.92,62.72 60.18,62.98 62.61,62.98 63.35,63.72 65.91,63.72 66.17,63.97 66.6,63.97
USB_OC4#: length 165.7
  TOP w0.102: JIO1.37 15.56,92.1 v2(15.62,92.16) ; v2(22.45,164.88) 22.05,165.29 20.93,165.29 20.79,165.15 U48.6 ; U48.10 18.71,164.78 v2(18.26,164.78)
  IN1 w0.109: v2(46.02,67.17) 45.49,67.17 44.68,67.98 44.68,68.8 43.02,70.46 41.83,70.46 39.59,72.7 36.32,72.7 35.65,72.02 29.09,72.02 24.76,76.35 23.71,76.35 18.73,81.33 18.73,87.73 17.5,88.96 17.5,89.62 15.62,91.5 v2(15.62,92.16)
  IN3 w0.127: v2(15.62,92.16) 15.7,92.24 15.7,101.38 14.86,102.22 14.86,110.86 8.76,116.96 8.76,121.45 2.21,128 2.21,139.35 1.08,140.48 1.08,148.1 2.06,149.07 2.06,150.31 2.74,150.99 2.74,153.67 2.37,154.04 2.37,155.47 11.23,164.33 17.8,164.33 v2(18.26,164.78) 22,164.78 22.1,164.88 v2(22.45,164.88)
  BOTTOM w0.102: RH191.2 61.64,61.15 60.91,60.41 59.65,60.41 59.34,60.11 57.81,60.11 57.47,60.45 56.4,60.45 56.03,60.08 54.87,60.08 52.13,62.83 51.59,62.83 v1(51.48,62.93) 51.1,63.31 51.1,66.03 49.99,67.15 46.05,67.15 v2(46.02,67.17)
USB_OC4#_R: length 49.5
  IN1 w0.109: v2(36.9,81.24) 36.9,78.89 38.4,77.4 38.4,76.42 39.87,74.95 41.84,74.95 48.54,68.25 48.54,67.45 50.89,65.09 50.89,64.28 v2(51.89,63.28)
  BOTTOM w0.076: 66.11,62.87 66.62,62.87 66.85,63.11 67.56,63.11 67.66,63.01 67.94,63.01 68.27,63.34 68.67,63.34 UH1.M3
  BOTTOM w0.102: 66.11,62.87 64.13,62.87 63.75,62.5 63.42,62.5 63.19,62.27 63.19,61.74 RH191.1 62.11,61.65 61.37,61.65 61.05,61.33 60.55,61.33 60.07,60.85 RPH7.4 59.79,60.85 59.26,60.31 58.06,60.31 57.72,60.65 56.24,60.65 56.01,60.41 54.83,60.41 51.96,63.28 v2(51.89,63.28) ; RH8.1 39.7,80.2 38.66,81.24 v1(37.49,81.24) v2(36.9,81.24)
USB_OC5#: length 42.8
  IN1 w0.109: v2(39.39,81.09) 38.1,79.79 38.1,78.93 39.37,77.66 42.32,77.66 45.01,74.98 45.01,73.59 49.2,69.4 49.83,69.4 51.2,68.03 51.2,67.05 v2(51.94,66.31)
  BOTTOM w0.076: UH1.T1 67.76,64.96 66.98,64.96 66.78,64.76 66.45,64.76
  BOTTOM w0.102: RH9.1 v2(39.39,81.09) ; v2(51.94,66.31) v1(52.53,66.31) 53.72,66.31 54.89,65.14 56.82,65.14 58.32,63.64 59,63.64 59.16,63.79 59.16,64.2 59.43,64.47 RPH6.3 60.1,64.47 60.3,64.28 60.3,64 60.5,63.79 60.93,63.79 61.54,64.4 63.24,64.4 63.52,64.12 65.05,64.12 65.68,64.76 66.45,64.76
USB_OC6#: length 46.1
  IN1 w0.109: v2(38.68,82.08) 38.68,81.73 37.41,80.46 37.41,78.98 39.19,77.2 40.41,77.2 42.75,74.87 42.75,74.64 48.65,68.73 49.55,68.73 50.4,67.89 50.4,66.18 51.33,65.25 51.33,65.09 v2(51.92,64.5)
  BOTTOM w0.076: 65.71,63.28 66.45,63.28 66.65,63.48 67.56,63.48 67.69,63.61 68.21,63.61 UH1.N2
  BOTTOM w0.102: 65.71,63.28 63.92,63.28 63.65,63.02 63.33,63.02 62.79,62.47 62.79,62.17 62.67,62.05 61.2,62.05 60.88,61.74 60.43,61.74 60.31,61.85 RPH7.2 59.63,61.85 59.41,62.06 59.41,62.37 59.1,62.68 57.96,62.68 57.01,63.63 55.15,63.63 54.56,64.22 54.56,64.61 54.33,64.83 53.72,64.83 53.39,64.5 v2(51.92,64.5) ; v2(38.68,82.08) 38.78,81.98 v1(39.22,81.98) RH17.1
USB_PWR_SHR_EN#: length 53.2
  IN1 w0.109: v2(278.05,81.19) 278.72,80.52 278.72,71.51 278.22,71.01 277.47,71.01 276.02,69.56 271.43,69.56 270.72,70.27 268.29,70.27 268.2,70.18 253.44,70.18 253.17,69.91 250.04,69.91 249.26,69.13 v2(248.26,69.13) 248.26,69.76 247.9,70.12 246.51,70.12 245.95,70.68 244.8,70.68 243.8,69.67 243.44,69.67 242.78,69 v2(242.16,69)
  BOTTOM w0.102: U46.B10 242.26,68.91 v2(242.16,69) ; v2(248.26,69.13) 248.28,69.15 RP2.7 ; R1626.1 277.14,81.65 v1(277.29,81.5) 277.6,81.19 v2(278.05,81.19)
USB_PWR_SHR_VBUS_EN: length 100.6
  TOP w0.102: v2(234.34,73.29) 233.91,73.29 v2(231.95,75.25)
  IN1 w0.109: v2(275.36,78.32) 274.69,78.32 272.94,76.57 268.65,76.57 267.16,75.07 264.97,75.07 262.58,72.68 250.29,72.68 248.59,74.38 246.78,74.38 246.51,74.66 239.6,74.66 238.89,75.37 238.89,76.34 238.54,76.69 235.99,76.69 235.36,76.06 232.76,76.06 v2(231.95,75.25)
  IN3 w0.127: v2(277.19,60.87) 277.42,61.1 277.42,66.61 276.17,67.86 276.17,70.4 275.36,71.21 v2(275.36,78.32)
  BOTTOM w0.102: Q55.2 291.17,62.08 290.3,61.2 290.3,58.75 289.58,58.03 288.11,58.03 287.51,58.62 279.44,58.62 v1(277.73,60.33) v2(277.19,60.87) ; v2(275.36,78.32) 275.36,81.97 276.99,83.6 276.99,84.54 278.24,85.8 U2.1 ; v2(231.95,75.25) 231.45,74.74 RP1.7 ; v2(234.34,73.29) 234.24,73.29 233.85,72.91 U46.B50
USB_SIDE_EN#: length 443.5
  TOP w0.102: v3(294.99,61.53) 286.46,61.53 283.28,64.71 272.03,64.71 266.6,70.14 266.6,75.55 265.09,77.06 260.29,77.06 v2(259.89,77.46) ; v2(11.94,76.77) 12.21,76.5 JIO1.89
  IN4 w0.109: v2(259.89,77.46) 259.31,76.87 247.62,76.87 247.14,76.39 247.14,74.54 244.14,71.54 241.15,71.54 239.77,70.17 238.25,70.17 235.38,67.3 233.53,67.3 232.05,65.82 229.86,65.82 228.13,64.1 226.97,64.1 226.59,63.72 v2(226.59,63.61) ; v2(11.94,76.77) 13.5,75.21 13.5,75.12 20.23,68.39 21.74,68.39 21.79,68.35 25.78,68.35 25.96,68.17 29.13,68.17 34.03,63.26 42.24,63.26 45.66,59.84 45.66,53.2 47.84,51.02 47.84,45.43 51.29,41.98 51.56,41.98 55.42,38.12 56.85,38.12 60.87,34.1 66.45,34.1 67.36,33.19 74.9,33.19 75.29,32.79 79.79,32.79 80.35,32.23 96.9,32.23 98.49,33.82 102.96,33.82 103.33,34.19 110.4,34.19 110.59,34.38 115.74,34.38 117.13,32.98 168.59,32.98 168.99,33.38 172.13,33.38 172.67,32.84 189.89,32.84 192.15,35.1 192.15,35.98 192.95,36.78 199.68,36.78 200.75,37.85 204.54,37.85 205.56,38.86 208.5,38.86 209.82,40.17 218.13,40.17 225.09,33.21 231.8,33.21 232.68,32.33 234.4,32.33 234.54,32.18 244.9,32.18 247.09,34.38 249.51,34.38 251.08,35.94 251.08,38.81 251.72,39.44 251.72,40.45 252.35,41.08 252.35,43.26 252.24,43.37 252.24,48.57 253.24,49.57 256.11,49.57 256.35,49.81 256.35,50.55 255.93,50.97 254.96,50.97 254.63,51.3 254.63,52.43 255,52.79 255.68,52.79 257.15,54.27 262.76,54.27 263.04,54.55 272.47,54.55 272.85,54.17 286.76,54.17 293.98,61.38 294.84,61.38 v3(294.99,61.53)
  BOTTOM w0.102: v3(294.99,61.53) 295.38,61.53 295.52,61.67 U45.5 ; v2(226.59,63.61) 226.59,64.1 227.46,64.96 229.49,64.96 230.25,65.72 R768.2 230.37,65.66 U46.A33 ; v2(259.89,77.46) 260.3,77.05 v1(262.09,77.05) 262.33,77.05 263.55,78.27 Q90.2
USBP0+: length 277.8
  IN4 w0.117: v2(97.94,53.38) 98.14,53.57 98.48,53.57 99.14,52.91 109.15,52.91 113.24,48.82 116.41,48.82 117.99,47.25 125.83,47.25 126.01,47.44 128.17,47.44 128.98,46.62 158.4,46.62 159.13,47.35 194.56,47.35 198.83,51.62 204.15,51.62 204.54,52.01 230.99,52.01 232.31,53.33 235.99,53.33 236.21,53.55 242.48,53.55 243.36,54.42 246.71,54.42 247.32,55.02 249.24,55.02 250.27,56.05 250.27,56.49 251.89,58.1 251.89,58.89 253.77,60.77 256.03,60.77 257.58,59.22 263.63,59.22 264.93,57.92 272.23,57.92 279.03,64.71 279.03,67.3 281.67,69.94 281.67,76.88 284.75,79.96 286.23,79.96 287.55,81.29 287.55,84.87 285.37,87.06 285.37,95.48 286.98,97.09 286.98,100.55 290.73,104.31 290.73,105.6 291.57,106.43 291.57,110.17 293.12,111.73 293.12,113.55 294.01,114.44 296.8,114.44 297.01,114.65 297.01,114.93 v2(297.2,115.13)
  BOTTOM w0.076: UH1.D37 82.82,59.49 82.73,59.32 82.65,59.17 82.55,58.98 82.55,58.81 82.67,58.61 82.75,58.49 82.75,58.22 82.73,58.2 82.73,58.18
  BOTTOM w0.102: R748.1 297.2,116.36 L39.2 297.2,115.75 296.9,115.45 296.9,115.33 297.1,115.13 v2(297.2,115.13) ; v2(97.94,53.38) 97.89,53.38 97.18,54.09 88.7,54.09 88.36,54.42 87.76,54.42 87.53,54.64 86.01,54.64 82.73,57.92 82.73,58.18
USBP0-: length 277.8
  IN4 w0.117: v2(97.94,54.24) 97.94,54.04 98.17,53.81 98.58,53.81 99.24,53.15 109.24,53.15 113.33,49.06 116.51,49.06 118.08,47.49 125.73,47.49 125.91,47.67 128.27,47.67 129.08,46.86 158.3,46.86 159.03,47.59 194.46,47.59 198.73,51.85 204.05,51.85 204.44,52.24 230.89,52.24 232.21,53.56 235.89,53.56 236.11,53.79 242.39,53.79 243.26,54.66 246.62,54.66 247.22,55.26 249.14,55.26 250.04,56.15 250.04,56.58 251.65,58.2 251.65,58.99 253.67,61.01 256.12,61.01 257.67,59.46 263.72,59.46 265.03,58.15 272.13,58.15 278.79,64.81 278.79,67.4 281.43,70.04 281.43,76.98 284.66,80.2 286.13,80.2 287.32,81.39 287.32,84.78 285.13,86.96 285.13,95.58 286.74,97.19 286.74,100.65 290.5,104.41 290.5,105.7 291.33,106.53 291.33,110.27 292.89,111.82 292.89,113.65 293.91,114.68 296.7,114.68 296.77,114.75 296.77,114.92 296.57,115.13 v2(296.4,115.13)
  BOTTOM w0.076: 82.94,58.18 82.94,58.2 82.92,58.22 82.92,58.58 83.13,58.79 83.13,59.04 83,59.17 82.87,59.17 82.83,59.13 82.81,59.09 82.78,59.03 82.78,58.95 UH1.B37
  BOTTOM w0.102: R749.1 296.35,116.36 L39.3 296.35,115.75 296.68,115.41 296.68,115.32 296.49,115.13 v2(296.4,115.13) ; 82.94,58.18 82.94,58.01 86.1,54.86 87.62,54.86 87.85,54.64 88.45,54.64 88.78,54.31 97.27,54.31 97.79,53.79 97.94,53.79 98.07,53.91 98.07,54.11 v2(97.94,54.24)
USBP0_D+: length 9.2
  BOTTOM w0.102: JUSB1.3 293.26,120.48 293.6,120.14 294.37,120.14 295.41,121.18 296.29,121.18 296.88,120.59 296.88,120.03 296.98,119.93 D15.2 297.74,119.33 297.47,119.06 296.94,119.06 296.88,119 296.88,118.55 297.2,118.23 L39.1
USBP0_D-: length 9.2
  BOTTOM w0.102: JUSB1.2 293.26,119.54 293.65,119.93 294.46,119.93 295.5,120.97 296.2,120.97 296.66,120.5 296.66,120.03 296.56,119.93 D15.3 295.81,119.27 296.01,119.06 296.52,119.06 296.66,118.92 296.66,118.55 296.35,118.23 L39.4
USBP1+: length 230.5
  IN4 w0.117: v2(99.01,55.31) 99.2,55.11 99.71,55.11 100.48,54.34 109.65,54.34 113.74,50.26 116.6,50.26 117.7,49.16 194.61,49.16 198.63,53.18 229.34,53.18 230.58,54.43 235.54,54.43 235.63,54.52 242.08,54.52 242.97,55.41 246.31,55.41 247.1,56.21 247.86,56.21 248.38,56.73 249.12,56.73 250.92,58.53 250.92,59.29 253.39,61.76 256.42,61.76 256.71,61.46 260.42,61.46 261.34,60.55 264.05,60.55 265.7,58.9 271.58,58.9 277.79,65.11 277.79,68.26 279.23,69.69 279.23,76.07 279.82,76.67 279.82,77.9 279.52,78.2 279.52,81.92 279.82,82.23 279.95,82.23 v2(280.19,82.46)
  BOTTOM w0.076: UH1.C38 83.26,59.31 83.26,59.3 83.37,58.76 83.7,58.35 83.8,58.23 83.92,58.08 84.08,57.91 84.11,57.91 84.12,57.9
  BOTTOM w0.102: v2(280.19,82.46) 280.19,82.44 279.81,82.06 279.65,82.06 279.54,82.17 279.02,82.69 279.02,83.4 279.24,83.63 U2.6 ; v2(99.01,55.31) 99.06,55.26 99.06,55.16 98.98,55.08 98.73,55.08 98.3,55.51 97.73,55.51 97.62,55.4 88.32,55.4 88.17,55.56 86.45,55.56 86,56.01 86,56.02 84.12,57.9
USBP1-: length 230.6
  IN4 w0.117: v2(280.19,81.84) 280.04,81.99 279.92,81.99 279.75,81.82 279.75,78.3 280.06,78 280.06,76.57 279.46,75.97 279.46,69.6 278.03,68.16 278.03,65.01 271.68,58.66 265.61,58.66 263.96,60.31 261.24,60.31 260.32,61.23 256.61,61.23 256.32,61.52 253.48,61.52 251.15,59.2 251.15,58.43 249.22,56.5 248.48,56.5 247.95,55.97 247.2,55.97 246.4,55.17 243.07,55.17 242.18,54.29 235.73,54.29 235.63,54.19 230.68,54.19 229.44,52.95 198.73,52.95 194.71,48.93 117.6,48.93 116.5,50.03 113.64,50.03 109.56,54.11 100.38,54.11 99.61,54.88 99.29,54.88 v2(99.01,54.6)
  BOTTOM w0.076: UH1.A38 83.13,58.35 83.13,58.08 83.21,58 83.31,58 83.39,58.08 83.39,58.18 83.44,58.23 83.54,58.23 83.58,58.21 83.67,58.1 83.79,57.96 83.79,57.95 83.96,57.79 83.96,57.76 83.97,57.75
  BOTTOM w0.102: 83.97,57.75 84.11,57.61 85.79,55.93 85.79,55.92 86.37,55.34 88.08,55.34 88.23,55.19 97.71,55.19 97.82,55.3 98.21,55.3 98.64,54.86 98.83,54.86 99.01,54.69 v2(99.01,54.6) ; U2.7 278.74,83.47 278.81,83.4 278.81,82.59 279.26,82.14 279.56,81.84 v2(280.19,81.84)
USBP1_D+: length 4.4
  BOTTOM w0.102: U2.3 279.24,86.44 279.11,86.57 279.11,86.86 278.75,87.22 v3(278.61,87.22) 277.73,87.22 277.6,87.36 277.6,87.82 278.09,88.32 L41.2 278.09,88.89 R764.1
USBP1_D-: length 4.4
  BOTTOM w0.102: R754.1 276.89,88.89 L41.3 276.89,88.24 277.37,87.77 v3(277.37,87.5) 277.37,87.28 277.64,87.01 278.33,87.01 278.34,87 278.67,87 278.9,86.77 278.9,86.57 278.74,86.41 U2.2
USBP1_R_D+: length 25.4
  IN4 w0.117: JUSB2.3 292.66,97.15 292.66,96.43 292.12,95.9 290.8,95.9 288.29,93.38 287.72,93.38 287.58,93.53 287.58,93.74 v2(287.68,93.84)
  BOTTOM w0.102: v2(287.68,93.84) 287.63,93.79 287.63,93.31 287.18,92.86 283.5,92.86 281.9,94.46 281.9,94.65 281.74,94.82 281.22,94.82 281.16,94.76 281.16,94.16 281.04,94.03 D17.2 280.95,94.03 280.82,94.16 280.82,94.87 280.75,94.95 279.96,94.95 278.97,93.96 278.97,93.96 v3(278.78,93.76) 277.61,92.6 277.61,92.13 277.6,92.11 277.6,90.88 278.09,90.38 L41.1 278.09,89.88 R764.2
USBP1_R_D-: length 25.4
  IN4 w0.117: v2(287.09,93.84) 287.34,93.59 287.34,93.43 287.62,93.15 288.39,93.15 290.9,95.66 292.22,95.66 292.81,96.25 293.06,96.25 293.26,96.06 JUSB2.2
  BOTTOM w0.102: v2(287.09,93.84) 287.41,93.52 287.41,93.4 287.09,93.08 283.58,93.08 282.12,94.55 282.12,94.74 281.82,95.03 281.33,95.03 281.2,95.16 281.2,95.83 281.07,95.96 D17.3 280.92,95.96 280.8,95.83 280.8,95.29 280.67,95.16 279.87,95.16 278.82,94.11 278.8,94.11 278.43,93.74 278.43,93.72 277.39,92.68 v3(277.39,92.39) 277.39,90.81 276.89,90.32 L41.4 276.89,89.88 R754.2
USBP2+: length 112.6
  TOP w0.102: v2(17.4,90.36) 17.5,90.36 17.88,90.74 17.88,90.95 17.8,91.02 17.27,91.02 16.79,90.54 15.21,90.54 14.96,90.28 14.81,90.28 14.81,90.29 14.14,90.29 JIO1.43
  IN4 w0.117: v2(82.78,56.17) 82.93,56.17 83.03,56.07 83.03,55.92 82.31,55.2 82.31,54.57 82.04,54.29 81.95,54.29 81.95,54.29 81.89,54.29 81.61,54.02 81.61,53.96 81.62,53.87 81.23,53.49 80.83,53.49 80.76,53.56 80.31,53.56 80.24,53.49 79.25,53.49 78.71,52.95 76.58,52.95 76.38,52.74 75.34,52.74 74.07,51.47 72.93,51.47 71.76,52.64 65.66,52.64 65.1,53.2 62.71,53.2 61.57,54.34 61.57,56.1 60.65,57.01 60.65,57.62 61.39,58.36 61.39,81.75 60.53,82.61 60.53,83.43 56.87,87.08 49.4,87.08 48.86,86.55 43.2,86.55 42.42,87.34 40.46,87.34 40.28,87.16 39.34,87.16 37.99,88.51 28.7,88.51 27.43,87.24 24.04,87.24 21.87,89.42 20.45,89.42 18.81,91.05 17.83,91.05 17.4,90.62 v2(17.4,90.36)
  BOTTOM w0.102: v2(82.78,56.17) 82.97,56.36 82.97,57.02 82.31,57.68 82.31,57.84 82.09,58.05 82.09,58.57 82.31,58.79 82.31,59.25 UH1.C36
USBP2-: length 112.6
  TOP w0.102: v2(18.08,90.36) 18.08,91.05 17.89,91.24 17.18,91.24 16.7,90.75 15.16,90.75 15.01,90.9 15.01,90.9 14.14,90.9 JIO1.41
  IN4 w0.117: v2(18.08,90.36) 17.96,90.36 17.77,90.55 17.77,90.65 17.93,90.82 18.71,90.82 20.35,89.18 21.77,89.18 23.95,87.01 27.53,87.01 28.8,88.28 37.89,88.28 39.25,86.92 40.38,86.92 40.56,87.1 42.32,87.1 43.11,86.31 48.96,86.31 49.5,86.85 56.78,86.85 60.29,83.33 60.29,82.52 61.15,81.65 61.15,58.46 60.42,57.72 60.42,56.91 61.33,56 61.33,54.25 62.61,52.96 65.01,52.96 65.57,52.41 71.66,52.41 72.83,51.24 74.16,51.24 75.43,52.51 76.48,52.51 76.68,52.71 78.81,52.71 79.35,53.25 81.33,53.25 82.55,54.47 82.55,55.1 83.32,55.87 83.32,55.88 v2(83.62,56.17)
  BOTTOM w0.102: UH1.A36 82.41,58.44 82.31,58.34 82.31,58.14 82.52,57.93 82.52,57.77 83.18,57.11 83.18,55.92 83.31,55.79 83.49,55.79 83.62,55.92 v2(83.62,56.17)
USBP3+: length 83.6
  IN1 w0.117: v2(82.19,57.14) 82.44,56.89 85.19,56.89 85.94,57.64 85.94,58.28 86.71,59.04 86.71,59.52 88.03,60.84 88.03,72.78 88.87,73.63 88.87,77.61 89.07,77.81 89.07,82.8 88.81,83.05 88.81,103.76 90.3,105.25 90.3,109.56 91.89,111.16 91.89,118.19 93.88,120.18 94.41,120.18 96.9,122.67 96.9,123.48 97.19,123.77 97.44,123.77 v2(97.64,123.97)
  BOTTOM w0.102: UH1.C34 81.61,59.35 81.66,59.3 81.66,58.84 81.89,58.61 81.89,57.98 82.05,57.81 82.05,57.28 v2(82.19,57.14) ; JDOCK1.72 100.24,125.88 100.42,125.71 100.42,125.53 100.38,125.49 100.12,125.23 99.99,125.23 99.75,124.99 99.75,124.86 99.54,124.65 99.41,124.65 99.17,124.41 99.17,124.28 98.54,123.65 97.95,123.65 v2(97.64,123.97)
USBP3-: length 83.7
  IN1 w0.117: v2(97.64,123.38) 97.48,123.53 97.28,123.53 97.14,123.38 97.14,122.57 94.51,119.94 93.98,119.94 92.12,118.09 92.12,111.06 90.53,109.47 90.53,105.15 89.05,103.67 89.05,83.15 89.31,82.9 89.31,77.71 89.11,77.52 89.11,73.53 88.26,72.68 88.26,60.74 86.94,59.42 86.94,58.94 86.18,58.18 86.18,57.54 85.29,56.66 82.5,56.66 v2(82.19,56.35)
  BOTTOM w0.102: v2(82.19,56.35) 82.24,56.4 82.24,56.68 82.17,56.76 81.99,56.76 81.81,56.93 81.81,57.75 81.67,57.89 81.67,58.37 UH1.A34 ; v2(97.64,123.38) 97.69,123.43 98.63,123.43 100.53,125.34 100.63,125.44 100.63,125.7 100.74,125.8 JDOCK1.74
USBP4+: length 144.6
  IN1 w0.117: v2(97.84,86.2) 97.66,86.02 97.66,85.31 96.73,84.37 96.73,77.32 98.47,75.58 98.47,71.75 96.98,70.25 96.98,66.49 96.16,65.67 96.16,63.71 95.87,63.42 95.87,61.81 92.84,58.79 89.41,58.79 89,58.37 87.47,58.37 86.92,57.82 86.92,57.19 84.27,54.54 83.43,54.54 v2(83.26,54.37)
  IN4 w0.117: v2(97.84,86.2) 97.66,86.37 97.66,86.7 103.96,93 105.87,93 112.17,99.31 112.17,100.05 113.99,101.87 114.63,101.87 116.59,103.83 116.59,118.8 115.44,119.95 115.44,121.73 114.99,122.18 114.99,123.03 115.73,123.77 115.73,130.85 116.31,131.44 116.31,134.18 117.3,135.16 117.3,137.14 117.87,137.72 117.87,138.51 119.18,139.81 119.18,148.07 118.5,148.75 118.5,153.17 123.24,157.91 123.24,158.51 125.11,160.38 128.01,160.38 128.41,160.78 128.41,161.27 v2(128.6,161.46)
  BOTTOM w0.102: UH1.D33 81.19,59.32 80.9,59.03 80.9,58.77 81.08,58.6 81.08,58.2 81.22,58.06 81.22,57.71 81.38,57.54 81.38,55.64 82.5,54.52 83.11,54.52 v2(83.26,54.37) ; JMINI2.38 128.69,160.82 128.4,161.12 128.4,161.26 v2(128.6,161.46)
