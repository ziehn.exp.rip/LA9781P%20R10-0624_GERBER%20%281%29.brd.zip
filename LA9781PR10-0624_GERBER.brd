# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP4-: length 144.6
  IN1 w0.117: v2(97.25,86.2) 97.43,86.02 97.43,85.4 96.49,84.47 96.49,77.23 98.24,75.48 98.24,71.85 96.74,70.35 96.74,66.58 95.93,65.77 95.93,63.81 95.63,63.51 95.63,61.91 92.74,59.03 89.31,59.03 88.9,58.61 87.37,58.61 86.68,57.92 86.68,57.29 84.17,54.78 83.36,54.78 83.16,54.98 83.16,55.11 v2(83.26,55.21)
  IN4 w0.117: v2(97.25,86.2) 97.43,86.37 97.43,86.8 103.86,93.24 105.77,93.24 111.94,99.41 111.94,100.14 113.9,102.1 114.53,102.1 116.36,103.93 116.36,118.7 115.21,119.85 115.21,121.63 114.76,122.08 114.76,123.13 115.49,123.86 115.49,130.95 116.08,131.53 116.08,134.28 117.06,135.26 117.06,137.24 117.64,137.82 117.64,138.61 118.94,139.91 118.94,147.97 118.26,148.65 118.26,153.27 123,158.01 123,158.61 125.01,160.62 127.91,160.62 128.18,160.88 128.18,161.27 v2(127.99,161.46)
  BOTTOM w0.102: v2(83.26,55.21) 83.46,55.21 83.64,55.03 83.64,54.88 83.54,54.78 83.03,54.78 82.99,54.74 82.59,54.74 82.4,54.93 82.4,55.03 82.13,55.3 82.03,55.3 81.6,55.73 81.6,55.88 81.71,55.99 81.71,56.3 81.6,56.41 81.6,57.63 81.43,57.8 81.43,58.15 81.29,58.29 81.29,58.57 81.41,58.69 81.41,58.84 81.35,58.89 UH1.B33 ; v2(127.99,161.46) 128.18,161.26 128.18,161.12 127.89,160.82 JMINI2.36
USBP5+: length 215.6
  IN1 w0.089: 80.31,59.75 80.31,59.77 80.34,59.79 80.34,60.68 80.85,61.2 v2(80.85,61.21)
  IN1 w0.117: v2(263.14,56.73) 263.33,56.92 263.33,57.25 263.09,57.49 262.41,57.49 261.26,56.34 259.76,56.34 259.54,56.12 255.4,56.12 254.75,55.48 251.08,55.48 250.03,56.53 238.46,56.53 238.14,56.22 215.16,56.22 212.83,53.89 201.25,53.89 192.38,45.02 185.49,45.02 184.88,44.4 181.49,44.4 181.08,44.82 175.95,44.82 175.95,44.82 172.08,44.82 171.68,45.23 123.36,45.23 121.23,47.36 117.91,47.36 113.64,51.62 103.71,51.62 103.17,52.16 93.92,52.16 92.71,53.37 89.25,53.37 89.02,53.14 87.84,53.14 87.61,53.37 85.6,53.37 85.17,53.8 84.75,53.8 84.58,53.64 82.77,53.64 81.88,54.53 81.88,54.83 81.4,55.31 81.4,58.08 80.31,59.17 80.31,59.75
  BOTTOM w0.102: v2(80.85,61.21) 80.61,60.97 UH1.G31 ; JMINI1.38 262.4,47 262.58,47.18 263.19,47.18 264.34,48.32 264.34,55.54 264.7,55.91 264.7,57 264.2,57.51 263.61,57.51 263.36,57.25 263.36,56.93 263.16,56.73 v2(263.14,56.73)
USBP5-: length 215.6
  IN1 w0.089: v2(80.84,60.62) 80.84,60.74 80.79,60.8 80.72,60.8 80.53,60.6 80.53,59.79 80.55,59.77 80.55,59.75
  IN1 w0.117: v2(263.98,56.73) 263.68,56.73 263.57,56.84 263.57,57.35 263.19,57.73 262.31,57.73 261.16,56.58 259.66,56.58 259.44,56.36 255.3,56.36 254.66,55.72 251.18,55.72 250.13,56.77 238.36,56.77 238.04,56.45 215.06,56.45 212.73,54.12 201.15,54.12 192.28,45.26 185.4,45.26 184.78,44.64 181.59,44.64 181.17,45.06 176.19,45.06 176.18,45.06 172.18,45.06 171.78,45.46 123.46,45.46 121.33,47.6 118,47.6 113.74,51.86 103.81,51.86 103.27,52.4 94.02,52.4 92.81,53.61 89.15,53.61 88.92,53.38 87.93,53.38 87.7,53.61 85.7,53.61 85.27,54.04 84.65,54.04 84.49,53.87 82.87,53.87 82.12,54.62 82.12,54.93 81.63,55.41 81.63,58.18 80.55,59.26 80.55,59.75
  BOTTOM w0.102: JMINI1.36 262.24,47.8 262.65,47.4 263.1,47.4 264.12,48.41 264.12,54.06 264.03,54.15 264.03,54.5 264.12,54.59 264.12,54.9 264.03,54.99 264.03,55.34 264.12,55.43 264.12,55.63 264.49,56 264.49,56.91 264.11,57.29 263.7,57.29 263.57,57.16 263.57,56.53 263.7,56.4 263.88,56.4 263.98,56.5 v2(263.98,56.73) ; v2(80.84,60.62) 80.6,60.38 UH1.F31
USBP6+: length 84.9
  IN1 w0.089: v2(80.86,62.41) 81.1,62.17 81.28,62.17 81.46,61.99 81.46,59.58 81.67,59.36 81.68,59.37 81.7,59.37 81.7,59.36
  IN1 w0.117: 81.7,59.36 81.81,59.25 82.7,59.25 83.35,58.59 85.2,58.59 85.87,59.26 85.87,71.92 88.04,74.08 88.04,77.28 87.77,77.54 87.77,82.68 88.05,82.95 88.05,104.15 88.57,104.66 88.57,109.26 90.08,110.78 90.08,114.03 91.15,115.1 91.15,121.72 93.78,124.35 96.15,124.35 97.04,125.24 98.02,125.24 v2(98.22,125.44)
  BOTTOM w0.102: JDOCK1.66 98.74,125.99 99.03,125.69 99.03,125.41 98.69,125.07 98.59,125.07 v2(98.22,125.44) ; v2(80.86,62.41) 80.51,62.76 UH1.L31
USBP6-: length 85
  IN1 w0.089: v2(80.86,61.8) 81.04,61.98 81.2,61.98 81.27,61.91 81.27,59.5 81.54,59.23 81.53,59.22 81.53,59.2 81.54,59.19
  IN1 w0.117: v2(98.22,124.85) 98.07,125.01 97.14,125.01 96.25,124.11 93.87,124.11 91.39,121.62 91.39,115 90.32,113.93 90.32,110.68 88.8,109.16 88.8,104.56 88.29,104.05 88.29,82.86 88.01,82.58 88.01,77.64 88.27,77.38 88.27,73.99 86.1,71.82 86.1,59.17 85.3,58.36 83.26,58.36 82.6,59.01 81.72,59.01 81.54,59.19
  BOTTOM w0.102: UH1.K31 80.5,62.17 v2(80.86,61.8) ; v2(98.22,124.85) 98.78,124.85 99.19,125.26 99.24,125.31 99.24,126.7 JDOCK1.68
USBP7+: length 61.4
  TOP w0.102: JUSH1.3 116.1,36.03 116.18,36.15 116.16,36.25 v3(116.16,43.37) 116.16,45.01 117.23,46.08 117.23,46.86 117.04,47.05 116.67,47.05 116.52,46.9 v2(116.52,46.62)
  IN1 w0.089: v2(79.88,61.22) 79.74,61.07 79.49,61.07 79.28,60.87 79.28,59.59 79.32,59.55 79.32,59.26 79.3,59.24 79.3,59.22
  IN1 w0.117: v2(116.52,46.62) 116.34,46.8 116.12,46.8 112.04,50.89 102.97,50.89 102.44,51.42 93.62,51.42 93.4,51.64 85.78,51.64 84.52,52.9 81.7,52.9 80.15,54.45 80.15,58 79.3,58.85 79.3,59.22
  BOTTOM w0.102: v2(79.88,61.22) 79.88,61.21 79.74,61.21 UH1.H29
USBP7-: length 61.5
  TOP w0.102: JUSH1.2 116.51,36.1 116.39,36.19 116.38,36.27 116.38,43.09 116.39,43.11 116.39,43.64 116.38,43.65 116.38,44.92 117.45,45.99 117.45,46.95 117.13,47.27 116.69,47.27 v2(116.52,47.44)
  IN1 w0.089: v2(79.88,60.57) 79.88,60.69 79.69,60.88 79.56,60.88 79.48,60.8 79.48,59.67 79.51,59.63 79.51,59.26 79.54,59.24 79.54,59.22
  IN1 w0.117: 79.54,59.22 79.54,58.95 80.39,58.1 80.39,54.55 81.8,53.14 84.62,53.14 85.88,51.88 93.5,51.88 93.72,51.66 102.54,51.66 103.07,51.12 112.13,51.12 114.52,48.73 114.65,48.73 114.95,48.43 114.95,48.31 115.2,48.06 115.33,48.06 115.62,47.76 115.62,47.63 116.22,47.04 116.5,47.04 116.62,47.16 116.62,47.33 v2(116.52,47.44)
  BOTTOM w0.102: UH1.G29 79.46,60.97 79.88,60.56 v2(79.88,60.57)
USBP8+: length 168.2
  TOP w0.102: R736.1 15.77,161.45 L51.1 15.77,160.84 15.57,160.64 15.39,160.64 15.31,160.57 15.31,160.21 15.57,159.96 15.8,159.96 15.9,160.06 v2(15.9,160.19)
  IN3 w0.127: v2(46.16,89.6) 46.24,89.68 46.24,90.5 46.33,90.59 46.33,92.65 17.86,121.12 17.86,123.66 14.93,126.59 14.93,127.46 6.84,135.55 6.84,139.43 3.43,142.84 3.43,144.94 5.83,147.35 7.74,147.35 10.54,150.15 10.54,152.44 11.2,153.1 11.2,157.75 13.09,159.65 14.63,159.65 15.16,160.18 15.89,160.18 v2(15.9,160.19)
  IN4 w0.117: v2(46.16,89.6) 46.38,89.38 46.38,89.17 46.62,88.93 47.82,88.93 48.56,89.68 53.69,89.68 54.2,89.17 58.87,89.17 61.56,86.48 61.56,85.79 64,83.35 64,78.75 63.77,78.52 63.77,75.93 63.44,75.6 63.44,63.57 64.2,62.81 64.2,60.78 66.62,58.36 66.62,58 67.05,57.57 67.05,56.13 67.41,55.77 74.22,55.77 74.91,56.46 74.91,57.27 75.73,58.1 78.35,58.1 78.46,58.2 79.14,58.2 80.39,56.95 80.6,56.95 v2(80.82,56.73)
  BOTTOM w0.102: v2(80.82,56.73) 80.22,57.33 80.22,57.94 80.48,58.19 80.48,58.57 80.7,58.79 80.7,59.26 UH1.C32
USBP8-: length 167.9
  TOP w0.102: R742.1 14.92,161.45 L51.4 14.92,160.74 15.11,160.54 15.11,160.11 15.48,159.74 15.71,159.74 v2(15.9,159.55)
  IN3 w0.127: v2(46.74,89.6) 46.74,89.61 46.49,89.87 46.49,90.4 46.58,90.49 46.58,92.75 18.11,121.22 18.11,123.76 15.17,126.69 15.17,127.56 7.09,135.65 7.09,139.53 3.68,142.94 3.68,144.84 5.94,147.1 7.84,147.1 10.79,150.05 10.79,152.34 11.45,152.99 11.45,157.65 13.2,159.4 14.73,159.4 15.26,159.93 15.52,159.93 v2(15.9,159.55)
  IN4 w0.117: v2(46.74,89.6) 46.62,89.47 46.62,89.27 46.71,89.17 47.72,89.17 48.47,89.91 53.79,89.91 54.3,89.4 58.97,89.4 61.8,86.58 61.8,85.89 64.24,83.45 64.24,78.66 64.01,78.43 64.01,75.84 63.68,75.51 63.68,63.67 64.44,62.9 64.44,60.88 66.86,58.46 66.86,58.1 67.28,57.67 67.28,56.22 67.5,56 74.12,56 74.67,56.55 74.67,57.37 75.64,58.33 78.25,58.33 78.36,58.44 79.24,58.44 80.49,57.19 80.75,57.19 80.87,57.32 80.87,57.66 v2(80.83,57.7)
  BOTTOM w0.102: v2(80.83,57.7) 80.92,57.7 81.18,57.44 81.18,57.11 81.13,57.06 81.05,57.06 80.92,57.19 80.67,57.19 80.44,57.42 80.44,57.85 80.72,58.13 80.8,58.13 80.87,58.2 80.87,58.35 UH1.A32
USBP8_D+: length 18.5
  TOP w0.102: R736.2 15.77,162.53 L51.2 15.77,163.29 15.45,163.61 15.45,164.03 D73.3 15.8,164.88 15.59,165.09 15.59,165.57 16.99,166.97 16.99,170.7 15.31,172.38 11.38,172.38 10.68,171.68 10.68,171.15 10.5,170.97 JESA1.3
USBP8_D-: length 18.6
  TOP w0.102: R742.2 14.92,162.53 L51.3 14.92,163.29 15.23,163.61 15.23,164.03 D73.2 15.21,164.88 15.38,165.05 15.38,165.66 16.78,167.06 16.78,170.61 15.23,172.16 11.47,172.16 10.9,171.59 10.9,171.08 11.01,170.97 JESA1.2
USBP9+: length 110.3
  TOP w0.102: JIO1.49 14.14,88.49 14.84,88.49 15.14,88.79 16.53,88.79 16.98,88.34 16.98,88.24 16.64,87.9 v2(16.58,87.9)
  IN4 w0.117: v2(80.81,55.96) 80.81,55.83 80.65,55.67 80.42,55.67 79.9,55.15 79.9,54.7 79.47,54.27 77.6,54.27 77.16,53.84 74.07,53.84 73.48,54.42 66.04,54.42 65.88,54.58 62.71,54.58 62.38,54.91 62.38,58.55 62.15,58.78 62.15,82.89 57.2,87.85 49,87.85 48.54,87.39 43.44,87.39 42.59,88.24 40.66,88.24 39.09,89.8 27.76,89.8 26.94,88.98 24.81,88.98 24.34,88.51 23.84,88.51 22.2,90.16 20.98,90.16 19.35,91.79 17.53,91.79 16.09,90.36 16.09,89.2 16.58,88.71 v2(16.58,87.9)
  BOTTOM w0.102: v2(80.81,55.96) 80.36,56.41 80.36,56.83 80.03,57.16 80.03,58.03 80.27,58.26 80.27,58.57 79.97,58.88 UH1.C30
USBP9-: length 110.3
  TOP w0.102: v2(17.22,87.9) 17.22,88.41 16.64,88.99 15.12,88.99 15.01,89.1 15.01,89.1 14.14,89.1 JIO1.47
  IN4 w0.117: v2(80.95,55.33) 80.85,55.44 80.52,55.44 80.14,55.05 80.14,54.6 79.57,54.03 78.98,54.03 78.89,53.94 78.48,53.94 78.39,54.03 77.69,54.03 77.26,53.6 76.92,53.6 76.83,53.51 76.42,53.51 76.33,53.6 73.97,53.6 73.39,54.18 65.94,54.18 65.78,54.34 62.61,54.34 62.14,54.81 62.14,58.45 61.92,58.68 61.92,82.8 57.1,87.61 49.1,87.61 48.64,87.15 43.34,87.15 42.49,88 40.56,88 39,89.57 27.86,89.57 27.04,88.75 24.91,88.75 24.44,88.28 23.74,88.28 22.1,89.92 20.89,89.92 19.25,91.55 17.63,91.55 16.33,90.26 16.33,89.3 16.82,88.81 16.82,88.27 17.19,87.9 v2(17.22,87.9)
  BOTTOM w0.102: v2(80.95,55.33) 80.92,55.31 80.54,55.31 80.36,55.49 80.36,56.05 80.15,56.27 80.15,56.74 79.82,57.07 79.82,58.12 79.97,58.27 UH1.A30
USBP10+: length 96.5
  TOP w0.102: v2(22.13,91.48) 22.13,90.78 21.84,90.49 20.45,90.49 20.26,90.3 JIO1.44
  IN4 w0.117: v2(22.13,91.48) 21.86,91.21 21.86,91.09 22.04,90.92 22.63,90.92 23.62,89.93 23.95,89.93 24.05,90.03 24.45,90.03 24.55,89.93 24.9,89.93 25,90.03 25.41,90.03 25.51,89.93 26.64,89.93 27.25,90.54 41.38,90.54 43.76,88.15 48.08,88.15 48.51,88.58 57.53,88.58 62.9,83.22 62.9,61.19 66.06,58.03 66.06,57.85 66.55,57.37 66.55,55.87 67.22,55.19 73.76,55.19 74.37,54.57 76.8,54.57 77.29,55.06 78.61,55.06 v2(78.98,55.43)
  BOTTOM w0.102: v2(78.98,55.43) 79.14,55.59 79.18,55.63 79.18,55.63 79.51,55.96 79.51,56.69 79.41,56.79 79.41,58.29 79.45,58.33 79.45,58.61 79.27,58.79 79.27,59.02 79.55,59.3 79.55,59.77 UH1.D29
USBP10-: length 96.4
  TOP w0.102: JIO1.42 20.26,90.9 20.47,90.7 20.67,90.7 20.77,90.79 21.34,90.79 21.44,90.7 21.76,90.7 21.93,90.87 21.93,91.1 v2(21.53,91.5)
  IN4 w0.117: v2(78.98,54.84) 78.98,54.83 77.39,54.83 76.9,54.34 74.28,54.34 73.66,54.95 67.13,54.95 66.31,55.77 66.31,57.27 65.83,57.75 65.83,57.93 62.66,61.1 62.66,83.12 57.43,88.35 48.61,88.35 48.17,87.91 43.66,87.91 41.28,90.3 27.35,90.3 26.74,89.69 23.52,89.69 22.53,90.68 21.94,90.68 21.63,91 21.63,91.4 v2(21.53,91.5)
  BOTTOM w0.102: v2(78.98,54.84) 79.15,54.84 79.4,55.08 79.4,55.54 79.73,55.87 79.73,56.78 79.63,56.88 79.63,58.2 79.67,58.24 79.67,58.57 79.78,58.69 79.78,58.84 79.73,58.89 UH1.B29
USBP11+: length 279
  TOP w0.102: JBT1.12 291.56,106.11 292.05,105.63 292.05,105.37 292.28,105.14 292.28,105.04 292.55,104.77 292.65,104.77 292.87,104.55 292.87,104.45 293.13,104.19 293.24,104.19 293.37,104.05 293.37,103.67 293.2,103.51 293.03,103.51 292.84,103.7 v2(292.84,103.77)
  IN1 w0.117: v2(78.81,57.24) 78.99,57.06 79.2,57.06 79.65,56.6 79.65,54.24 81.49,52.4 84.29,52.4 85.57,51.12 92,51.12 92.73,50.39 111.22,50.39 115.52,46.09 121.77,46.09 123.75,44.11 134.87,44.11 135.48,44.72 171.39,44.72 171.8,44.31 175.23,44.31 175.64,43.9 185.16,43.9 185.73,44.47 192.54,44.47 201.45,53.38 214.24,53.38 216.16,55.29 234.23,55.29 234.54,54.98 241.37,54.98 241.98,55.58 247.99,55.58 248.04,55.54 250.27,55.54 250.83,54.98 255.12,54.98 255.77,55.62 260.18,55.62 260.35,55.79 282.93,55.79 293.25,66.12 293.25,74.17 291.39,76.04 291.39,82.13 290.16,83.35 290.16,101.91 291.82,103.58 292.64,103.58 v2(292.84,103.77)
  BOTTOM w0.076: v2(78.81,57.24) 78.87,57.29 78.87,58.59 79.04,58.76 79.04,59.14 79.16,59.26 UH1.C28
USBP11-: length 279
  TOP w0.102: v2(292.84,103.14) 292.99,103.29 293.29,103.29 293.58,103.58 293.58,104.14 292.26,105.46 292.26,105.61 292.56,105.91 JBT1.11
  IN1 w0.117: v2(78.81,56.66) 78.98,56.83 79.1,56.83 79.42,56.51 79.42,54.14 81.39,52.17 84.19,52.17 85.47,50.88 91.9,50.88 92.63,50.15 111.12,50.15 115.42,45.85 121.67,45.85 123.65,43.87 134.97,43.87 135.58,44.48 171.3,44.48 171.7,44.07 175.14,44.07 175.54,43.67 185.26,43.67 185.83,44.23 192.64,44.23 201.54,53.14 214.34,53.14 216.25,55.06 234.13,55.06 234.44,54.74 241.47,54.74 242.07,55.35 247.9,55.35 247.94,55.3 250.17,55.3 250.73,54.74 255.22,54.74 255.86,55.39 260.28,55.39 260.45,55.56 283.03,55.56 293.49,66.02 293.49,74.27 291.62,76.14 291.62,82.23 290.4,83.45 290.4,101.82 291.92,103.34 292.63,103.34 v2(292.84,103.14)
  BOTTOM w0.076: v2(78.81,56.66) 79.09,56.66 79.2,56.76 79.2,57.93 79.04,58.08 79.04,58.33 UH1.A28
USBP12+: length 110.2
  TOP w0.102: v2(45.26,90.99) 45.03,91.22 45.03,93.1 33.31,104.83 33.31,112.93 33.87,113.49 33.87,113.97 33.88,113.98 33.88,114.52 33.87,114.53 33.87,123.65 34.49,124.27 34.49,126.25 33.46,127.28 32.14,127.28 31.92,127.5 L10.1 31.34,127.5 R428.1
  IN4 w0.117: v2(78.9,60.56) 78.81,60.65 78.67,60.65 78.53,60.51 78.53,60.2 78.19,59.85 78.19,59.73 77.36,58.91 75.51,58.91 74.69,58.1 68.13,58.1 66.97,59.25 66.97,60.16 65.75,61.38 65.75,63.03 65.29,63.49 65.29,64.84 64.33,65.8 64.33,73.75 64.96,74.38 64.96,77.64 64.84,77.76 64.84,82.18 65.45,82.79 65.45,83.92 59.36,90.01 54.68,90.01 54.24,90.45 47.12,90.45 46,91.58 45.06,91.58 44.75,91.27 44.75,90.92 44.88,90.79 45.07,90.79 v2(45.26,90.99)
  BOTTOM w0.102: v2(78.9,60.56) 78.71,60.38 UH1.F26
USBP12-: length 110
  TOP w0.102: R427.1 31.34,126.7 L10.4 31.82,126.7 32.18,127.06 33.37,127.06 34.28,126.16 34.28,124.36 33.65,123.74 v3(33.65,114.25) 33.65,113.58 33.09,113.02 33.09,104.74 44.82,93.02 44.82,91.24 44.59,91.01 v2(44.33,91.01)
  IN4 w0.117: v2(44.33,91.01) 44.52,91.2 44.52,91.37 44.96,91.82 46.1,91.82 47.22,90.69 54.33,90.69 54.78,90.24 59.46,90.24 65.68,84.02 65.68,82.69 65.07,82.08 65.07,77.86 65.2,77.73 65.2,74.28 64.57,73.65 64.57,65.9 65.53,64.94 65.53,63.59 65.99,63.13 65.99,61.48 67.21,60.26 67.21,59.35 68.22,58.33 74.59,58.33 75.41,59.14 77.27,59.14 77.95,59.83 77.95,59.95 78.29,60.29 78.29,60.61 v2(78.9,61.21)
  BOTTOM w0.102: UH1.G26 78.66,60.97 v2(78.9,61.21)
USBP12_D+: length 24.9
  TOP w0.102: R428.2 30.03,127.61 L10.2 29.6,127.5 29.3,127.2 22.13,127.2 20.37,128.97 17.74,128.97 17.73,128.98 17.2,128.98 17.18,128.97 v3(11.17,128.97) 8.35,128.97 7.79,128.41 7.51,128.41 JCAM1.19
USBP12_D-: length 24.9
  TOP w0.102: R427.2 30.03,126.59 L10.3 29.72,126.7 29.44,126.99 22.05,126.99 20.28,128.75 v3(17.46,128.75) 11.45,128.75 11.44,128.74 10.91,128.74 10.9,128.75 8.44,128.75 8.22,128.54 8.22,127.7 JCAM1.17
USBP13+: length 96.6
  TOP w0.102: R430.1 31.24,115.32 L11.1 31.76,115.32 32.07,115.01 32.52,115.01 32.84,114.69 32.84,114.29 32.43,113.88 v3(32.43,107.56) 32.43,102.5 42.95,91.99 43.08,91.99 v2(43.27,92.18)
  IN4 w0.089: 75.51,59.88 75.54,59.88 75.56,59.86 76.51,59.86 77.14,60.49 77.14,60.74 77.37,60.97 77.65,60.97 v2(77.9,61.23)
  IN4 w0.117: v2(43.27,92.18) 43.43,92.02 43.56,92.02 44.27,92.72 46.33,92.72 47.63,91.43 54.94,91.43 55.32,91.05 61.13,91.05 66.48,85.7 66.48,82.39 66.33,82.24 66.33,76.11 67.79,74.64 67.79,69.3 65.53,67.04 65.53,65.98 66.39,65.11 66.39,64.33 67.99,62.73 67.99,59.65 68.63,59.02 74.24,59.02 75.1,59.88 75.51,59.88
  BOTTOM w0.102: UH1.G24 77.65,60.97 v2(77.9,61.23)
USBP13-: length 96.6
  TOP w0.102: R429.1 31.24,114.52 L11.4 31.77,114.52 32.05,114.8 32.43,114.8 32.63,114.6 32.63,114.38 32.22,113.97 32.22,107.84 32.21,107.82 32.21,107.29 32.22,107.28 32.22,102.41 42.86,91.77 43.04,91.77 v2(43.25,91.55)
  IN4 w0.089: 75.51,59.64 75.54,59.64 75.56,59.67 76.59,59.67 77.33,60.41 77.33,60.67 77.45,60.78 77.71,60.78 v2(77.9,60.59)
  IN4 w0.117: 75.51,59.64 75.2,59.64 74.34,58.78 68.53,58.78 67.76,59.55 67.76,62.63 66.16,64.23 66.16,65.02 65.29,65.88 65.29,67.14 67.56,69.4 67.56,74.54 66.09,76.01 66.09,82.33 66.24,82.49 66.24,85.61 61.03,90.82 55.22,90.82 54.84,91.19 47.53,91.19 46.23,92.49 44.36,92.49 43.66,91.78 43.48,91.78 v2(43.25,91.55)
  BOTTOM w0.102: UH1.F24 77.68,60.38 v2(77.9,60.59)
USBP13_D+: length 22.1
  TOP w0.102: R430.2 30.11,115.32 L11.2 29.55,115.32 29.26,115.02 29.08,115.02 27.84,116.27 27.84,116.4 26.88,117.35 24.1,117.35 24.09,117.36 23.56,117.36 23.55,117.35 22.9,117.35 16.75,123.5 v3(15.44,123.5) 14.47,123.5 13.65,122.68 13.1,122.68 JCAM1.3
USBP13_D-: length 21.9
  TOP w0.102: JCAM1.1 13.8,121.97 13.8,122.52 14.56,123.28 15.16,123.28 15.18,123.27 15.71,123.27 15.72,123.28 16.66,123.28 22.81,117.13 v3(23.82,117.13) 26.79,117.13 27.62,116.31 27.62,116.18 28.99,114.81 29.3,114.81 29.59,114.52 L11.3 30.11,114.52 R429.2
USBRBIAS: length 2.4
  TOP w0.102: RH187.1 77.32,61.85 v2(77.92,62.45)
  BOTTOM w0.102: UH1.K26 78.13,62.45 v2(77.92,62.45) 77.71,62.45 UH1.K24
USH_DET#: length 91.2
  TOP w0.076: 72.03,59.65 72.03,60.11 72.42,60.5 v2(72.42,60.51)
  TOP w0.102: 72.03,59.65 72.03,59.55 72.39,59.2 72.39,56 72.77,55.61 72.77,51.15 72.57,50.95 72.57,49.49 72.72,49.34 72.72,48.63 71.81,47.71 71.41,47.71 70.8,47.1 69.49,47.1 69.06,46.67 RPH9.6 69.06,46.02 69.26,45.81 69.85,45.81 70.23,45.43 70.23,44.18 70.88,43.53 80.06,43.53 v2(80.37,43.84) ; v2(118.87,28.44) 118.87,27.56 118.63,27.32 JUSH1.20 ; v2(108.67,31.69) 109.32,32.33 109.32,35.27 110.58,36.53 110.58,43.79 v2(110.01,44.36)
  IN1 w0.109: v2(110.01,44.36) 108.23,42.58 104.49,42.58 103.51,43.56 94.74,43.56 93.98,42.8 81.41,42.8 v2(80.37,43.84)
  IN3 w0.127: v2(118.87,28.44) 114.7,28.44 113.37,29.77 110.91,29.77 108.99,31.69 v2(108.67,31.69)
  BOTTOM w0.102: v2(72.42,60.51) 72.77,60.51 UH1.F13 ; v1(118.01,28.68) 118.25,28.44 v2(118.87,28.44)
USH_PWR_ON: length 170.1
  TOP w0.102: v2(96.77,41.19) v1(96.77,40.34) 96.77,39.97 97.94,38.8 R1621.1
  IN3 w0.127: v2(96.77,41.19) 97.15,40.81 100.28,40.81 100.89,40.2 119.84,40.2 121.41,38.62 144.06,38.62 147.06,35.62 155.78,35.62 156.7,34.71 166.78,34.71 168.28,36.21 173.09,36.21 174.61,37.73 180.76,37.73 181.52,38.49 187.85,38.49 189.14,39.79 193.53,39.79 193.94,40.2 203.12,40.2 204.47,41.54 206.37,41.54 211.29,46.46 211.29,47.51 214.57,50.79 220.67,50.79 221.34,51.46 223.51,51.46 226.41,54.37 226.41,57.43 228.61,59.63 234.97,59.63 235.37,60.03 242.24,60.03 v2(242.67,59.6)
  BOTTOM w0.102: v2(242.67,59.6) 241.71,60.57 241.71,61.53 242.26,62.09 242.26,62.37 241.48,63.16 U46.A18
USH_PWR_STATE#: length 157.3
  TOP w0.102: v2(120.52,36.39) 120.52,34.74 123.29,31.97 123.29,30.24 121.82,28.77 120.29,28.77 119.74,29.32 JUSH1.16
  IN3 w0.127: v2(230.99,57.44) 230.24,56.69 230.24,54.58 226.95,51.3 226.95,50.84 225.42,49.31 217.43,49.31 207.4,39.28 205.03,39.28 204.47,38.72 194.55,38.72 194.04,38.21 192.51,38.21 189.84,35.55 179.58,35.55 178.54,34.51 168.72,34.51 167.37,33.15 156.18,33.15 155.22,34.1 146.5,34.1 143.45,37.15 121.28,37.15 v2(120.52,36.39)
  BOTTOM w0.102: v2(230.99,57.44) 227.91,57.44 227.43,57.93 227.43,62.19 226.13,63.49 226.13,64.53 v1(226.14,64.54) 227.2,65.6 227.2,66.4 227.87,67.07 230.1,67.07 230.3,66.87 R102.2 230.96,66.61 231.42,66.16 U46.A34
USH_SMBCLK: length 148.6
  TOP w0.102: v2(113.43,34.96) 113.41,34.99 R589.2 113.26,34.55 114.1,34.55 114.37,34.82 JUSH1.5
  IN3 w0.127: v2(113.43,34.96) 113.17,34.7 112.99,34.7 112.9,34.78 112.9,35.19 113.28,35.57 116.19,35.57 118.04,33.73 123.28,33.73 123.93,34.38 142.48,34.38 145.23,31.62 154.42,31.62 156.41,29.63 177.8,29.63 180.49,32.32 194.01,32.32 197.78,36.09 209.21,36.09 209.45,36.34 218.78,36.34 222.19,39.74 223.87,39.74 225.84,41.71 232.07,41.71 233.55,43.19 236.68,43.19 238.76,41.11 245.41,41.11 v2(246.53,39.99)
  BOTTOM w0.102: U51.A50 246.3,40.22 v2(246.53,39.99)
USH_SMBDAT: length 152.1
  TOP w0.102: JUSH1.6 113.04,34.32 R585.2 113.06,33.87 v2(113.46,33.87)
  IN3 w0.127: v2(246.38,42.27) 245.47,41.36 238.86,41.36 236.78,43.45 233.45,43.45 231.96,41.96 225.74,41.96 223.77,39.99 222.08,39.99 218.68,36.59 209.35,36.59 209.11,36.35 197.67,36.35 193.9,32.58 180.39,32.58 177.69,29.88 156.51,29.88 154.52,31.88 145.34,31.88 142.58,34.63 123.82,34.63 123.17,33.99 118.14,33.99 116.3,35.83 113.18,35.83 112.65,35.3 112.65,34.68 v2(113.46,33.87)
  BOTTOM w0.102: v2(246.38,42.27) 246.55,42.1 U51.B53
VCI_IN3#: length 4.8
  BOTTOM w0.102: R880.2 236.05,39.83 236.97,39.83 237.02,39.78 v1(237.44,39.78) 237.62,39.96 237.62,40.14 238.42,40.93 238.42,40.93 U51.B68
VCORE_VDDP: length 7.8
  TOP w0.203: 158.11,165.32 156.95,166.48 PU500.23
  TOP w0.508: PR523.1 158.91,164.28 PR520.1 v2(158.85,164.96) 158.47,164.96 158.11,165.32
  BOTTOM w0.508: 157.86,166.82 157.71,166.82 157.45,166.56 157.45,165.88 v1(158.05,165.28) 158.37,164.96 v2(158.85,164.96)
VCP2: length 2.6
  BOTTOM w0.102: R131.2 39.32,90.74 v1(38.57,91.49) 38.28,91.78 U29.31
VCP_4021: length 2.5
  BOTTOM w0.254: U29.25 37.74,94.78 v1(38.53,95.57) R431.1
VCT_LAN_R1: length 7.6
  TOP w0.102: v1(121.13,91.47) 120,91.47 R558.1 118.67,90.13 117.52,90.13 117.04,90.62 R553.2 116.13,91.48 115.39,91.48 115.18,91.69 U31.6
VGA_ID: length 9.7
  TOP w0.102: v2(237.87,78.91) 237.87,76.53 237.74,76.41 237.74,75.98 237.56,75.8 237.56,74.28 237.79,74.05 237.79,73.16 237.82,73.14 237.82,73.13 v2(238.2,72.75)
  BOTTOM w0.102: v2(238.2,72.75) 237.73,73.22 U46.B59 ; v2(237.87,78.91) 237.72,79.06 R800.2 R803.1
VIDALERT_N: length 88.1
  TOP w0.102: v3(162.25,171.64) 162.43,171.64 v1(162.98,171.09)
  TOP w0.254: RC61.2 RC60.2 200.68,137.83 v2(200.73,137.88) ; PR506.1 162.25,171.64 v3(162.25,171.64)
  IN4 w0.254: v3(162.25,171.64) 163.04,172.43 163.04,173.67 164.57,175.2 204.47,175.2 206.4,173.27 206.4,150.61 202.41,146.62 202.41,144.46 200.73,142.79 v2(200.73,137.88)
VIDSCLK: length 98.7
  TOP w0.254: JCPU1.AM29 192.59,132.78 v2(193.06,132.31) ; PR508.1 162.25,172.53 v3(162.25,172.53)
  IN4 w0.254: v3(162.25,172.53) 162.28,172.53 162.53,172.79 162.53,173.93 164.31,175.71 204.72,175.71 206.91,173.52 206.91,150.36 203.43,146.88 203.43,144.21 202.16,142.94 202.16,137.5 201.47,136.82 201.47,135.88 200.19,134.6 199.8,134.6 198.01,132.8 193.55,132.8 v2(193.06,132.31)
VIDSOUT: length 100.3
  TOP w0.102: v1(202.47,134.75) 201.38,134.75 RC63.2
  TOP w0.254: JCPU1.AL28 v2(192.06,132.31) ; v2(200,135.45) RC63.2 ; v3(162.25,170.75) 162.25,170.75 PR505.1
  IN4 w0.254: v2(192.06,132.31) 192.06,132.51 193.37,133.82 197.87,133.82 199.5,135.45 v2(200,135.45) 199.87,135.57 199.87,144.21 201.52,145.86 201.52,146.5 205.89,150.86 205.89,173.01 204.21,174.69 164.82,174.69 163.55,173.42 163.55,172.02 162.28,170.75 v3(162.25,170.75)
VLDOIN_1.35V: length 1.9
  BOTTOM w0.102: PJP201.2 146.21,25.43 v1(146.12,25.51)
VOL_DOWN: length 269.6
  TOP w0.102: JIO1.95 15.05,74.7 15.75,75.4 15.75,76.3 17.22,77.78 17.22,78.12 v2(17.58,78.47)
  IN4 w0.109: v2(17.58,78.47) 17.24,78.14 17.24,76.34 20.6,72.99 22.63,72.99 23.57,72.04 25.1,72.04 25.73,72.67 40.78,72.67 44.56,68.89 45.62,68.89 49.47,65.04 49.47,57.29 53.28,53.48 53.28,52.37 56.23,49.42 56.97,49.42 61.75,44.64 61.75,44.13 62.54,43.34 75.99,43.34 76.32,43.01 82.33,43.01 82.9,42.44 98.88,42.44 99.52,41.81 102.47,41.81 103.72,40.55 119.67,40.55 121.98,38.25 172.99,38.25 174.85,40.11 174.89,40.11 174.9,40.11 177.2,40.11 177.69,39.63 188.46,39.63 189.84,41.01 197.2,41.01 200.01,43.82 208.65,43.82 208.94,43.54 219.95,43.54 221.29,42.2 223.52,42.2 225.73,39.99 226.24,39.99 230.21,36.02 233.91,36.02 236.26,33.66 240.53,33.66 242.16,35.29 v2(244.56,35.29)
  BOTTOM w0.102: R1197.2 R887.2 245.07,34.79 v2(244.56,35.29) ; v1(19.62,79.91) 18.98,79.27 18.96,79.27 18.29,78.6 17.7,78.6 v2(17.58,78.47)
VOL_DOWN_R: length 10.7
  TOP w0.102: v2(243.99,42.81) 244.4,42.41 244.4,42.1 245.52,40.98 245.52,37.55 246.1,36.97 v2(246.1,36.31)
  BOTTOM w0.102: v1(244.68,35.84) 244.82,35.7 R887.1 246.1,36.08 v2(246.1,36.31) ; U51.B57 244.55,42.25 v2(243.99,42.81)
VOL_MUTE: length 277.2
  TOP w0.102: JIO1.97 15.08,74.1 16.01,75.03 16.01,76.23 v2(17.65,77.86)
  IN3 w0.127: v2(226.92,41.11) 227.29,41.48 232.16,41.48 232.73,42.05 233.96,42.05 234.14,41.87 237.34,41.87 238.33,40.88 244.55,40.88 245.34,40.09 245.34,39.71 245.74,39.31 249.15,39.31 249.53,38.93 v2(249.53,38.88)
  IN4 w0.109: v2(17.65,77.86) 18.25,77.27 28.24,77.27 30.69,79.72 35.3,79.72 37.46,77.56 37.46,76.14 40.25,73.36 40.99,73.36 44.82,69.53 45.88,69.53 50.12,65.28 50.12,57.53 53.91,53.74 53.91,52.68 56.46,50.13 57.21,50.13 62.23,45.11 62.75,45.11 63.64,44.22 67.36,44.22 68.16,45.02 72.05,45.02 72.85,44.22 76.3,44.22 76.48,44.03 79.1,44.03 79.56,44.5 82.2,44.5 83.41,43.29 103.35,43.29 105.21,41.43 119.99,41.43 122.33,39.09 170.78,39.09 172.67,40.98 177.63,40.98 177.96,41.31 188.79,41.31 189.38,41.9 196.88,41.9 199.67,44.68 204.45,44.68 205.29,45.52 208.14,45.52 209.28,44.38 220.3,44.38 221.16,43.52 224.51,43.52 v2(226.92,41.11)
  BOTTOM w0.102: R884.2 231.95,41.42 230.5,39.97 227.68,39.97 226.92,40.73 v2(226.92,41.11) ; R1986.2 v2(249.53,38.88) ; v1(18.24,78.25) 17.85,77.86 v2(17.65,77.86)
VOL_UP: length 267.8
  TOP w0.102: v2(16.79,77.97) 15.38,76.56 15.38,75.59 15.09,75.3 JIO1.93
  IN4 w0.109: v2(16.79,77.97) 16.79,76.34 20.39,72.73 22.58,72.73 23.48,71.83 25.19,71.83 25.81,72.46 40.69,72.46 44.47,68.68 45.53,68.68 49.25,64.96 49.25,57.21 53.07,53.39 53.07,52.25 56.13,49.19 56.9,49.19 61.43,44.66 61.43,44.15 62.45,43.13 75.9,43.13 76.23,42.8 82.25,42.8 82.86,42.18 98.64,42.18 99.26,41.56 102.38,41.56 103.64,40.3 119.63,40.3 121.89,38.04 173.07,38.04 174.94,39.9 177.05,39.9 177.57,39.38 188.51,39.38 189.92,40.8 197.45,40.8 200.26,43.61 208.47,43.61 208.75,43.33 219.87,43.33 221.46,41.73 222.67,41.73 225.43,38.97 226.88,38.97 230.75,35.1 234.5,35.1 236.16,33.45 240.64,33.45 241.9,34.71 v2(244.55,34.71)
  BOTTOM w0.102: R1984.2 247.57,34.86 R1118.2 246.84,34.13 v1(244.78,34.13) 244.55,34.35 v2(244.55,34.71)
VR_HOT#: length 2.7
  TOP w0.203: PU500.5 155.75,171.87
  TOP w0.254: PR524.2 v1(155.67,172.61) 155.67,172.33 155.75,172.25 155.75,171.87
VR_ON: length 4.7
  TOP w0.203: PU500.2 156.95,171.6
  TOP w0.254: 156.95,171.6 156.95,171.65 157.63,172.33 v1(158.24,172.33) 158.29,172.33 159.36,173.39 PR513.2 160.22,173.44 PR517.2
VSB_N_001: length 8.8
  TOP w0.102: v1(43.89,82.61) 43.33,82.05 PQ4.2 41.94,82.8 41.65,83.08 41.65,83.53 41.87,83.74 PC7.2 41.87,85.09 41.53,85.43 PR17.2 PR15.2
VSB_N_002: length 5.1
  TOP w0.102: PQ7.2 42.63,85.9 PC16.1 42.92,85.02 PR21.2 43.84,84.98 PR23.2 43.9,85.74 v1(44.36,86.21)
VSB_N_003: length 2.8
  TOP w0.102: PQ7.1 39.29,86.55 39.05,86.79 v1(38.66,86.79) 38.31,86.45 38.31,85.69 PR17.1
VSET_4021: length 3.4
  BOTTOM w0.254: R424.1 C319.1 38.86,92.52 v1(38.56,92.82) 38.1,93.28 U29.28
VSET_5075: length 5.4
  BOTTOM w0.102: U51.A17 239.13,51.45 238.33,51.45 v1(236.75,53.03) 236.45,53.33 C320.1 R425.1
VSYNC: length 3.1
  TOP w0.102: v2(86.87,64.33) 86.87,64.61 87.7,65.44 RH95.2
  BOTTOM w0.102: v2(86.87,64.33) 86.77,64.43 86.33,64.43 85.99,64.08 UH1.N44
VSYNC_BUF: length 72.9
  TOP w0.102: v2(87.46,160.8) 87.5,160.8 87.9,161.19 87.9,162.11 v1(89.73,163.94) L5.1
  IN4 w0.109: v2(87.46,160.8) 89.48,158.78 89.48,157.89 90.32,157.04 92.46,157.04 94.19,155.31 94.19,145.56 92.56,143.92 92.56,140.42 94.19,138.79 94.19,137.52 101.95,129.76 101.95,121.58 101.14,120.77 101.14,113.23 101.69,112.68 101.69,109.69 100.68,108.69 100.68,106.08 v2(99.67,105.07)
  BOTTOM w0.102: U19.36 99.11,105.34 99.11,105.33 99.35,105.09 99.64,105.09 v2(99.67,105.07)
VSYNC_DOCK: length 12.7
  TOP w0.102: v2(99.21,117.39) 99,117.39 v1(98.63,117.77)
  IN3 w0.127: v2(96.85,109.54) 96.85,113.7 98.14,115 98.14,116.24 98.45,116.55 98.45,116.7 99.14,117.39 v2(99.21,117.39)
  BOTTOM w0.102: v2(99.21,117.39) 99.24,117.42 JDOCK1.67 ; U19.27 96.31,108.52 96.42,108.62 96.42,109.11 v2(96.85,109.54)
VSYNC_L: length 10.5
  TOP w0.102: JCRT1.14 87.66,172.32 88.54,171.44 C18.1 R50.2 88.54,165.75 L5.2 88.88,164.74 v1(88.35,164.21)
WIGIG60GHZ_DIS#: length 196.3
  TOP w0.102: v2(126.62,153.3) 127.02,153.71 127.61,153.71 128.14,153.18 128.14,152.58 128.57,152.15 128.57,150.48 129.16,149.9 130.57,149.9 131.82,148.65 131.82,144.57 132.99,143.41 132.99,130.54 132,129.55 132,128.24 130.9,127.14 v2(130.58,127.14) ; v2(245.79,76.47) 245.79,78.22 244.72,79.3 244.72,80.34 241.73,83.33 227.61,83.33 224.18,86.75 219.28,86.75 217.85,85.33 210.41,85.33 v1(208.18,87.57) v2(207.47,88.28)
  BOTTOM w0.102: R695.1 125.82,156.32 D35.1 126.97,153.66 v2(126.62,153.3) ; U46.A1 245.21,74.69 245.21,75.88 v2(245.79,76.47) ; v2(130.58,127.14) 130.17,126.73 130.17,124.98 130.96,124.19 130.96,117.87 132.21,116.62 132.21,108.81 136.2,104.81 140.49,104.81 145.96,110.29 152.71,110.29 157.28,105.73 157.28,101.14 161.53,96.89 188.49,96.89 191.11,94.27 196.65,94.27 202.64,88.28 v2(207.47,88.28)
WIGIG60GHZ_DIS#_R: length 8.2
  BOTTOM w0.102: JMINI2.32 126.29,157.83 R695.2 ; D35.2 126.84,157.24 R695.2 ; v1(126.62,154.08) 126.62,154.55 R725.1 125.58,155.46 125.12,155.92 125.12,156.66 R695.2
WIGIG_LED#: length 31.6
  TOP w0.102: v2(127.25,161.96) 127.18,162.04 127.18,163.18 v1(126.78,163.58) 125.47,164.88 125.47,166.38 125.79,166.7 Q124.4 126.9,166.72 R705.1
  IN3 w0.127: v2(127.25,161.96) 127.07,161.96 126.54,161.43 126.54,157.85 125.73,157.04 120.46,157.04 119.73,157.76 117.79,157.76 117.7,157.67 115.09,157.67 v2(114.65,158.1)
  BOTTOM w0.102: JMINI2.42 130.29,160.6 128.81,162.08 127.37,162.08 v2(127.25,161.96) ; v2(114.65,158.1) 114.71,158.05 114.71,157.39 115.54,156.55 R706.1
WIRELESS_LED#: length 269
  TOP w0.102: v2(132.08,164.2) v1(132.08,165.15) 132.08,165.88 Q78.3 131.58,167.12 R937.2 129.35,166.7 Q124.3 127.51,165.4 Q124.6 ; v2(259.03,44.74) 259.05,44.74 261.26,46.95 261.26,70.7 v2(260.78,71.18)
  IN1 w0.109: v2(232.08,73.44) 232.08,72.84 234.12,70.79 235.52,70.79 235.76,71.03 240.52,71.03 241.04,71.55 241.75,71.55 241.76,71.54 242.68,71.54 243.22,72.07 244.87,72.07 245.25,71.69 246.81,71.69 247.21,72.09 248.49,72.09 249.17,71.41 260.55,71.41 v2(260.78,71.18)
  IN4 w0.109: v2(132.08,164.2) 132.71,163.56 132.71,157.44 130.4,155.13 130.4,152.51 128.4,150.51 127.39,150.51 124.71,147.83 124.71,143.01 125.65,142.07 125.9,142.07 126.78,141.2 126.78,137.68 128.17,136.29 128.17,129.84 128.08,129.76 128.08,117.35 124.42,113.68 121.69,113.68 120.69,112.68 120.69,107.07 122.83,104.94 133.36,104.94 133.39,104.92 135.16,104.92 145.45,94.63 186.15,94.63 205.75,75.03 207.83,75.03 210.26,72.6 215.46,72.6 217.54,70.51 217.54,69.9 219.61,67.84 219.73,67.71 226.46,67.71 227.27,68.52 227.27,69.19 227.85,69.77 228.92,69.77 232.08,72.93 v2(232.08,73.44)
  BOTTOM w0.102: U46.A47 232.31,72.66 232,72.96 232,73.37 v2(232.08,73.44) ; Q77.1 258.29,44.34 258.7,44.74 v2(259.03,44.74)
WIRELESS_ON#/OFF: length 93.2
  TOP w0.102: v2(247.71,68.12) 247.75,68.09 247.75,67.48 250.32,64.91 250.32,57.85 250.72,57.45 250.72,55.94 251.2,55.45 251.2,51.41 252.45,50.16 252.45,48.58 253.19,47.84 253.19,44.95 252.8,44.56 v2(252.8,44.62) ; JWL1.3 281.62,17.78 270.41,28.99 270.41,33.29 270.92,33.8 v2(270.92,34.61)
  IN1 w0.109: v2(241.49,66.92) 241.94,67.37 243.1,67.37 244.22,68.49 245.85,68.49 246.21,68.12 v2(247.71,68.12)
  IN3 w0.127: v2(252.8,44.62) 252.86,44.56 253.49,44.56 254.3,43.75 256.72,43.75 258.22,42.24 258.22,40.19 262.13,36.28 267.56,36.28 269.65,34.2 270.51,34.2 v2(270.92,34.61)
  BOTTOM w0.102: v1(270.04,35.24) 270.67,34.61 v2(270.92,34.61) ; RP2.6 248.24,68.65 v2(247.71,68.12) ; U46.B13 242.42,67.41 242.39,67.37 241.94,67.37 v2(241.49,66.92)
WLAN_LAN_DISB#: length 193.3
  TOP w0.102: U15.4 104.26,95.71 104.11,95.86 v2(104.11,96.25)
  IN1 w0.109: v2(104.11,96.25) 104.11,95.49 103.43,94.81 103.43,92.55 104.66,91.32 104.66,87.45 105.41,86.7 105.41,84.71 119.57,70.55 122.32,70.55 123.25,69.62 123.25,66.98 125.77,64.45 141.81,64.45 141.96,64.3 146,64.3 146.89,63.41 149.71,63.41 151.56,61.57 154.26,61.57 154.73,61.1 169.93,61.1 171.94,63.11 179.96,63.11 180.47,62.6 186.28,62.6 187.7,64.01 196.79,64.01 199.02,66.24 210.85,66.24 211.61,66.99 215.14,66.99 218.41,70.27 229.36,70.27 229.64,69.99 231.22,69.99 231.22,69.99 233.17,69.99 233.35,69.81 235.1,69.81 235.99,70.7 242.44,70.7 243.58,71.84 244.8,71.84 245.16,71.48 246.9,71.48 247.3,71.88 248.38,71.88 249.18,71.08 251.79,71.08 v2(252.07,70.8)
  BOTTOM w0.102: U46.A64 242.42,74.86 242.53,74.74 243.42,74.74 243.97,75.28 243.97,76.28 244.79,77.1 248.08,77.1 249.69,75.49 v1(249.69,74.82) 249.69,72.95 251.56,71.08 251.79,71.08 v2(252.07,70.8)
WLAN_LED: length 241.1
  TOP w0.102: v2(77.43,91.16) 77.82,90.77 83.49,90.77 91.31,82.94 92.48,82.94 93.09,83.55 97.99,83.55 98.22,83.33 100.14,83.33 100.75,82.72 113.59,82.72 115.39,84.52 125.35,84.52 126.32,85.48 127.96,85.48 135.47,93 135.47,115.94 134.21,117.2 134.21,143.18 134.64,143.61 v1(134.64,150.8) 132.1,153.34 132.1,159.7 131.72,160.08 131.72,162.45 133.04,163.78 133.04,167.4 134.67,169.02 R939.2 ; v2(24.69,77.71) 24.69,76.01 24.26,75.58 20.39,75.58 20.12,75.3 JIO1.94
  IN1 w0.109: v2(24.69,77.71) 24.69,77.9 19.46,83.14 19.46,99.91 20.7,101.16 46.79,101.16 47.57,100.37 68.86,100.37 77.32,91.91 77.32,91.28 v2(77.43,91.16)
WLAN_LED#: length 7.1
  TOP w0.102: v2(130.33,162.62) 129.77,163.18 v1(129.77,163.64) R718.1 128.87,165.34 Q124.1
  BOTTOM w0.102: JMINI2.44 131.09,161.86 v2(130.33,162.62)
WLAN_RADIO_DIS#: length 181.5
  TOP w0.102: v2(120.65,153.35) 120.88,153.12 120.88,140.96 122.78,139.05 123.49,139.05 125.78,136.77 127.76,136.77 130.4,134.13 130.4,129.92 129.13,128.65 v1(129.13,125.04) 129.13,124.24 v2(130.43,122.95) ; v2(210.95,82.13) 211.99,81.09 211.99,76.48 211.12,75.62 211.12,74.03 211.84,73.32 212.34,73.32 212.77,73.75 215.59,73.75 217.04,72.3 223.3,72.3 225.3,74.31 230.07,74.31 230.2,74.18 232.21,74.18 v2(232.54,73.85)
  BOTTOM w0.102: v2(120.65,153.35) 120.65,154.39 D31.1 119.99,155.05 R697.1 ; v2(130.43,122.95) 130.4,122.95 129.82,122.37 129.82,116.03 131.75,114.1 131.75,107.61 139.57,99.78 145.76,99.78 147.13,98.41 154.62,98.41 156.65,96.38 188.18,96.38 192.17,92.39 195.42,92.39 200.75,87.06 208.15,87.06 210.74,84.47 210.74,82.33 v2(210.95,82.13) ; v2(232.54,73.85) 232.48,73.8 232.48,73.39 232.72,73.16 U46.A48
WLAN_RADIO_DIS#_R: length 7.8
  BOTTOM w0.102: R728.1 118.73,157.25 D31.2 121.25,157.25 ; v1(122.2,155.52) 122.2,156.81 121.77,157.24 R697.2 121.25,157.25 ; 121.25,157.25 121,157.49 121,158.2 121.49,158.69 JMINI2.20
WWAN_RADIO_DIS#: length 56.4
  TOP w0.102: v2(236.19,75.6) 235.99,75.6 235.63,75.96 235.63,76.7 235.23,77.1 233.4,77.1 v2(232.84,76.54)
  IN1 w0.109: v2(236.19,75.6) 236.22,75.6 236.83,74.99 238.63,74.99 239.17,74.45 246.42,74.45 246.71,74.16 248.51,74.16 250.46,72.21 261.46,72.21 v2(261.52,72.15)
  BOTTOM w0.102: JMINI1.20 262.49,54.2 262.86,54.57 262.86,55.49 262.08,56.27 262.08,57.29 262.56,57.77 263.17,57.77 264.26,58.87 264.26,62.37 263.35,63.28 263.35,66.15 261.52,67.98 v1(261.52,71.06) v2(261.52,72.15) ; U46.A53 236.48,75.42 236.29,75.6 v2(236.19,75.6) ; v2(232.84,76.54) 232.05,76.54 231.25,75.74 RP1.5
XDP_DBRESET#: length 353
  TOP w0.102: v2(206.83,124.47) 206.86,124.44 JXDP1.9
  IN1 w0.109: v2(206.83,124.47) 208.05,125.69 208.05,128.61 209.09,129.65 209.09,131.23 207.85,132.47 207.85,135.94 200.28,143.51 200.28,146.7 202.49,148.91 v2(202.67,148.91)
  IN3 w0.127: v2(54.35,85.76) 54.71,85.76 55.37,86.42 58.39,86.42 59.66,85.15 61.14,85.15 62.71,83.58 64.16,83.58 v2(64.9,82.84)
  IN4 w0.109: v2(220.95,87.36) 220.55,87.77 220.55,93.94 215.84,98.65 215.84,100.55 210.68,105.7 210.68,111.94 207.3,115.32 207.3,116.67 205.29,118.68 205.29,119.99 206.83,121.53 v2(206.83,124.47) ; v2(216.51,46.29) 209.9,46.29 208.76,47.44 199.19,47.44 195.83,44.07 185.55,44.07 184.72,43.25 176.98,43.25 176.63,42.9 167.08,42.9 165.96,41.78 122.4,41.78 120.77,43.41 112.27,43.41 110.32,45.37 86.55,45.37 84.29,47.63 65.63,47.63 64.3,48.95 62.41,48.95 58.06,53.3 58.06,54.66 56.27,56.45 55.5,56.45 53.97,57.98 53.97,62.69 54.66,63.38 54.66,68.06 55.9,69.3 55.9,71.17 55.28,71.79 54.01,71.79 53.1,72.7 53.1,84.51 v2(54.35,85.76)
  BOTTOM w0.102: RC26.1 v2(202.67,148.91) ; JXDP2.48 50.44,86.45 50.62,86.63 53.49,86.63 v2(54.35,85.76) ; v2(216.51,46.29) 215.31,47.49 215.31,56.01 216.58,57.28 216.58,64.41 220.72,68.55 220.72,69.92 214.68,75.97 214.68,81.67 v1(216.15,83.14) 216.81,83.81 217.35,83.81 220.9,87.36 v2(220.95,87.36) ; UC3.1 65.99,84.92 65.61,84.54 65.61,83.27 65.23,82.89 64.95,82.89 v2(64.9,82.84) 64.57,83.17 63.02,83.17 62.56,83.63 RH66.1
XDP_DBRESET#_R: length 16.6
  TOP w0.102: JCPU1.AP33 v2(195.06,137.31)
  BOTTOM w0.102: v2(195.06,137.31) 195.07,137.31 195.63,137.87 195.63,138.47 196.14,138.97 v1(196.14,140.48) 196.14,140.88 202.39,147.13 202.49,147.13 RC26.2 203.17,147.82 203.17,149.04 202.67,149.54 RC19.2
XDP_FN0: length 2.6
  BOTTOM w0.102: RH3.2 41.5,76.95 JXDP2.9
XDP_FN1: length 2.5
  BOTTOM w0.102: JXDP2.11 41.29,77.45 RH4.2
XDP_FN2: length 2.4
  BOTTOM w0.102: JXDP2.15 41.22,78.45 RH6.2
XDP_FN3: length 2.6
  BOTTOM w0.102: RH7.2 41.56,78.95 JXDP2.17
XDP_FN4: length 2.9
  BOTTOM w0.102: JXDP2.27 42.44,81.45 RH8.2
XDP_FN5: length 2.8
  BOTTOM w0.102: RH9.2 42.05,81.95 JXDP2.29
XDP_FN6: length 2.8
  BOTTOM w0.102: RH17.2 41.65,81.98 42.62,82.95 JXDP2.33
XDP_FN7: length 3
  BOTTOM w0.102: RH10.2 41.68,83.35 41.68,83.53 41.86,83.71 42.39,83.71 42.65,83.45 JXDP2.35
XDP_FN8: length 5.4
  BOTTOM w0.102: JXDP2.10 52.39,76.95 RH11.2 52.93,76.57 v1(54.49,76.57)
XDP_FN9: length 3.3
  BOTTOM w0.102: JXDP2.12 v1(51.27,77.45) 52.01,77.45 RH13.2
XDP_FN10: length 12.4
  TOP w0.102: v2(51.48,78.52) v1(51.48,77.46) 51.48,76.24 v2(51.46,76.21)
  BOTTOM w0.102: RH12.2 58.28,77.15 57.34,76.21 v2(51.46,76.21) ; JXDP2.16 50.34,78.45 50.64,78.74 51.27,78.74 v2(51.48,78.52)
XDP_FN11: length 3.3
  BOTTOM w0.102: RH14.2 52.3,79.11 v1(51.55,79.11) 51.04,79.11 50.88,78.95 JXDP2.18
XDP_FN12: length 3.2
  BOTTOM w0.102: RH16.2 52.4,81.39 v1(51.45,81.39) 51.08,81.39 51.03,81.45 JXDP2.28
XDP_FN13: length 16.6
  TOP w0.102: v2(54.28,74.31) 54.28,74.82 52.6,76.5 52.6,79.64 52.37,79.87 52.37,81.27 v1(52.2,81.45) v2(51.81,81.83)
  BOTTOM w0.102: RH19.2 58.3,73.34 57.82,72.86 56.12,72.86 55.39,73.6 54.99,73.6 v2(54.28,74.31) ; v2(51.81,81.83) 51.7,81.95 JXDP2.30
XDP_FN14: length 17.8
  TOP w0.102: RH20.2 59.03,72.76 58.42,72.76 v1(57.94,73.24) 57.28,73.9 55.78,73.9 53.06,76.62 53.06,79.8 52.83,80.02 52.83,82.82 v2(52.65,83)
  BOTTOM w0.102: v2(52.65,83) 52.37,82.72 50.77,82.72 50.54,82.95 JXDP2.34
XDP_FN15: length 18.9
  TOP w0.102: RH22.2 59.1,73.62 57.94,73.62 57.45,74.11 55.86,74.11 53.29,76.68 53.29,79.85 53.06,80.08 53.06,83.27 v1(52.72,83.62) 52.63,83.71 v2(52.63,84.19)
  BOTTOM w0.102: JXDP2.36 50.4,83.45 50.93,82.92 51.36,82.92 v2(52.63,84.19)
XDP_FN16: length 16.3
  TOP w0.102: RH24.2 58.8,65.62 58.22,65.62 57.94,65.9 56.54,65.9 56.11,66.33 56.11,67.12 55.8,67.42 55.32,67.42 v1(54.04,68.7) 53.08,69.66 53.08,72.05 52.09,73.04 v2(52.09,73.39)
  BOTTOM w0.102: JXDP2.4 50.42,75.45 50.72,75.15 50.72,74.56 51.89,73.39 v2(52.09,73.39)
XDP_FN17: length 8.8
  BOTTOM w0.102: RH25.2 56.92,75.63 53.59,75.63 v1(52.96,74.99) 51.69,74.99 51.21,75.48 50.93,75.48 50.46,75.95 JXDP2.6
XDP_HOOK2: length 3.9
  TOP w0.102: v1(204.61,120.12) 205.14,120.12 RC21.2 206.47,121.44 JXDP1.15
XDP_OBS0_R: length 25.5
  TOP w0.102: v2(196.06,134.31) JCPU1.AR30
  BOTTOM w0.089: v2(196.06,134.31) 196.44,134.31 196.57,134.18 196.57,133.06 196.7,132.93 197.84,132.93
  BOTTOM w0.102: T167.1 203.05,123.17 202.52,123.17 202.42,123.07 202.42,122.82 202.32,122.72 202.14,122.72 202.04,122.82 202.04,123.07 201.94,123.17 201.73,123.17 201.63,123.07 201.63,122.44 201.51,122.31 201.27,122.31 201.14,122.44 201.14,123.5 201.27,123.63 202.39,123.63 202.51,123.75 202.51,123.92 202.39,124.03 201.23,124.03 201.12,124.15 201.12,124.32 201.23,124.44 202.42,124.44 202.55,124.57 202.55,124.77 202.42,124.89 201.2,124.89 201.07,125.02 201.07,130.68 200.48,131.27 200.48,132.65 200.19,132.93 197.84,132.93
XDP_OBS1_R: length 25.9
  TOP w0.102: v2(194.06,135.31) JCPU1.AN31
  BOTTOM w0.102: T168.1 205.45,147.16 205.53,147.08 205.53,146.16 205.38,146.01 203.98,146.01 203.05,145.08 203.05,143.75 198.3,139 198.3,137.8 198.4,137.69 199.68,137.69 199.78,137.59 199.78,137.39 199.68,137.29 198.4,137.29 198.3,137.19 198.3,136.98 198.4,136.88 199.67,136.88 199.77,136.78 199.77,136.58 199.67,136.47 198.4,136.47 198.3,136.37 198.3,136.27 197.72,135.69 194.44,135.69 v2(194.06,135.31)
XDP_OBS2_R: length 25.6
  TOP w0.102: v2(194.06,133.31) JCPU1.AN29
  BOTTOM w0.089: v2(194.06,133.31) 194.65,132.72 195.28,132.72 195.49,132.51 195.49,132.31 195.7,132.11
  BOTTOM w0.102: 195.7,132.11 195.87,131.93 197.92,131.93 198.11,131.74 198.11,131.29 198.21,131.19 198.7,131.19 198.8,131.29 198.8,131.74 198.9,131.84 199.05,131.84 200.45,130.44 200.45,119.91 200.58,119.78 202.73,119.78 202.86,119.91 202.86,120.96 202.98,121.08 204.09,121.08 T169.1
XDP_OBS3_R: length 25.7
  TOP w0.102: v2(195.06,135.31) JCPU1.AP31
  BOTTOM w0.089: 197.84,134.94 196.82,134.94 196.8,134.91 195.46,134.91 v2(195.06,135.31)
  BOTTOM w0.102: T170.1 202.74,127.52 202.74,128.2 202.96,128.41 202.96,128.56 202.81,128.7 202.67,128.7 202.45,128.49 202.31,128.49 201.89,128.9 201.89,129.02 202,129.13 203.2,129.13 203.3,129.23 203.3,129.43 203.2,129.53 202,129.53 201.89,129.63 201.89,129.84 202,129.94 203.2,129.94 203.3,130.04 203.3,130.24 203.2,130.35 202,130.35 201.89,130.45 201.89,130.76 201.4,131.25 201.4,132.84 200.17,134.07 200.17,134.93 200.07,135.03 199.86,135.03 199.76,134.93 199.76,134.02 199.66,133.92 199.46,133.92 199.36,134.02 199.36,135.22 199.25,135.32 199.05,135.32 198.95,135.22 198.95,134.04 198.85,133.94 198.64,133.94 198.54,134.04 198.54,135.22 198.44,135.32 198.23,135.32 198.13,135.22 198.13,135.04 198.03,134.94 197.84,134.94
XDP_OBS4_R: length 26.3
  TOP w0.102: v2(195.06,134.31) JCPU1.AP30
  BOTTOM w0.089: 197.99,132.7 196.64,132.7 196.45,132.89 195.74,132.89 195.55,133.08 195.55,133.82 v2(195.06,134.31)
  BOTTOM w0.102: T173.1 204.25,122.5 202.26,122.5 201.95,122.19 201.95,120.3 201.85,120.19 201,120.19 200.87,120.32 200.87,120.51 201,120.64 201.44,120.64 201.54,120.74 201.54,120.96 201.41,121.08 201,121.08 200.87,121.21 200.87,130.6 199.87,131.59 199.87,131.99 199.63,132.23 199.63,132.56 199.49,132.7 197.99,132.7
XDP_OBS5_R: length 26.1
  TOP w0.102: v2(194.06,132.31) JCPU1.AN28
  BOTTOM w0.102: T174.1 204.66,119.49 204.53,119.37 201.9,119.37 201.77,119.24 201.77,118.48 201.65,118.35 200.17,118.35 200.04,118.48 200.04,130.27 199.95,130.37 196.92,130.37 196.57,130.72 194.97,130.72 194.56,131.13 194.56,131.81 v2(194.06,132.31)
XDP_OBS6_R: length 25.6
  TOP w0.102: v2(195.06,133.31) JCPU1.AP29
  BOTTOM w0.089: 197.98,132.47 196.6,132.47 196.37,132.7 195.66,132.7 v2(195.06,133.31)
  BOTTOM w0.102: 197.98,132.47 199.06,132.47 199.66,131.87 199.66,131.51 200.67,130.51 200.67,120.11 200.79,119.99 202.53,119.99 202.65,120.11 202.65,120.41 202.53,120.54 202.28,120.54 202.15,120.66 202.15,120.98 202.28,121.11 202.56,121.11 202.69,121.23 202.69,121.46 202.56,121.59 202.28,121.59 202.15,121.72 202.15,122.1 202.28,122.23 203.47,122.23 203.59,122.1 203.59,121.76 203.47,121.63 T171.1
XDP_OBS7_R: length 26.1
  TOP w0.102: v2(195.06,132.31) JCPU1.AP28
  BOTTOM w0.102: T172.1 203.69,120.27 203.82,120.14 203.82,119.71 203.69,119.58 200.85,119.58 200.72,119.45 200.72,119.19 200.85,119.06 201.44,119.06 201.57,118.94 201.57,118.68 201.44,118.56 200.37,118.56 200.25,118.68 200.25,130.36 199.68,130.92 197.66,130.92 197.47,131.12 197.47,131.55 197.29,131.72 195.24,131.72 195.06,131.9 v2(195.06,132.31)
XDP_PRDY#: length 4
  TOP w0.102: JXDP1.25 206.22,116.44 RC62.2 205.56,115.79 v1(204.3,115.79)
XDP_PRDY#_R: length 30.3
  TOP w0.102: v1(204.96,117.96) 205.43,117.49 v2(205.43,117.11) 205.26,116.93 RC62.1 ; v2(196.06,133.31) JCPU1.AR29
  IN1 w0.109: v2(205.43,117.11) 202.26,120.28 202.26,123.1 202.84,123.69 205,123.69 206.53,125.21 206.53,127.5 206.07,127.95 203.43,127.95 199.26,132.12 196.98,132.12 196.06,133.04 v2(196.06,133.31)
XDP_PREQ#: length 11.8
  TOP w0.102: JXDP1.26 v2(209.73,115.94)
  BOTTOM w0.102: RC81.2 205.54,124.02 207.85,121.7 v1(207.85,118.86) 207.85,117.82 v2(209.73,115.94)
XDP_PREQ#_R: length 15.4
  TOP w0.102: v2(197.06,133.31) JCPU1.AT29
  BOTTOM w0.102: v2(197.06,133.31) 197.06,133.29 197.08,133.26 200.22,133.26 200.87,132.61 200.87,131.21 201.28,130.8 201.28,126.11 202.21,125.18 v1(202.74,125.18) 203.58,125.18 RC32.2 RC81.1
XDP_RST#_R: length 2.5
  TOP w0.102: RC8.2 212.06,124.96 212.06,124.8 211.2,123.94 JXDP1.10
XDP_TCLK: length 3.6
  TOP w0.102: JXDP1.1 206.65,128.44 v2(205.74,129.35)
  BOTTOM w0.102: RC78.2 v2(205.74,129.35)
XDP_TCLK_R: length 18.5
  TOP w0.102: v2(193.06,138.31) JCPU1.AM34
  IN1 w0.109: v2(199.11,135.83) 198.12,136.81 193.93,136.81 193.58,137.17 193.58,137.79 v2(193.06,138.31)
  BOTTOM w0.089: v2(199.11,135.83) 199.24,135.95
  BOTTOM w0.102: 199.24,135.95 199.34,136.06 200.4,136.06 203.86,132.6 v4(203.86,131.69) RC78.1 RC40.2
XDP_TDI: length 4.2
  TOP w0.102: JXDP1.5 207.02,126.44 206.53,126.94 v2(205.71,126.94)
  BOTTOM w0.102: v1(206.28,126.81) 206.16,126.94 v2(205.71,126.94) 205.03,126.94 RC23.2
XDP_TDI_R: length 19
  TOP w0.102: v2(193.06,135.31) JCPU1.AM31
  BOTTOM w0.089: 197.38,134.68 194.66,134.68 194.44,134.91 193.67,134.91 193.28,135.31 v2(193.06,135.31)
  BOTTOM w0.102: 197.38,134.68 v4(197.83,134.24) 198.49,133.58 200.19,133.58 201.07,132.7 201.07,131.29 201.5,130.87 201.5,127.05 201.86,126.68 RC23.1 RC29.2
XDP_TDO: length 32
  TOP w0.102: JXDP1.7 207.54,125.44 v2(206.98,126)
  IN1 w0.109: v2(206.98,126) 206.98,135.91 198.07,144.82 198.07,150.13 198.73,150.79 v2(198.73,151.19)
  BOTTOM w0.102: v2(206.98,126) 207.45,126 v1(207.76,125.69) ; RC24.2 v2(198.73,151.19)
XDP_TDO_R: length 16.1
  TOP w0.102: v2(192.06,137.31) JCPU1.AL33
  BOTTOM w0.102: v2(192.06,137.31) 192.06,140.33 v4(195.49,143.76) 197.57,145.85 197.57,146.15 RC35.2 198.22,147.82 198.22,149.09 RC24.1
XDP_TMS: length 34.6
  TOP w0.102: JXDP1.4 211.76,126.94 212.27,127.45 212.27,129.73 211.05,130.95 v2(208.56,130.95)
  IN1 w0.109: v2(201.65,151.32) 201.52,151.32 199.29,149.09 199.29,144.2 207.59,135.9 207.59,131.92 v2(208.56,130.95)
  BOTTOM w0.102: v2(208.56,130.95) v1(209.12,130.95) ; RC80.2 v2(201.65,151.32)
XDP_TMS_R: length 16.6
  TOP w0.102: JCPU1.AN33 v2(194.06,137.31)
  BOTTOM w0.102: v2(194.06,137.31) 194.27,137.31 v4(194.94,137.99) 194.94,138.6 195.73,139.38 195.73,140.81 201.35,146.42 201.35,147.01 RC27.2 202.16,147.82 202.16,149.09 RC80.1
XDP_TRST#: length 37.5
  TOP w0.102: v2(207.8,130.92) 208.25,130.47 208.53,130.47 208.96,130.04 208.96,127.34 210.37,125.94 JXDP1.6
  IN1 w0.109: v2(200.38,152.21) 200.38,151.09 199.26,149.97 198.88,149.97 198.28,149.37 198.28,144.91 207.31,135.88 207.31,131.41 v2(207.8,130.92)
  BOTTOM w0.102: v2(200.38,152.21) 200.23,152.06 v1(200.23,151.73) 200.23,148.63 199.82,148.22 RC56.2
XDP_TRST#_R: length 16.2
  TOP w0.102: v2(193.06,137.31) JCPU1.AM33
  BOTTOM w0.102: v2(193.06,137.31) 193.06,137.65 193.52,138.11 v4(193.52,140.47) 199.32,146.27 199.32,146.88 RC56.1 199.69,147.31 199.24,147.77 199.24,149.09 RC41.2
XTAL25_IN: length 8.9
  BOTTOM w0.076: UH1.AM43 85.56,71.44 85.98,71.44 86.28,71.13 86.82,71.13 86.92,71.03 87.22,71.03 87.39,71.2
  BOTTOM w0.102: RH152.2 91.56,73.72 89.84,73.72 v1(88.64,72.53) 87.75,71.63 87.75,71.56 87.39,71.2
XTAL25_IN_R: length 3.9
  BOTTOM w0.102: YH2.1 94.77,75.07 CH14.2 93.58,73.87 RH152.1 RH153.2
XTAL25_OUT: length 13.6
  BOTTOM w0.076: UH1.AL44 86.04,70.93 86.69,70.93 86.82,70.8 86.97,70.8
  BOTTOM w0.102: 86.97,70.8 87.27,70.8 88.59,72.12 89.46,72.12 89.66,71.92 90.59,71.92 v1(90.75,72.08) 90.83,72.17 CH13.2 91.67,73.01 RH153.1 92.17,72.51 93,72.51 93.17,72.68 96.53,72.68 YH2.3
XTALI: length 5.5
  TOP w0.203: U31.10 115.22,93.29 115.26,93.33 115.9,93.33 v1(116.1,93.54) 116.76,94.2 117.8,94.2 C471.1 118.72,94.48 Y3.3
XTALO: length 2.4
  TOP w0.203: R1144.2 116.88,92.89 U31.9
XTALO_R: length 4.6
  TOP w0.203: Y3.1 120.02,94.02 118.49,94.02 C470.1 R1144.1
Z2805: length 4.7
  TOP w0.102: v1(55.9,155.36) 55.9,156.93 R574.1 v2(55.35,158.43)
  BOTTOM w0.102: v2(55.35,158.43) 55.35,157.02
Z2806: length 3.4
  TOP w0.102: v2(47.73,158.4) R573.1 v1(48.84,157.49)
  BOTTOM w0.102: T156.16 v2(47.73,158.4)
Z2807: length 5.4
  TOP w0.102: v1(53.96,154.88) 53.52,155.32 53.52,156.93 R572.1 v2(54.08,158.43)
  BOTTOM w0.102: v2(54.08,158.43) T156.21
Z2808: length 2.9
  TOP w0.102: R571.1 v2(46.46,158.4) v1(46.46,159.03)
  BOTTOM w0.102: T156.15 v2(46.46,158.4)
Z4012: length 2.5
  BOTTOM w0.102: v1(47.73,101.06) 47.74,101.05 PD1.2
  BOTTOM w0.508: PD1.2 49.17,100.9 PR1.2
Z4304: length 12.2
  TOP w0.102: PR3.4 195.41,7.39 195.28,7.26 195.28,7.16 195.38,7.05 195.55,7.05 195.81,7.3 195.81,8.22 196,8.41 196.38,8.41 196.53,8.56 PD2.2 196.68,8.95 v2(197.19,8.95)
  BOTTOM w0.102: PBATT1.3 194.18,3.49 194.18,5.68 195.93,7.43 196.82,8.32 197.05,8.32 197.19,8.46 v2(197.19,8.95)
Z4305: length 12.4
  TOP w0.102: PR3.3 194.91,7.39 195.05,7.26 195.05,7.06 195.29,6.82 195.65,6.82 196.04,7.21 196.04,8.12 196.1,8.18 196.39,8.18 196.53,8.04 PD2.3 196.91,7.43 v2(197.19,7.43)
  BOTTOM w0.102: PBATT1.4 194.41,3.58 194.41,5.58 196.92,8.09 197.09,8.09 197.19,7.99 v2(197.19,7.43)
Z4306: length 16.2
  TOP w0.254: v2(194.54,7.18) 194.41,7.3 PR3.2 ; v2(199.72,9.82) 199.29,9.82 199.06,9.6 199.06,8.87 PD3.2 198.47,8.27 198.47,5.14 197.34,4.01 PBATT1.5
  BOTTOM w0.254: v2(194.54,7.18) v1(194.54,8.52) 195.84,9.82 v2(199.72,9.82)
ZODD_WAKE#: length 284.9
  TOP w0.102: v2(30,25.44) 30.06,25.38 Q81.6 30.06,24.46 29.78,24.18 27.49,24.18 27.2,23.89 27.2,22.75 R796.2
  IN3 w0.127: v2(56.97,35.62) 57.65,36.3 76.09,36.3 79.46,39.68 96.73,39.68 97.79,38.62 101.19,38.62 102.11,37.71 119.04,37.71 119.14,37.61 143.64,37.61 146.64,34.61 155.36,34.61 156.37,33.6 167.18,33.6 168.53,34.96 178.35,34.96 179.44,36.06 187.75,36.06 188.97,37.28 190.59,37.28 192.02,38.7 193.88,38.7 194.36,39.18 204.28,39.18 204.84,39.74 207.09,39.74 217.12,49.77 224.05,49.77 229.46,55.18 229.46,57.05 230.51,58.1 234.48,58.1 236.14,56.45 243.56,56.45 245.44,58.33 246.7,58.33 248,59.64 248,60.02 248.44,60.45 248.44,63.7 250.04,65.3 250.04,75.12 247.94,77.22 247.68,77.22 245.18,79.72 243.74,79.72 243.53,79.92 v2(243.53,80.58)
  IN4 w0.109: v2(30,25.44) 31.15,24.28 50.93,24.28 56.97,30.33 v2(56.97,35.62)
  BOTTOM w0.102: U46.A59 v1(239.48,76.07) 239.18,76.37 239.18,76.83 239.37,77.02 239.37,79.89 239.94,80.46 243.41,80.46 v2(243.53,80.58)
