# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D55: length 72.5
  TOP w0.102: v2(161.06,110.31) 161.53,109.84 JCPU1.A6
  TOP w0.14: v2(133.7,70.81) 133.86,70.81 134.04,70.99 JDIMM1.177
  IN1 w0.089: 160.12,110.89 160.48,110.89 v2(161.06,110.31)
  IN1 w0.147: 160.12,110.89 147.26,110.89 143.3,106.93 143.3,104.46 139.73,100.89 139.73,100.02 139.36,99.66 139.15,99.66 138.82,99.98 138.62,99.98 138.41,99.77 138.41,99.57 138.73,99.24 138.73,99.03 138.53,98.82 138.32,98.82 137.99,99.15 137.78,99.15 137.57,98.94 137.57,98.73 137.9,98.41 137.9,98.2 137.69,97.99 137.48,97.99 137.16,98.31 136.95,98.31 136.74,98.11 136.74,97.9 137.07,97.57 137.07,97.36 136.86,97.16 136.65,97.16 136.32,97.48 136.12,97.48 135.91,97.27 135.91,97.06 136.23,96.74 136.23,96.53 136.02,96.32 135.82,96.32 135.49,96.65 135.28,96.65 135.07,96.44 135.07,96.23 135.4,95.9 135.4,95.7 135.19,95.49 134.98,95.49 134.66,95.81 134.45,95.81 134.24,95.61 134.24,95.4 134.57,95.07 134.57,94.86 134.36,94.65 134.15,94.65 133.82,94.98 133.61,94.98 133.41,94.77 133.41,94.56 133.73,94.24 133.73,94.03 133.18,93.48 133.18,71.64 133.7,71.12 v2(133.7,70.81)
  BOTTOM w0.14: JDIMM2.176 134.34,71.29 133.86,70.81 v2(133.7,70.81)
DDR_A_D56: length 79.7
  TOP w0.102: JCPU1.E12 165.53,115.84 v2(165.06,116.31)
  TOP w0.14: v2(131.67,70.24) 132.24,70.81 JDIMM1.183
  IN1 w0.089: v2(165.06,116.31) 164.68,115.93 164.35,115.93 163.65,115.23 163.65,114.77 163.47,114.58 163.47,114.15 163.22,113.91 162.82,113.91 162.47,113.55 162.47,113.15 162.22,112.91 161.82,112.91 161.62,112.71 160.93,112.71 160.73,112.51 160.12,112.51
  IN1 w0.147: 160.12,112.51 146.58,112.51 141.68,107.61 141.68,105.96 138.79,103.08 138.79,102.46 138.5,102.17 138.29,102.17 138.2,102.27 137.99,102.27 137.78,102.06 137.78,101.86 137.88,101.76 137.88,101.55 137.67,101.34 137.46,101.34 137.36,101.44 137.15,101.44 136.95,101.23 136.95,101.02 137.04,100.92 137.04,100.72 136.84,100.51 136.63,100.51 136.53,100.6 136.32,100.6 136.11,100.4 136.11,100.19 136.21,100.09 136.21,99.88 136,99.67 135.79,99.67 135.7,99.77 135.49,99.77 135.28,99.56 135.28,99.35 135.38,99.26 135.38,99.05 135.17,98.84 134.96,98.84 134.86,98.94 134.65,98.94 134.45,98.73 134.45,98.52 134.54,98.42 134.54,98.21 134.33,98.01 134.13,98.01 134.03,98.1 133.82,98.1 133.61,97.9 133.61,97.69 133.71,97.59 133.71,97.38 131.53,95.21 131.53,75.91 131.02,75.4 131.02,74.3 131.17,74.15 131.39,74.15 131.53,74.01 131.53,73.73 131.38,73.58 131.18,73.58 131.02,73.43 131.02,73.12 131.17,72.98 131.39,72.98 131.53,72.83 131.53,72.53 131.39,72.39 131.17,72.39 131.02,72.24 131.02,71.9 131.15,71.77 131.35,71.77 131.53,71.59 131.53,71.01 131.67,70.86 v2(131.67,70.24)
  BOTTOM w0.14: JDIMM2.182 132.54,71.11 v2(131.67,70.24)
DDR_A_D57: length 81.5
  TOP w0.102: v2(164.06,116.31) 164.53,115.84 JCPU1.D12
  TOP w0.14: JDIMM1.181 132.84,71.3 132.7,71.16 132.7,69.75 v2(131.67,68.72)
  IN1 w0.089: v2(164.06,116.31) 163.46,115.71 163.46,114.88 163.29,114.71 162.77,114.71 162.66,114.59 162.66,114.01 162.35,113.71 161.76,113.71 161.66,113.6 161.66,113.11 161.45,112.9 160.2,112.9
  IN1 w0.147: 160.2,112.9 146.42,112.9 141.29,107.77 141.29,106.12 132.96,97.79 132.96,97.58 133.05,97.48 133.05,97.27 132.84,97.07 132.64,97.07 132.54,97.16 132.33,97.16 132.12,96.96 132.12,96.75 132.22,96.65 132.22,96.44 132.01,96.23 131.8,96.23 131.7,96.33 131.5,96.33 131.15,95.98 131.15,76.07 130.61,75.53 130.61,71.37 131.16,70.82 131.16,68.81 131.31,68.66 131.62,68.66 v2(131.67,68.72)
  BOTTOM w0.14: JDIMM2.180 133.14,70.19 v2(131.67,68.72)
DDR_A_D58: length 81.4
  TOP w0.102: v2(162.06,115.31) 162.53,114.84 JCPU1.B11
  TOP w0.14: JDIMM1.192 129.54,66 v2(128.34,67.2)
  IN1 w0.089: 160.2,115.21 160.7,115.71 161.66,115.71 v2(162.06,115.31)
  IN1 w0.147: v2(128.34,67.2) 128.34,67.12 128.9,66.56 129.12,66.56 129.32,66.75 129.32,66.97 128.97,67.31 128.97,70.35 129.05,70.42 129.05,78.62 129.6,79.17 129.6,96.67 139.65,106.72 139.65,108.5 145.73,114.58 159.57,114.58 160.2,115.21
  BOTTOM w0.14: JDIMM2.191 129.84,65.7 v2(128.34,67.2)
DDR_A_D59: length 78.5
  TOP w0.102: JCPU1.A11 161.53,114.84 v2(161.06,115.31)
  TOP w0.14: JDIMM1.194 128.94,65.08 v2(128.34,65.67)
  IN1 w0.147: v2(161.06,115.31) 160.85,115.31 159.73,114.19 145.89,114.19 140.04,108.34 140.04,106.56 129.99,96.51 129.99,79.01 129.44,78.46 129.44,70.26 129.36,70.19 129.36,67.47 129.8,67.04 130.32,67.04 130.48,66.88 130.48,65.82 130.32,65.67 v2(128.34,65.67)
  BOTTOM w0.14: JDIMM2.193 129.24,64.87 128.44,65.67 v2(128.34,65.67)
DDR_A_D60: length 81.4
  TOP w0.102: JCPU1.E11 v2(166.06,115.31)
  TOP w0.14: v2(131.67,67.2) 132.15,66.71 132.15,66.24 133.14,65.26 JDIMM1.180
  IN1 w0.089: 160.12,112.12 160.62,112.12 160.87,111.87 161.31,111.87 161.66,112.22 161.66,112.48 161.9,112.72 162.3,112.72 162.66,113.07 162.66,113.48 162.89,113.71 163.29,113.71 163.66,114.07 163.66,114.51 163.84,114.69 163.84,115.04 164.54,115.74 165.63,115.74 v2(166.06,115.31)
  IN1 w0.147: v2(131.67,67.2) 132.15,67.68 132.15,70.93 131.92,71.16 131.92,95.05 139.18,102.3 139.18,102.91 142.07,105.8 142.07,107.45 146.74,112.12 160.12,112.12
  BOTTOM w0.14: JDIMM2.181 132.84,65.05 132.47,65.42 132.47,66.38 131.67,67.18 v2(131.67,67.2)
DDR_A_D61: length 79
  TOP w0.102: JCPU1.D11 v2(165.06,115.31)
  TOP w0.14: v2(131.67,65.67) 132,65.67 132.54,65.13 JDIMM1.182
  IN1 w0.089: 160.55,111.68 162.05,111.68 162.57,112.21 162.57,112.49 162.93,112.84 163.14,112.84 163.55,113.25 163.55,113.4 163.98,113.83 164.12,113.83 164.46,114.16 164.46,114.71 v2(165.06,115.31)
  IN1 w0.147: 160.55,111.68 160.51,111.73 146.91,111.73 142.45,107.27 142.45,105.64 139.57,102.75 139.57,102.14 132.34,94.91 132.34,71.29 132.78,70.85 132.78,65.38 132.63,65.23 131.82,65.23 131.67,65.38 v2(131.67,65.67)
  BOTTOM w0.14: JDIMM2.183 132.24,65.1 v2(131.67,65.67)
DDR_A_D62: length 79.9
  TOP w0.102: v2(162.08,116.27) 162.52,115.84 JCPU1.B12
  TOP w0.14: v2(128.34,70.24) 129.24,71.14 JDIMM1.193
  IN1 w0.089: 160.2,115.76 160.34,115.9 161.71,115.9 v2(162.08,116.27)
  IN1 w0.147: v2(128.34,70.24) 128.56,70.46 128.56,78.68 129.21,79.33 129.21,79.91 129.06,80.06 128.71,80.06 128.56,80.21 128.56,80.5 128.71,80.65 129.06,80.65 129.21,80.8 129.21,81.09 129.06,81.24 128.71,81.24 128.56,81.39 128.56,81.68 128.71,81.83 129.06,81.83 129.21,81.98 129.21,82.27 129.06,82.42 128.71,82.42 128.56,82.56 128.56,82.86 128.71,83.01 129.06,83.01 129.21,83.15 129.21,83.45 129.06,83.6 128.71,83.6 128.56,83.74 128.56,84.04 128.71,84.19 129.06,84.19 129.21,84.33 129.21,84.63 129.06,84.77 128.71,84.77 128.56,84.92 128.56,85.22 128.71,85.36 129.06,85.36 129.21,85.51 129.21,85.81 129.06,85.95 128.71,85.95 128.56,86.1 128.56,86.4 128.71,86.54 129.06,86.54 129.21,86.69 129.21,96.83 139.26,106.88 139.26,108.66 145.56,114.97 159.4,114.97 160.2,115.76
  BOTTOM w0.14: v2(128.34,70.24) 128.34,70.75 128.94,71.35 JDIMM2.194
DDR_A_D63: length 81.4
  TOP w0.102: JCPU1.A12 161.53,115.84 v2(161.06,116.31)
  TOP w0.14: v2(128.34,68.72) 128.97,69.34 128.97,70.27 129.84,71.14 JDIMM1.191
  IN1 w0.147: v2(161.06,116.31) 160.2,116.31 159.24,115.36 145.4,115.36 138.87,108.82 138.87,107.04 128.17,96.34 128.17,90.38 128.32,90.23 128.37,90.23 128.52,90.08 128.52,89.79 128.37,89.64 128.32,89.64 128.17,89.5 128.17,89.2 128.32,89.05 128.67,89.05 128.82,88.91 128.82,88.61 128.67,88.46 128.32,88.46 128.17,88.32 128.17,88.02 128.32,87.87 128.67,87.87 128.82,87.73 128.82,87.43 128.67,87.29 128.32,87.29 128.17,87.14 128.17,71.29 127.8,70.91 127.8,69.27 v2(128.34,68.72)
  BOTTOM w0.14: v2(128.34,68.72) 128.99,69.37 128.99,70.79 129.54,71.34 JDIMM2.192
DDR_A_DQS0: length 81.1
  TOP w0.102: v2(195.06,117.31) 194.59,117.78 JCPU1.AP14
  TOP w0.127: v2(187,67.61) 186.84,67.46 186.01,67.46 185.75,67.2 185.75,66.74 186.13,66.36 186.13,65.39 185.94,65.21 JDIMM1.12
  IN1 w0.089: 197.7,116.59 197.69,116.59 197.67,116.61 197.33,116.61 197.24,116.7 195.87,116.7 195.48,117.09 195.48,117.63 195.21,117.9 195.04,117.9 194.92,117.78 194.92,117.45 v2(195.06,117.31)
  IN1 w0.147: 197.7,116.59 197.83,116.59 197.84,116.59 199.49,116.59 203.85,112.22 203.85,83.76 203.41,83.32 203.41,82.9 203.46,82.86 203.46,82.65 203.25,82.44 203.04,82.44 202.99,82.49 202.57,82.49 202.22,82.13 202.22,81.71 202.26,81.66 202.26,81.46 202.05,81.25 201.84,81.25 201.8,81.29 201.38,81.29 201.02,80.93 201.02,80.52 201.07,80.47 201.07,80.26 200.86,80.05 200.65,80.05 200.61,80.1 200.19,80.1 199.83,79.74 199.83,79.32 199.87,79.28 199.87,79.07 199.67,78.86 199.46,78.86 199.41,78.91 198.99,78.91 198.63,78.55 198.63,78.13 198.68,78.08 198.68,77.87 198.47,77.67 198.26,77.67 198.22,77.71 197.8,77.71 197.44,77.35 197.44,76.93 197.49,76.89 197.49,76.68 197.28,76.47 197.07,76.47 197.02,76.52 196.61,76.52 196.25,76.16 196.25,75.74 196.29,75.7 196.29,75.49 196.08,75.28 195.88,75.28 195.83,75.32 195.41,75.32 190.98,70.89 189.9,70.89 189.76,70.75 188.79,70.75 187.48,69.44 187.48,67.47 187.27,67.26 187.13,67.26 187,67.39 v2(187,67.61)
  BOTTOM w0.127: JDIMM2.12 185.94,71.26 186.13,71.08 186.13,70.19 187.43,68.88 187.43,67.43 187.24,67.24 187.09,67.24 186.91,67.42 186.91,67.53 v2(187,67.61)
DDR_A_DQS1: length 70.7
  TOP w0.102: v2(195.06,112.31) 194.59,112.78 JCPU1.AP9
  TOP w0.127: v2(180.85,67.18) 180.69,67.34 180.48,67.34 180.12,67.7 180.12,69.39 181.03,70.29 181.03,71.15 180.84,71.33 JDIMM1.29
  IN1 w0.089: v2(195.06,112.31) 195.37,112 197.66,112 197.77,111.9 197.83,111.9 197.84,111.89
  IN1 w0.147: 197.84,111.89 198.16,111.57 198.39,111.34 198.39,111.33 200.15,109.57 200.15,87.04 196.43,83.32 196.43,82.77 188.21,74.54 187.03,74.54 184.89,72.4 184.3,72.4 183.44,71.54 182.83,71.54 181.73,70.44 181.73,68.94 181.56,68.77 181.56,68.39 181.73,68.23 181.73,67.78 181.28,67.33 181,67.33 v2(180.85,67.18)
  BOTTOM w0.127: JDIMM2.29 180.84,65.01 181.03,65.19 181.03,65.58 181.25,65.8 181.49,65.8 181.59,65.9 181.59,66.18 181.33,66.43 181.33,66.91 181.79,67.37 181.79,67.57 181.65,67.71 181.45,67.71 181.29,67.55 180.87,67.55 180.76,67.44 180.76,67.27 v2(180.85,67.18)
DDR_A_DQS2: length 67.4
  TOP w0.102: JCPU1.AK8 190.59,111.78 v2(191.06,111.31)
  TOP w0.127: JDIMM1.47 175.44,71.09 175.6,70.93 175.6,69.74 175.03,69.16 175.03,67.83 175.4,67.46 175.67,67.46 v2(175.81,67.32)
  IN1 w0.089: v2(191.06,111.31) 190.88,111.13 190.88,111.08 191.08,110.88 191.3,110.88 191.67,110.51 191.67,110.17 191.92,109.92 192.26,109.92 192.68,109.5 192.68,109.12 193.24,108.56 193.46,108.35 193.89,107.91 194.24,107.91 194.67,107.49 194.67,104.27 194.71,104.22 194.74,104.22 194.8,104.16 194.81,104.16 194.82,104.16
  IN1 w0.147: v2(175.81,67.32) 176.03,67.54 176.64,67.54 176.93,67.83 176.93,71.23 182.09,76.39 183.19,76.39 195.81,89.01 195.81,103.17 194.82,104.16
  BOTTOM w0.127: v2(175.81,67.32) 175.73,67.4 175.73,67.51 175.91,67.69 176.32,67.69 176.46,67.56 176.46,67.36 176.24,67.14 176.24,66.22 175.63,65.61 175.63,65.39 175.44,65.21 JDIMM2.47
DDR_A_DQS3: length 63.2
  TOP w0.102: v2(188.06,106.31) 187.59,106.78 JCPU1.AG3
  TOP w0.127: JDIMM1.64 170.34,65.01 170.53,65.19 170.53,65.52 170.32,65.72 170.32,67.15 170.66,67.48 170.83,67.48 v2(171.01,67.67)
  IN1 w0.089: v2(188.06,106.31) 188.06,106.22 187.85,106.01 187.68,106.01 187.57,106.12 187.57,106.55 187.74,106.72 188.23,106.72 189.44,105.51 189.44,104.12 189.9,103.66 189.9,103.66 189.93,103.62 189.93,103.58 189.94,103.57
  IN1 w0.147: v2(171.01,67.67) 170.99,67.67 170.91,67.58 170.91,67.49 171.06,67.33 171.3,67.33 171.56,67.59 171.56,71.84 180.33,80.61 180.69,80.61 183.75,83.67 184.45,83.67 191.26,90.48 191.26,102.26 189.94,103.57
  BOTTOM w0.127: JDIMM2.64 170.34,71.27 170.59,71.02 170.59,69.38 171.58,68.4 171.58,67.57 171.29,67.28 171.12,67.28 170.96,67.45 170.96,67.61 v2(171.01,67.67)
DDR_A_DQS4: length 67.1
  TOP w0.102: v2(168.06,106.31) JCPU1.H3
  TOP w0.127: v2(145.29,68.96) 145.19,68.86 145.19,68.77 145.38,68.58 145.56,68.58 145.76,68.78 145.76,70.62 146.18,71.03 146.18,71.12 146.04,71.26 JDIMM1.137
  IN1 w0.089: 163.25,102.21 163.33,102.29 163.36,102.29 163.41,102.34 163.5,102.43 163.59,102.51 165.2,102.51 167.49,104.8 167.49,105.58 167.8,105.89 168.35,105.89 168.57,106.12 168.57,106.25 168.39,106.43 168.18,106.43 v2(168.06,106.31)
  IN1 w0.147: 163.25,102.21 162.57,101.54 162.57,101.54 162.24,101.21 162.24,101.21 161.57,100.53 158.65,100.53 153.41,95.29 152.42,95.29 150.72,93.59 148.63,93.59 146,90.96 145.4,90.96 143.69,89.25 143.69,88.66 142.72,87.68 142.72,75.09 144.8,73.02 144.8,72.12 144.95,71.97 145.3,71.62 145.3,70.36 145.72,69.94 145.72,68.81 145.65,68.75 145.51,68.75 v2(145.29,68.96)
  BOTTOM w0.127: JDIMM2.137 146.04,64.99 146.19,65.14 146.19,65.6 145.82,65.97 144.64,67.15 144.64,68.5 144.94,68.79 145.12,68.79 v2(145.29,68.96)
DDR_A_DQS5: length 69.9
  TOP w0.102: v2(165.06,107.31) 165.53,106.84 JCPU1.E3
  TOP w0.127: JDIMM1.154 140.94,64.93 141.13,65.11 141.13,65.31 140.76,65.67 140.1,65.67 139.6,66.18 139.6,67.49 139.9,67.79 140.09,67.79 v2(140.26,67.97)
  IN1 w0.089: v2(165.06,107.31) 165.15,107.21 165.15,107.05 165.05,106.95 164.76,106.95 164.46,106.65 164.46,106.18 164.19,105.91 163.85,105.91 163.46,105.51 163.46,105.18 163.18,104.9 162.78,104.9 162.56,104.68 162.52,104.64 160.49,104.64 160.28,104.43 160.22,104.43 160.18,104.47 160.12,104.47
  IN1 w0.147: v2(140.26,67.97) 140.5,67.73 140.59,67.73 140.72,67.87 140.72,71.43 138.35,73.8 138.35,89.57 148.14,99.35 151.84,99.35 156.95,104.47 160.12,104.47
  BOTTOM w0.127: JDIMM2.154 140.94,71.2 141.13,71.02 141.13,70.86 140.9,70.64 140.9,67.93 140.55,67.58 140.4,67.58 140.2,67.78 140.2,67.9 v2(140.26,67.97)
DDR_A_DQS6: length 76.3
  TOP w0.102: v2(163.06,110.31) 163.53,109.84 JCPU1.C6
  TOP w0.127: v2(135.43,68.15) 135.36,68.08 135.36,67.93 135.52,67.77 135.81,67.77 136.03,67.99 136.03,71.06 135.84,71.25 JDIMM1.171
  IN1 w0.089: 160.41,109.21 160.43,109.19 160.44,109.19 160.7,108.93 161.21,108.93 161.46,109.18 161.46,109.51 161.87,109.92 162.9,109.92 163.06,110.07 v2(163.06,110.31)
  IN1 w0.147: v2(135.43,68.15) 135.69,67.89 135.81,67.89 135.89,67.97 135.89,69.1 135.51,69.48 135.51,71.05 134.41,72.15 134.41,92.97 140.96,99.51 140.96,100.38 144.52,103.95 144.52,106.31 147.85,109.63 159.99,109.63 160.41,109.21
  BOTTOM w0.127: v2(135.43,68.15) 135.29,68.01 135.03,68.01 134.71,67.68 134.71,66.21 135.22,65.7 135.6,65.7 135.96,65.34 135.96,65.15 135.84,65.03 JDIMM2.171
DDR_A_DQS7: length 84.7
  TOP w0.102: v2(163.06,116.31) 163.53,115.84 JCPU1.C12
  TOP w0.127: JDIMM1.188 130.74,64.98 130.93,65.16 130.93,65.62 129.16,67.38 129.16,68.58 129.51,68.93 129.7,68.93 v2(129.87,69.1)
  IN1 w0.089: v2(163.06,116.31) 163.06,116.06 162.98,115.98 162.71,115.98 162.45,115.72 162.45,115.11 162.25,114.91 161.74,114.91 161.46,114.63 161.46,114.01 161.33,113.88 160.68,113.88 160.41,113.61 160.34,113.61 160.3,113.65 160.2,113.65
  IN1 w0.147: v2(129.87,69.1) 129.87,68.98 130.05,68.8 130.17,68.8 130.33,68.95 130.33,70.43 129.89,70.87 129.89,76.17 130.44,76.71 130.44,77.32 130.29,77.47 130.18,77.47 129.89,77.77 129.89,78.27 130.18,78.57 130.29,78.57 130.44,78.72 130.44,96.32 140.49,106.37 140.49,108.03 146.11,113.65 160.2,113.65
  BOTTOM w0.127: JDIMM2.188 130.74,71.28 130.93,71.09 130.93,70.73 130.78,70.58 130.52,70.58 130.26,70.33 130.26,69.91 130.53,69.64 130.88,69.64 131.02,69.5 131.02,68.98 130.74,68.7 130.03,68.7 129.81,68.92 129.81,69.04 v2(129.87,69.1)
DDR_A_DQS#0: length 81.1
  TOP w0.102: JCPU1.AP15 194.59,118.78 v2(195.06,118.31)
  TOP w0.127: v2(187,66.85) 187.06,66.91 187.06,67.05 186.88,67.23 186.11,67.23 185.98,67.1 185.98,66.83 186.35,66.46 186.35,65.39 186.54,65.21 JDIMM1.10
  IN1 w0.089: 197.7,116.84 197.6,116.84 197.56,116.8 197.41,116.8 197.32,116.89 195.95,116.89 195.67,117.17 195.67,117.71 195.07,118.31 v2(195.06,118.31)
  IN1 w0.147: 197.7,116.84 199.59,116.84 204.11,112.33 204.11,83.66 203.66,83.22 203.66,83.01 203.71,82.96 203.71,82.54 203.35,82.19 202.93,82.19 202.89,82.23 202.68,82.23 202.47,82.02 202.47,81.82 202.52,81.77 202.52,81.35 202.16,80.99 201.74,80.99 201.69,81.04 201.49,81.04 201.28,80.83 201.28,80.62 201.32,80.58 201.32,80.16 200.96,79.8 200.55,79.8 200.5,79.85 200.29,79.85 200.08,79.64 200.08,79.43 200.13,79.38 200.13,78.96 199.77,78.61 199.35,78.61 199.31,78.65 199.1,78.65 198.89,78.44 198.89,78.23 198.93,78.19 198.93,77.77 198.58,77.41 198.16,77.41 198.11,77.46 197.9,77.46 197.7,77.25 197.7,77.04 197.74,76.99 197.74,76.58 197.38,76.22 196.96,76.22 196.92,76.26 196.71,76.26 196.5,76.05 196.5,75.85 196.55,75.8 196.55,75.38 196.19,75.02 195.77,75.02 195.73,75.07 195.52,75.07 191.08,70.64 190,70.64 189.86,70.5 188.89,70.5 187.73,69.33 187.73,67.36 187.37,67.01 187.15,67.01 v2(187,66.85)
  BOTTOM w0.127: v2(187,66.85) 187.16,67.01 187.34,67.01 187.66,67.34 187.66,68.98 186.35,70.29 186.35,71.12 186.54,71.3 JDIMM2.10
DDR_A_DQS#1: length 70.7
  TOP w0.102: v2(195.06,111.31) 194.59,111.78 JCPU1.AP8
  TOP w0.127: v2(180.85,67.94) 180.94,67.86 180.94,67.73 180.79,67.57 180.57,67.57 180.35,67.79 180.35,69.29 181.25,70.19 181.25,71.15 181.44,71.33 JDIMM1.27
  IN1 w0.089: 197.66,111.71 197.66,111.72 197.57,111.81 194.97,111.81 194.85,111.69 194.85,111.52 v2(195.06,111.31)
  IN1 w0.147: 197.66,111.71 199.9,109.47 199.9,87.14 196.18,83.43 196.18,82.88 188.1,74.8 186.92,74.8 184.78,72.66 184.2,72.66 183.34,71.8 182.72,71.8 181.47,70.54 181.47,69.04 181.3,68.88 181.3,68.29 181.47,68.12 181.47,67.89 181.17,67.59 181.04,67.59 180.85,67.78 v2(180.85,67.94)
  BOTTOM w0.127: JDIMM2.27 181.44,65 181.25,65.19 181.25,65.48 181.35,65.58 181.58,65.58 181.82,65.81 181.82,66.27 181.56,66.53 181.56,66.82 182.01,67.27 182.01,67.66 181.74,67.94 181.36,67.94 181.2,67.78 181.02,67.78 v2(180.85,67.94)
DDR_A_DQS#2: length 67.4
  TOP w0.102: v2(190.06,111.31) 189.59,111.78 JCPU1.AJ8
  TOP w0.127: JDIMM1.45 176.04,71.09 175.83,70.88 175.83,69.64 175.26,69.07 175.26,67.92 175.49,67.69 175.64,67.69 175.81,67.86 v2(175.81,68.08)
  IN1 w0.089: v2(190.06,111.31) 190.53,111.31 190.69,111.15 190.69,111 191,110.69 191.22,110.69 191.48,110.43 191.48,110.09 191.84,109.73 192.18,109.73 192.49,109.42 192.49,109.04 193.11,108.43 193.82,107.72 194.16,107.72 194.48,107.41 194.48,104.19 194.62,104.05 194.62,103.99 194.64,103.98
  IN1 w0.147: 194.64,103.98 195.55,103.06 195.55,89.12 183.08,76.65 181.99,76.65 176.68,71.33 176.68,67.93 176.54,67.79 176.1,67.79 v2(175.81,68.08)
  BOTTOM w0.127: v2(175.81,68.08) 175.97,67.92 176.41,67.92 176.69,67.65 176.69,67.26 176.46,67.04 176.46,66.13 175.85,65.52 175.85,65.39 176.04,65.21 JDIMM2.45
DDR_A_DQS#3: length 63.2
  TOP w0.102: v2(187.06,106.31) 186.59,106.78 JCPU1.AF3
  TOP w0.127: JDIMM1.62 170.94,65.01 170.75,65.2 170.75,65.61 170.55,65.82 170.55,67.05 170.75,67.25 170.96,67.25 171.06,67.16 171.06,66.95 v2(171.01,66.9)
  IN1 w0.089: 190.12,103.75 190.11,103.76 190.1,103.76 190.09,103.75 189.63,104.2 189.63,105.59 188.31,106.91 187.66,106.91 187.38,106.63 187.38,106.61 187.08,106.31 v2(187.06,106.31)
  IN1 w0.147: v2(171.01,66.9) 171.18,67.08 171.41,67.08 171.82,67.48 171.82,71.73 180.44,80.35 180.8,80.35 183.86,83.41 184.56,83.41 191.51,90.37 191.51,102.35 190.12,103.75
  BOTTOM w0.127: v2(171.01,66.9) 171.16,67.05 171.38,67.05 171.8,67.48 171.8,68.49 170.82,69.47 170.82,71.11 170.94,71.23 JDIMM2.62
DDR_A_DQS#4: length 67.2
  TOP w0.102: v2(169.06,106.31) JCPU1.J3
  TOP w0.127: JDIMM1.135 146.64,71.37 146.4,71.13 146.4,70.94 145.99,70.52 145.99,68.69 145.66,68.35 145.45,68.35 v2(145.29,68.2)
  IN1 w0.089: 163.43,102.04 163.44,102.05 163.44,102.09 163.47,102.12 163.47,102.13 163.55,102.2 163.67,102.32 165.28,102.32 167.68,104.73 167.68,105.5 167.88,105.7 168.43,105.7 168.76,106.04 168.76,106.14 168.93,106.31 v2(169.06,106.31)
  IN1 w0.147: 163.43,102.04 162.5,101.11 162.5,101.1 161.67,100.27 158.76,100.27 153.52,95.03 152.53,95.03 150.82,93.33 148.74,93.33 146.11,90.71 145.51,90.71 143.95,89.15 143.95,88.55 142.97,87.57 142.97,75.2 145.05,73.12 145.05,72.23 145.56,71.72 145.56,70.47 145.97,70.05 145.97,68.71 145.76,68.49 145.58,68.49 v2(145.29,68.2)
  BOTTOM w0.127: JDIMM2.135 146.64,64.99 146.42,65.22 146.42,65.7 145.98,66.13 144.87,67.25 144.87,68.4 145.03,68.57 145.18,68.57 145.35,68.4 145.35,68.26 v2(145.29,68.2)
DDR_A_DQS#5: length 69.9
  TOP w0.102: JCPU1.E2 165.53,105.84 v2(165.06,106.31)
  TOP w0.127: v2(140.26,67.2) 140.32,67.26 140.32,67.47 140.23,67.56 140,67.56 139.82,67.39 139.82,66.27 140.19,65.9 140.85,65.9 141.35,65.4 141.35,65.16 141.54,64.97 JDIMM1.152
  IN1 w0.089: 160.12,104.22 160.13,104.22 160.16,104.24 160.36,104.24 160.56,104.45 162.6,104.45 162.86,104.71 163.26,104.71 163.65,105.1 163.65,105.43 163.93,105.72 164.27,105.72 164.65,106.1 164.65,106.57 164.84,106.76 164.96,106.76 165.06,106.66 v2(165.06,106.31)
  IN1 w0.147: v2(140.26,67.2) 140.53,67.48 140.69,67.48 140.98,67.76 140.98,71.54 138.61,73.9 138.61,89.46 148.25,99.1 151.94,99.1 157.06,104.22 160.12,104.22
  BOTTOM w0.127: v2(140.26,67.2) 140.41,67.35 140.64,67.35 141.13,67.84 141.13,70.55 141.36,70.77 141.36,71.08 141.54,71.26 JDIMM2.152
DDR_A_DQS#6: length 76.3
  TOP w0.102: v2(163.06,109.31) 163.53,108.84 JCPU1.C5
  TOP w0.127: v2(135.43,67.39) 135.59,67.54 135.9,67.54 136.26,67.89 136.26,71.06 136.44,71.25 JDIMM1.169
  IN1 w0.089: 160.23,109.03 160.24,109.02 160.28,109.02 160.32,108.99 160.38,108.99 160.62,108.74 161.29,108.74 161.65,109.1 161.65,109.43 161.95,109.73 162.9,109.73 163.06,109.57 v2(163.06,109.31)
  IN1 w0.147: 160.23,109.03 159.95,109.32 159.94,109.32 159.88,109.37 147.95,109.37 144.78,106.2 144.78,103.85 141.21,100.28 141.21,99.41 134.67,92.87 134.67,72.25 135.76,71.16 135.76,69.59 136.14,69.21 136.14,67.87 135.91,67.64 135.69,67.64 v2(135.43,67.39)
  BOTTOM w0.127: v2(135.43,67.39) 135.5,67.45 135.5,67.58 135.3,67.78 135.13,67.78 134.94,67.58 134.94,66.31 135.32,65.93 135.7,65.93 136.19,65.43 136.19,65.16 136.44,64.91 JDIMM2.169
DDR_A_DQS#7: length 84.8
  TOP w0.102: v2(163.06,115.31) 163.53,114.84 JCPU1.C11
  TOP w0.127: JDIMM1.186 131.34,64.98 131.15,65.17 131.15,65.71 129.39,67.48 129.39,68.48 129.61,68.7 129.75,68.7 129.92,68.53 129.92,68.4 v2(129.87,68.34)
  IN1 w0.089: 160.2,113.4 160.21,113.4 160.23,113.42 160.49,113.42 160.76,113.69 161.41,113.69 161.65,113.93 161.65,114.55 161.81,114.72 162.33,114.72 162.64,115.03 162.64,115.64 162.79,115.79 162.98,115.79 163.06,115.7 v2(163.06,115.31)
  IN1 w0.147: 160.2,113.4 160.13,113.4 160.12,113.4 146.21,113.4 140.74,107.93 140.74,106.26 130.69,96.21 130.69,78.61 130.4,78.31 130.29,78.31 130.14,78.17 130.14,77.87 130.29,77.72 130.4,77.72 130.69,77.43 130.69,76.61 130.14,76.06 130.14,70.97 130.58,70.54 130.58,68.85 130.28,68.54 130.07,68.54 v2(129.87,68.34)
  BOTTOM w0.127: v2(129.87,68.34) 130,68.47 130.84,68.47 131.25,68.88 131.25,69.6 130.98,69.87 130.63,69.87 130.49,70.01 130.49,70.23 130.62,70.35 130.87,70.35 131.15,70.63 131.15,71.14 131.34,71.32 JDIMM2.186
DDR_A_MA0: length 63.6
  TOP w0.102: v2(158.91,70.1) 158.91,70.1 157.96,69.15 157.96,65.36 157.74,65.14 JDIMM1.98 ; v2(179.06,111.31) 178.59,111.78 JCPU1.V8
  IN1 w0.089: v2(179.06,111.31) 179.37,111.31 179.75,110.92 180.05,110.92 181.45,109.52 181.45,104.08 180.41,103.04 180.41,102.81
  IN1 w0.208: v2(158.91,70.1) 158.82,70.19 158.82,74.21 160.1,75.49 160.1,77.42 161.07,78.39 161.07,79.47 168.86,87.25 168.86,87.9 180.41,99.45 180.41,102.81
  BOTTOM w0.102: JDIMM2.98 157.74,70.87 157.64,70.77 157.45,70.77 157.35,70.67 157.35,70.4 157.46,70.29 158.05,70.29 158.19,70.15 158.19,69.83 158.32,69.7 158.6,69.7 158.91,70.01 v2(158.91,70.1)
DDR_A_MA1: length 74.1
  TOP w0.102: v2(184.06,109.31) 183.59,109.78 JCPU1.AC6 ; JDIMM1.97 158.04,70.68 158.18,70.54 159.09,70.54 159.34,70.28 159.34,68 158.91,67.56 v2(158.91,67.56)
  IN1 w0.089: 180.94,102.96 180.94,103.31 181.64,104 181.64,109.6 181.46,109.78 181.46,110.6 181.12,110.94 180.86,110.94 180.67,111.13 180.67,112.48 180.97,112.77 181.34,112.77 181.65,112.46 181.65,112.19 182.51,111.33 182.51,110.12 182.73,109.9 183.47,109.9 v2(184.06,109.31)
  IN1 w0.208: 180.94,102.96 180.94,99.23 169.39,87.68 169.39,87.03 161.61,79.25 161.61,78.38 161.79,78.2 161.79,77.7 161.36,77.28 161.01,77.28 160.64,76.91 160.64,75.27 159.37,74 159.37,69.45 159.43,69.4 159.43,68.63 159.72,68.34 159.72,68 159.28,67.56 v2(158.91,67.56)
  BOTTOM w0.102: v2(158.91,67.56) 158.91,67.71 158.78,67.83 158.31,67.83 158.18,67.71 158.18,67.42 158.31,67.3 158.39,67.3 158.51,67.17 158.51,66.97 158.39,66.85 158.3,66.85 158.17,66.72 158.17,66.55 158.3,66.42 158.4,66.42 158.52,66.29 158.52,66.09 158.41,65.97 158.27,65.97 158.19,65.9 158.19,65.69 158.27,65.61 158.36,65.61 158.48,65.48 158.48,65.29 158.36,65.16 158.17,65.16 158.04,65.03 JDIMM2.97
DDR_A_MA2: length 85.8
  TOP w0.102: JDIMM1.96 158.34,65.07 158.52,65.24 159.09,65.24 159.22,65.37 159.22,65.73 159.09,65.86 158.52,65.86 158.34,66.04 158.34,68.84 158.43,68.93 158.81,68.93 v2(158.91,68.83) ; v2(178.06,112.31) JCPU1.V9
  IN1 w0.089: v2(178.06,112.31) 178.51,112.76 178.51,113.53 178.68,113.69 179.38,113.69 179.59,113.49 179.59,112.27 179.1,111.78 178.96,111.78 178.66,111.48 178.66,111.14 178.92,110.88 179.35,110.88 179.65,110.58 179.65,110.2 179.89,109.96 180.26,109.96 180.63,109.59 180.63,103.69 179.88,102.94 179.88,102.4
  IN1 w0.208: v2(158.91,68.83) 158.86,68.83 158.38,68.35 158.38,63.26 158.11,63 157.8,63 157.35,63.45 157.35,64.24 157.17,64.42 157.16,64.42 156.98,64.6 156.98,64.94 157.16,65.11 157.46,65.11 157.63,65.29 157.63,68.58 158.29,69.24 158.29,74.43 159.57,75.71 159.57,77.67 160.54,78.64 160.54,79.69 168.33,87.48 168.33,88.12 179.88,99.68 179.88,102.4
  BOTTOM w0.102: v2(158.91,68.83) 158.91,68.83 159.04,68.7 159.23,68.7 159.36,68.83 159.36,69.01 159.49,69.14 159.57,69.14 159.7,69.27 159.7,69.51 159.57,69.64 159.49,69.64 159.36,69.76 159.36,69.95 159.49,70.08 159.57,70.08 159.7,70.21 159.7,70.38 159.57,70.51 159.41,70.51 159.31,70.6 159.31,70.91 159.19,71.04 158.98,71.04 158.85,70.91 158.85,70.65 158.73,70.52 158.48,70.52 158.34,70.66 JDIMM2.96
DDR_A_MA3: length 85.6
  TOP w0.102: JCPU1.U9 177.59,112.83 v2(177.07,112.31) ; JDIMM1.95 158.64,71.48 159.63,70.49 159.63,67.68 159.32,67.37 159.32,66.7 158.91,66.29 v2(158.91,66.29)
  IN1 w0.089: v2(177.07,112.31) 177.24,112.31 177.42,112.49 177.42,112.74 177.24,112.92 176.66,112.92 176.55,112.81 176.55,112 176.72,111.84 178.26,111.84 178.47,111.62 178.47,111.06 178.84,110.69 179.27,110.69 179.46,110.5 179.46,110.12 179.87,109.71 180.24,109.71 180.44,109.51 180.44,103.77 179.34,102.68 179.34,102.15
  IN1 w0.208: 179.34,102.15 179.34,99.9 167.79,88.34 167.79,87.7 160.01,79.91 160.01,78.86 159.04,77.89 159.04,75.93 157.76,74.65 157.76,69.46 157.07,68.78 157.07,67.22 157.1,67.2 157.1,65.8 156.92,65.62 156.45,65.62 155.9,65.07 155.9,65.06 155.9,63.26 156.08,63.08 156.96,63.08 157.99,62.06 159.34,62.06 159.64,62.35 159.64,62.71 158.91,63.43 v2(158.91,66.29)
  BOTTOM w0.102: v2(158.91,66.29) 158.91,66.41 159.04,66.54 159.45,66.54 159.57,66.41 159.57,65.38 159.45,65.26 159.29,65.26 159.17,65.39 159.17,65.69 159.04,65.82 158.89,65.82 158.77,65.69 158.77,65.26 158.64,65.13 JDIMM2.95
DDR_A_MA4: length 75.8
  TOP w0.102: JDIMM1.92 159.54,66.18 159.67,66.31 159.67,67.11 160.13,67.58 160.13,69.35 v2(160.96,70.18) ; v2(183.06,108.31) JCPU1.AC5
  IN1 w0.089: v2(183.06,108.31) 183.16,108.41 183.16,108.63 183.08,108.71 182.63,108.71 182.21,108.29 182.21,103.43 182.47,103.16
  IN1 w0.208: 182.47,103.16 182.54,103.09 182.54,98.57 180.05,96.08 180.05,95.84 180.09,95.8 180.09,95.55 179.91,95.36 179.66,95.36 179.62,95.41 179.38,95.41 179.22,95.24 179.22,95.01 179.28,94.95 179.28,94.71 179.11,94.54 178.87,94.54 178.82,94.59 178.58,94.59 178.41,94.43 178.41,94.19 178.46,94.14 178.46,93.9 178.29,93.74 178.06,93.74 178,93.79 177.76,93.79 177.6,93.62 177.6,93.38 177.64,93.33 177.64,93.08 177.46,92.9 177.21,92.9 177.13,92.97 176.94,92.97 174.24,90.26 174.24,89.93 174.82,89.35 174.82,89.1 174.61,88.89 174.36,88.89 173.74,89.51 173.49,89.51 173.28,89.29 173.28,89.04 173.9,88.42 173.9,88.17 173.68,87.96 173.43,87.96 172.81,88.58 172.56,88.58 172.38,88.4 172.38,88.14 172.92,87.61 172.92,87.36 172.74,87.18 172.49,87.18 172,87.67 171.65,87.67 170.99,87.02 170.99,86.34 170.8,86.16 170.8,85.9 170.87,85.84 170.87,85.14 168.51,82.78 168.1,82.78 167.88,83.01 167.64,83.01 167.47,82.84 167.47,82.6 167.79,82.29 167.79,82.05 167.62,81.89 167.38,81.89 167.07,82.2 166.83,82.2 166.66,82.03 166.66,81.79 166.96,81.49 166.96,81.24 166.77,81.05 166.52,81.05 166.23,81.35 165.97,81.35 165.78,81.15 165.78,80.9 166.08,80.6 166.08,80.35 165.9,80.17 165.64,80.17 165.35,80.46 165.11,80.46 164.94,80.29 164.94,80.05 165.22,79.77 165.22,79.54 165.05,79.37 164.59,79.37 164.43,79.21 164.43,78.7 164.12,78.38 163.86,78.38 163.47,77.99 163.47,77.06 162.98,76.57 162.98,76.23 162.76,76 162.41,76 162.24,75.83 162.24,73.96 161.66,73.38 161.44,73.38 161.25,73.19 161.25,73.01 160.97,72.73 160.97,70.19 v2(160.96,70.18)
  BOTTOM w0.102: JDIMM2.92 159.54,71.18 159.79,70.93 159.79,70.71 159.95,70.55 159.95,68.69 160.08,68.57 160.29,68.57 160.41,68.69 160.41,70.36 160.52,70.46 160.86,70.46 160.96,70.36 v2(160.96,70.18)
DDR_A_MA5: length 76.9
  TOP w0.102: JCPU1.AC4 v2(184.06,108.31) ; JDIMM1.91 159.84,71.34 160.56,70.61 161.07,70.61 161.39,70.3 161.39,68.08 160.99,67.68 160.99,67.68 v2(160.96,67.64)
  IN1 w0.089: v2(184.06,108.31) 184.06,108.76 183.64,109.18 183.64,109.35 183.27,109.71 182.65,109.71 182.44,109.5 182.44,109.2 181.83,108.59 181.83,103.87 181.48,103.52 181.48,103.32
  IN1 w0.208: 181.48,103.32 181.48,99.01 169.93,87.46 169.93,86.81 163.78,80.66 163.78,80.08 162.89,79.19 162.89,78.93 162.32,78.35 162.32,77.42 161.64,76.75 161.44,76.75 161.17,76.48 161.17,75.05 159.9,73.78 159.9,69.67 159.96,69.62 159.96,68.85 160.44,68.38 160.44,67.96 159.49,67.01 159.49,63.61 159.81,63.29 160.2,63.29 160.37,63.46 160.37,64.47 160.12,64.72 160.12,66.86 160.89,67.64 v2(160.96,67.64)
  BOTTOM w0.102: v2(160.96,67.64) 160.96,67.49 160.83,67.37 159.98,67.37 159.85,67.49 159.85,67.66 159.72,67.79 159.44,67.79 159.31,67.66 159.31,66.96 159.44,66.83 159.73,66.83 159.84,66.72 JDIMM2.91
DDR_A_MA6: length 75.7
  TOP w0.102: JDIMM1.90 160.14,65.04 160.27,65.17 160.27,65.34 160.14,65.47 160.01,65.47 159.88,65.6 159.88,65.9 160.02,66.04 160.02,66.86 160.45,67.29 160.45,69.04 160.58,69.16 160.83,69.16 160.96,69.04 v2(160.96,68.91) ; v2(185.08,110.39) 184.59,109.89 JCPU1.AD6
  IN1 w0.089: v2(185.08,110.39) 185.09,110.38 185.09,110.15 184.97,110.03 184.59,110.03 184.47,110.15 184.47,110.51 184.27,110.7 183.71,110.7 183.53,110.88 182.89,110.88 182.72,110.7 182.72,110.27 182.89,110.09 183.55,110.09 183.83,109.81 184.25,109.81 184.52,109.54 184.52,108.05 184.35,107.89 183.72,107.89 183.54,108.06 183.54,108.52 183.13,108.93 182.46,108.93 182.02,108.49 182.02,103.67 182.01,103.66 182.01,102.84
  IN1 w0.208: v2(160.96,68.91) 160.66,68.91 160.49,69.08 160.49,69.84 160.44,69.89 160.44,72.95 160.71,73.23 160.71,73.41 160.63,73.49 160.63,73.74 160.86,73.97 161.11,73.97 161.16,73.92 161.41,73.92 161.71,74.21 161.71,76.05 162.85,77.2 162.85,78.13 163.42,78.7 163.42,78.97 164.31,79.86 164.31,80.44 167.63,83.76 167.88,83.76 168.17,83.47 168.43,83.47 168.61,83.65 168.61,83.91 168.33,84.2 168.33,84.46 168.51,84.64 168.77,84.64 169.06,84.35 169.32,84.35 169.5,84.54 169.5,84.79 169.21,85.08 169.21,85.32 169.39,85.49 169.63,85.49 169.92,85.2 170.17,85.2 170.34,85.37 170.34,85.62 170.05,85.9 170.05,86.18 170.46,86.59 170.46,87.24 182.01,98.79 182.01,102.84
  BOTTOM w0.102: v2(160.96,68.91) 161.13,68.91 161.38,69.16 161.38,70.54 161.26,70.66 161.19,70.66 161.07,70.79 161.07,70.92 160.9,71.09 160.71,71.09 160.58,70.97 160.58,70.84 160.45,70.71 160.25,70.71 160.14,70.82 JDIMM2.90
DDR_A_MA7: length 76.6
  TOP w0.102: JDIMM1.86 161.34,66.07 161.81,66.54 161.81,67.51 162.21,67.91 162.21,69.77 v2(162.62,70.18) ; v2(184.06,107.31) JCPU1.AC3
  IN1 w0.089: v2(184.06,107.31) 183.8,107.05 183.8,106.9 183.91,106.79 184.08,106.79 184.15,106.72 184.15,106.37 184.07,106.29 183.8,106.29 183.69,106.17 183.69,105.9 183.43,105.65 183.43,103.87 184.05,103.26
  IN1 w0.208: v2(162.62,70.18) 162.62,72.08 163.84,73.3 163.84,74.22 169.36,79.73 169.36,80.22 169.94,80.81 169.94,81.12 169.65,81.41 169.65,81.65 169.84,81.85 170.09,81.85 170.65,81.29 170.9,81.29 171.1,81.49 171.1,81.74 170.55,82.3 170.55,82.55 170.73,82.72 170.98,82.72 171.53,82.17 171.78,82.17 171.98,82.37 171.98,82.62 171.42,83.18 171.42,83.42 171.6,83.6 171.84,83.6 172.4,83.04 172.65,83.04 172.83,83.22 172.83,83.47 172.27,84.03 172.27,84.27 172.45,84.44 172.69,84.44 173.25,83.89 173.49,83.89 173.67,84.06 173.67,84.31 173.1,84.88 173.1,85.13 173.3,85.32 173.55,85.32 174.12,84.75 174.37,84.75 174.58,84.96 174.58,85.21 174.02,85.77 174.02,86.02 174.23,86.24 174.49,86.24 174.88,85.84 175.16,85.84 175.37,86.06 175.37,86.46 175.56,86.65 175.81,86.65 175.91,86.54 176.17,86.54 176.35,86.73 176.35,86.98 176.22,87.11 176.22,87.37 176.44,87.59 176.69,87.59 176.81,87.46 177.07,87.46 177.25,87.65 177.25,87.9 176.42,88.73 176.42,88.98 176.64,89.2 176.89,89.2 177.71,88.37 177.97,88.37 178.14,88.55 178.14,88.8 177.03,89.92 177.03,90.18 181.69,94.85 181.69,95.46 183.5,97.26 184.14,97.91 184.14,103.16 184.05,103.26
  BOTTOM w0.102: v2(162.62,70.18) 162.62,70.32 162.52,70.42 162.29,70.42 162.21,70.34 162.21,68.91 161.91,68.61 161.65,68.61 161.53,68.73 161.53,68.93 161.78,69.17 161.78,70.87 161.34,71.31 JDIMM2.86
DDR_A_MA8: length 77.7
  TOP w0.102: JCPU1.AD5 184.59,108.89 v2(185.05,109.35) ; JDIMM1.89 160.44,71.41 160.81,71.04 160.97,71.04 161.72,70.3 161.72,67.85 161.39,67.52 161.39,66.8 v2(160.96,66.37)
  IN1 w0.089: v2(185.05,109.35) 185.05,109.3 184.71,108.96 184.71,107.98 184.43,107.7 183.57,107.7 183.38,107.88 182.67,107.88 182.45,107.66 182.45,103.68 182.95,103.18
  IN1 w0.208: v2(160.96,66.37) 160.87,66.37 160.66,66.17 160.66,64.93 160.91,64.69 160.91,63.58 161.09,63.41 161.76,63.41 161.94,63.58 161.94,63.9 161.76,64.08 161.64,64.08 161.47,64.25 161.47,64.69 161.64,64.87 161.77,64.87 161.95,65.05 161.95,65.42 161.77,65.6 161.58,65.6 161.4,65.77 161.4,66.1 161.58,66.28 161.9,66.28 162.08,66.46 162.08,66.81 161.9,66.99 161.67,66.99 161.5,67.16 161.5,67.48 161.67,67.66 161.95,67.66 162.12,67.84 162.12,68.13 161.96,68.29 161.68,68.29 161.5,68.46 161.5,72.47 162.77,73.74 162.77,75.13 163.51,75.87 163.51,76.35 164,76.84 164,77.52 171.41,84.92 171.41,86 172.05,86.65 173.13,86.65 174.8,88.32 174.8,88.33 175.35,88.88 175.35,90.01 180.63,95.29 180.63,95.61 180.63,95.9 183.08,98.35 183.08,103.05 182.95,103.18
  BOTTOM w0.102: v2(160.96,66.37) 160.96,66.5 160.83,66.63 160.7,66.63 160.57,66.75 160.57,66.87 160.44,67 160.26,67 160.13,66.87 160.13,66.16 160.26,66.03 160.69,66.03 160.82,65.91 160.82,65.69 160.69,65.56 160.25,65.56 160.13,65.44 160.13,65.27 160.25,65.14 160.37,65.14 160.44,65.07 JDIMM2.89
DDR_A_MA9: length 75.5
  TOP w0.102: v2(183.06,106.31) 183.53,105.84 JCPU1.AC2 ; v2(162.62,68.91) 162.89,68.64 163.02,68.64 163.09,68.72 163.09,70.3 162.76,70.63 162.18,70.63 161.64,71.16 JDIMM1.85
  IN1 w0.089: v2(183.06,106.31) 182.68,106.69 182.68,107.51 182.85,107.69 183.3,107.69 183.56,107.43 183.56,107.18 183.46,107.07 183.46,106.01 183.3,105.85 182.88,105.85 182.65,105.62 182.65,104.07 183.41,103.31
  IN1 w0.208: v2(162.62,68.91) 162.47,68.76 162.22,68.76 162.05,68.93 162.05,72.26 163.31,73.52 163.31,74.91 163.52,75.12 163.69,75.12 163.72,75.1 163.96,75.1 164.13,75.27 164.13,75.51 164.04,75.59 164.04,76.04 164.2,76.19 164.44,76.19 164.65,75.97 164.79,75.97 165,76.18 165,76.59 164.53,77.06 164.53,77.3 164.76,77.52 164.96,77.52 165.54,76.94 165.79,76.94 166.01,77.15 166.01,77.4 165.45,77.96 165.45,78.21 165.63,78.38 165.88,78.38 166.43,77.83 166.68,77.83 166.88,78.02 166.88,78.27 166.32,78.82 166.32,79.07 166.52,79.27 166.77,79.27 167.31,78.72 167.56,78.72 167.73,78.9 167.73,79.15 167.2,79.69 167.2,79.96 167.41,80.17 167.56,80.17 168.17,79.56 168.42,79.56 168.59,79.74 168.59,79.99 168.04,80.55 168.04,80.79 168.21,80.97 168.46,80.97 168.77,80.66 169.02,80.66 169.21,80.85 169.21,81.1 168.9,81.41 168.9,81.66 169.52,82.28 169.53,82.28 169.62,82.38 169.79,82.38 170.02,82.6 170.02,82.77 170.03,82.78 170.03,82.79 171.63,84.39 172.24,85 172.24,85.18 171.94,85.48 171.94,85.78 172.27,86.12 172.56,86.12 172.87,85.8 173.04,85.8 173.27,86.03 173.97,86.73 173.97,86.73 174.01,86.77 174.26,86.77 174.52,87.04 174.52,87.29 174.7,87.47 174.98,87.47 175.22,87.71 175.22,87.98 175.42,88.18 175.69,88.18 175.89,88.37 175.89,89.79 181.16,95.07 181.16,95.61 181.16,95.68 183.12,97.64 183.61,98.13 183.61,103.11 183.41,103.31
  BOTTOM w0.102: v2(162.62,68.91) 162.56,68.91 162.12,68.47 162.12,67.97 161.99,67.84 161.48,67.84 161.35,67.71 161.35,67.52 161.47,67.4 161.77,67.4 161.97,67.2 161.97,66.1 161.64,65.77 JDIMM2.85
DDR_A_MA10: length 79.5
  TOP w0.102: JDIMM1.107 155.04,71.12 155.22,70.95 155.34,70.95 155.66,70.63 155.66,69.02 155.49,68.84 155.24,68.84 155.06,69.02 155.06,70.18 154.88,70.36 v2(154.62,70.36) ; v2(178.1,110.35) 178.59,109.86 JCPU1.V6
  IN1 w0.089: v2(178.1,110.35) 178.1,110.34 177.84,110.34 177.77,110.42 177.77,110.66 177.94,110.83 178.43,110.83 178.6,110.65 178.6,110.2 178.96,109.84 179.36,109.84 179.63,109.57 179.63,109.17 179.87,108.93 179.87,108.7 179.63,108.46 179.63,108.03 179.46,107.86 178.86,107.86 178.55,108.17 178.55,109.53 178.56,109.54 178.56,109.73 178.38,109.91 177.61,109.91 177.49,109.8 177.49,108.09 176.49,107.09 176.49,105.17 176.12,104.8 176.12,104.76
  IN1 w0.208: v2(154.62,70.36) 154.47,70.36 154.27,70.56 154.27,71.57 153.82,72.03 153.82,73.55 153.64,73.73 153.64,74.16 153.82,74.33 153.82,74.71 153.64,74.89 153.64,75.35 153.82,75.53 153.82,75.88 153.64,76.06 153.64,76.36 153.82,76.54 153.82,76.9 153.64,77.08 153.64,77.38 154.05,77.79 154.31,77.79 154.55,78.03 154.55,78.42 154.38,78.6 153.78,78.6 153.6,78.78 153.6,79.22 153.78,79.4 154.74,79.4 154.92,79.58 154.92,79.94 154.74,80.12 154.27,80.12 154.09,80.3 154.09,80.7 154.27,80.88 154.63,80.88 154.81,81.06 154.81,81.25 154.67,81.39 154.67,81.65 154.85,81.83 155.04,81.83 155.22,82.01 155.22,82.37 155.09,82.49 155.09,82.7 155.62,83.23 155.87,83.23 156.19,83.55 156.19,83.82 156.63,84.25 156.89,84.25 157.22,84.58 157.22,84.84 157.61,85.23 157.87,85.23 158.22,85.58 158.22,85.84 158.67,86.29 158.93,86.29 159.18,86.54 159.18,86.81 159.6,87.22 159.86,87.22 160.16,87.51 160.16,87.78 160.05,87.88 160.05,88.13 160.33,88.41 160.58,88.41 160.7,88.3 160.94,88.3 161.21,88.57 161.21,88.77 161.08,88.9 161.08,89.15 161.33,89.39 161.58,89.39 161.65,89.32 161.96,89.32 162.25,89.61 162.25,89.87 162.16,89.97 162.16,90.22 162.45,90.51 162.7,90.51 162.87,90.34 164.57,90.34 175.61,101.38 175.61,103.49 176.12,104 176.12,104.76
  BOTTOM w0.102: v2(154.62,70.36) 154.62,70.29 155.17,69.74 155.17,65.13 155.04,65 JDIMM2.107
DDR_A_MA11: length 75
  TOP w0.102: v2(184.06,104.31) 183.59,104.78 JCPU1.AC1 ; v2(162.62,67.64) 162.22,67.23 162.22,66.32 162.04,66.14 161.76,66.14 161.62,66 161.62,65.7 161.74,65.57 162.11,65.57 162.43,65.89 162.9,65.89 163.02,65.77 163.02,65.5 162.89,65.37 162.53,65.37 162.39,65.23 162.06,65.23 161.94,65.11 JDIMM1.84
  IN1 w0.089: 184.68,103.27 184.34,103.6 184.01,103.6 183.64,103.98 183.64,104.43 183.77,104.56 183.92,104.56 184.06,104.42 v2(184.06,104.31)
  IN1 w0.208: v2(162.62,67.64) 162.66,67.64 163.15,67.15 163.31,67.15 163.43,67.27 163.43,67.84 163.21,68.06 163.1,68.17 163.1,68.41 163.43,68.74 163.43,68.97 163.11,69.29 163.11,69.58 163.43,69.9 163.43,70.21 163.16,70.48 163.16,71.86 164.37,73.07 164.37,74 169.89,79.51 169.89,80 170.42,80.53 170.91,80.53 175.19,84.81 175.19,85.12 175.84,85.78 176.15,85.78 178.85,88.48 178.85,88.85 177.79,89.91 177.79,90.16 177.96,90.33 178.21,90.33 179.32,89.23 179.57,89.23 179.75,89.41 179.75,89.67 178.64,90.78 178.64,91.03 178.83,91.22 179.08,91.22 180.2,90.1 180.45,90.1 180.68,90.33 180.68,90.58 179.57,91.69 179.57,91.94 179.78,92.16 180.03,92.16 181.14,91.05 181.39,91.05 181.61,91.27 181.61,91.53 180.5,92.64 180.5,92.9 182.23,94.63 182.23,95.24 183.88,96.88 184.68,97.69 184.68,103.27
  BOTTOM w0.102: v2(162.62,67.64) 162.65,67.66 163.73,67.66 163.85,67.79 163.85,68.23 163.73,68.35 163.35,68.35 163.04,68.66 163.04,70.32 162.76,70.6 162.67,70.6 161.94,71.33 JDIMM2.84
DDR_A_MA12: length 78.9
  TOP w0.102: v2(185.11,108.3) 184.65,107.84 JCPU1.AD4 ; JDIMM1.83 162.24,71.38 162.56,71.06 162.74,71.06 163.42,70.37 163.42,67.49 163.13,67.2 163.13,66.88 v2(162.62,66.37)
  IN1 w0.089: v2(185.11,108.3) 185.11,107.91 184.62,107.42 184.62,107.07 184.42,106.87 184.42,106.23 183.68,105.5 183.68,104.95 183.83,104.8 184.31,104.8 184.47,104.65 184.47,103.89 185.21,103.14 185.21,102.98
  IN1 w0.208: v2(162.62,66.37) 162.62,63.05 162.44,62.87 161.36,62.87 161.18,62.69 161.18,62.38 161.3,62.25 163.16,62.25 163.34,62.43 163.34,66.43 163.97,67.05 163.97,71.92 164.91,72.85 164.91,73.77 182.15,91.01 182.15,91.75 181.35,92.54 181.35,93 182.76,94.4 182.76,95.01 184.25,96.51 185.21,97.47 185.21,102.98
  BOTTOM w0.102: JDIMM2.83 162.24,65.19 161.97,65.46 161.97,65.64 162.1,65.76 162.28,65.76 162.52,65.52 162.73,65.52 162.86,65.65 162.86,65.83 163.04,66.02 163.28,66.02 164.12,66.85 164.12,67.03 163.94,67.22 163.76,67.22 163.07,66.53 162.78,66.53 v2(162.62,66.37)
DDR_A_MA13: length 71.5
  TOP w0.102: v2(152.17,67.56) 151.9,67.56 151.74,67.72 151.74,68.56 151.32,68.97 151.11,68.97 150.98,69.1 150.98,69.77 151.11,69.9 151.17,69.9 151.3,70.03 151.3,70.42 151.17,70.55 151.01,70.55 150.88,70.68 150.88,70.91 151.01,71.04 151.33,71.04 151.44,71.15 JDIMM1.119 ; JCPU1.V7 178.59,110.84 v2(178.09,111.34)
  IN1 w0.089: 174.27,103.87 174.43,104.03 174.43,108.61 174.65,108.83 175.33,108.83 175.46,108.95 175.46,109.58 175.58,109.71 176.46,109.71 176.67,109.92 177.27,109.92 177.57,110.22 177.57,111.18 177.73,111.34 v2(178.09,111.34)
  IN1 w0.208: 174.27,103.87 174.19,103.78 174.19,102.22 164.71,92.74 162.38,92.74 158.4,88.76 158.4,88.29 152.49,82.38 152.49,80.59 151.99,80.09 151.99,77.02 152.04,76.97 152.04,73.06 152.22,72.88 152.22,72.43 152.04,72.25 152.04,71.39 152.66,70.78 152.66,68.11 152.17,67.63 v2(152.17,67.56)
  BOTTOM w0.102: JDIMM2.119 151.44,65.72 151.57,65.85 152.05,65.85 152.16,65.96 152.16,66.12 152.05,66.24 151.58,66.24 151.44,66.37 151.44,66.6 151.54,66.7 152.02,66.7 152.13,66.82 152.13,66.98 152.02,67.1 151.54,67.1 151.44,67.2 151.44,67.44 151.57,67.56 v2(152.17,67.56)
DDR_A_MA14: length 75.9
  TOP w0.102: JDIMM1.80 163.14,65.04 163.42,65.32 163.42,66.35 163.56,66.49 163.56,67.01 164.14,67.59 164.14,68.27 v2(165.03,69.16) ; JCPU1.AD3 184.63,106.84 v2(185.06,107.27)
  IN1 w0.089: v2(185.06,107.27) 185.17,107.27 185.3,107.15 185.3,106.92 185.17,106.8 184.86,106.8 184.68,106.62 184.68,106.13 184.87,105.94 184.87,104.46 186.28,103.05 186.28,102.84
  IN1 w0.208: 186.28,102.84 186.28,96.99 185.63,96.34 185.63,95.98 186.27,95.33 186.27,95.08 186.1,94.91 185.85,94.91 185.13,95.62 184.89,95.62 184.71,95.45 184.71,95.21 186.27,93.65 186.27,93.4 186.07,93.2 185.82,93.2 184.24,94.77 184.03,94.77 183.84,94.59 183.84,93.98 182.78,92.92 182.78,92.66 183,92.45 183.25,92.45 184.28,93.49 184.54,93.49 185.35,92.68 185.35,92.42 185.1,92.18 184.85,92.18 184.48,92.55 184.23,92.55 183.99,92.31 183.99,92.06 184.37,91.67 184.37,91.43 184.2,91.27 183.97,91.27 183.64,91.59 183.4,91.59 183.22,91.41 183.22,91.17 183.49,90.9 183.49,90.55 182.74,89.8 182.74,89.8 182.44,89.8 182.03,89.39 182.03,89.09 181.44,88.5 181.13,88.5 180.54,87.9 180.54,87.59 179.95,87.01 179.65,87.01 178.98,86.34 178.98,86.03 178.47,85.52 178.3,85.52 176.07,83.29 175.93,83.29 171.18,78.54 171.18,78.4 170.62,77.85 170.49,77.85 169.96,77.32 169.96,77.18 169.42,76.64 169.28,76.64 168.61,75.97 168.61,75.84 168.12,75.34 167.98,75.34 167.35,74.71 167.35,74.57 166.84,74.06 166.72,74.06 166.2,73.55 166.2,73.33 166.41,73.12 166.41,72.85 165.03,71.47 165.03,71.21 165.35,70.89 165.35,70.57 165.03,70.25 165.03,69.95 165.33,69.66 165.33,69.34 165.15,69.16 v2(165.03,69.16)
  BOTTOM w0.102: v2(165.03,69.16) 164.85,68.98 164.67,68.98 164.49,69.16 164.49,69.34 164.71,69.56 164.71,69.74 164.58,69.87 164.4,69.87 164.17,69.64 163.99,69.64 163.86,69.76 163.86,69.94 164.08,70.16 164.08,70.31 163.14,71.25 JDIMM2.80
DDR_A_MA15: length 74.6
  TOP w0.102: JDIMM1.78 163.74,65.94 163.98,66.18 163.98,66.84 v2(165.03,67.89) ; JCPU1.AD2 184.59,105.89 v2(185.06,106.36)
  IN1 w0.089: v2(185.06,106.36) 185.06,104.54 186.81,102.79 186.81,102.66
  IN1 w0.208: 186.81,102.66 186.81,93.11 178.69,84.99 178.52,84.99 176.29,82.76 176.15,82.76 171.71,78.32 171.71,78.18 166.95,73.42 166.95,72.63 165.89,71.57 165.89,67.61 166.22,67.27 166.22,63.72 166.4,63.54 168.56,63.54 168.73,63.37 168.73,62.83 168.56,62.65 165.75,62.65 165.57,62.83 165.57,67.18 165.03,67.72 v2(165.03,67.89)
  BOTTOM w0.102: JDIMM2.78 163.74,71.2 165.46,69.47 165.46,68.07 165.29,67.89 v2(165.03,67.89)
DDR_A_RAS#: length 75.9
  TOP w0.102: v2(177.1,109.31) 177.59,109.8 JCPU1.U6 ; JDIMM1.110 154.14,65.09 154.32,65.27 154.76,65.27 155.17,65.67 155.17,66.61 154.68,67.09 v2(154.66,67.09)
  IN1 w0.089: 174.72,103.52 174.72,103.79 174.88,103.95 174.88,104.59 175.46,105.16 175.46,108.25 176.12,108.91 176.31,108.91 176.71,109.31 v2(177.1,109.31)
  IN1 w0.208: 174.72,103.52 174.72,102 164.93,92.2 162.6,92.2 158.94,88.54 158.94,88.07 153.02,82.15 153.02,80.37 152.52,79.87 152.52,77.24 152.57,77.19 152.57,73.28 152.75,73.11 152.75,71.44 153.19,71 153.19,67.89 152.24,66.94 151.78,66.94 151.18,66.34 151.18,63.72 151.6,63.3 153.58,63.3 154.09,63.81 154.09,66.47 154.66,67.04 v2(154.66,67.09)
  BOTTOM w0.102: JDIMM2.110 154.14,71.43 153.97,71.26 153.97,68.19 154.66,67.5 v2(154.66,67.09)
DDR_A_WE#: length 71.4
  TOP w0.102: v2(177.06,110.31) JCPU1.U7 ; v2(152.11,70.09) 152.11,70.31 152.21,70.41 152.57,70.41 152.67,70.31 152.67,69.93 152.86,69.74 153.11,69.74 153.24,69.87 JDIMM1.113
  IN1 w0.089: 173.62,103.63 173.62,108.63 173.89,108.9 174.31,108.9 174.45,109.04 174.45,109.74 174.63,109.92 176.22,109.92 176.73,110.43 176.94,110.43 v2(177.06,110.31)
  IN1 w0.208: 173.62,103.63 173.66,103.59 173.66,102.44 164.55,93.33 161.8,93.33 161.61,93.14 161.61,92.73 161.43,92.55 161.14,92.55 161.05,92.63 160.8,92.63 160.53,92.36 160.53,92.11 160.64,92.01 160.64,91.76 160.39,91.51 160.14,91.51 160.04,91.61 159.78,91.61 159.6,91.43 159.6,91.17 159.7,91.07 159.7,90.81 159.51,90.62 159.26,90.62 159.16,90.73 158.9,90.73 158.71,90.55 158.71,90.29 158.81,90.19 158.81,89.94 158.62,89.75 158.37,89.75 158.27,89.85 158.01,89.85 157.83,89.66 157.83,89.4 157.94,89.29 157.94,89.04 157.75,88.85 157.5,88.85 157.39,88.96 157.13,88.96 156.95,88.78 156.95,88.52 157.26,88.21 157.26,87.95 157.07,87.77 156.82,87.77 156.78,87.81 156.53,87.81 156.33,87.61 156.33,87.36 156.4,87.3 156.4,87.04 156.21,86.85 155.96,86.85 155.89,86.92 155.64,86.92 155.43,86.71 155.43,86.46 155.49,86.39 155.49,86.14 155.28,85.93 155.03,85.93 154.72,86.24 154.47,86.24 154.19,85.96 154.19,85.71 154.45,85.45 154.45,85.09 151.95,82.6 151.95,80.81 151.3,80.16 151.3,79.8 151.46,79.65 151.46,76.8 151.51,76.75 151.51,71.1 151.66,70.95 151.66,70.26 151.84,70.08 152.1,70.08 v2(152.11,70.09)
  BOTTOM w0.102: JDIMM2.113 153.24,69.03 152.17,70.09 v2(152.11,70.09)
DDR_B_BS0: length 92.6
  TOP w0.102: v2(153.74,56.06) 153.31,55.63 153.31,54.95 153.19,54.83 152.88,54.83 152.75,54.95 152.75,55.92 153.52,56.68 153.82,56.68 154.14,56.36 154.34,56.36 154.51,56.53 154.51,56.82 154.44,56.88 JDIMM3.109 ; v2(175.06,110.31) JCPU1.R7
  IN3 w0.089: v2(175.06,110.31) 175.26,110.31 175.82,109.74 178.17,109.74 178.49,109.42 178.49,104.19 177.09,102.78 177.09,102.6
  IN3 w0.178: v2(153.74,56.06) 153.88,56.2 153.88,57.14 154.52,57.78 154.52,59.02 154.81,59.3 154.81,63.52 155.66,64.37 155.66,71.09 158.56,73.99 158.56,75.21 160.6,77.26 160.6,77.92 161.69,79.01 161.69,79.31 163.19,80.81 163.42,80.81 163.7,80.53 163.85,80.53 171.09,87.77 171.09,87.98 170.94,88.12 170.74,88.12 167.47,84.86 167.27,84.86 167.13,85 167.13,85.2 172.59,90.67 172.59,91.07 177.09,95.57 177.09,102.6
  BOTTOM w0.102: JDIMM4.109 154.44,50.77 154.06,51.14 154.06,51.16 153.31,51.91 153.31,55.63 v2(153.74,56.06)
DDR_B_BS1: length 92.9
  TOP w0.102: v2(174.06,111.31) JCPU1.P8 ; v2(153.73,53.53) 153.31,53.12 153.31,51.98 153.79,51.51 154.14,51.51 154.74,50.9 JDIMM3.108
  IN3 w0.089: 176.07,102.58 177.47,103.98 177.47,108.49 177.28,108.68 175.48,108.68 175.29,108.87 174.96,108.87 174.62,109.21 174.62,110.72 174.06,111.28 v2(174.06,111.31)
  IN3 w0.178: v2(153.73,53.53) 153.58,53.38 153.47,53.38 153.29,53.2 153.29,52.57 153.13,52.41 152.92,52.41 152.76,52.57 152.76,53.58 153.24,54.06 153.24,54.52 152.76,55 152.76,57.46 153.35,58.04 153.35,60.4 153.8,60.85 153.8,63.95 154.55,64.69 154.55,65.02 154.18,65.39 154.18,71.05 157.56,74.43 157.56,75.63 159.61,77.67 159.61,78.33 160.7,79.42 160.7,79.72 162.99,82.02 162.99,82.48 171.6,91.08 171.6,91.49 175.05,94.94 175.05,95.16 174.9,95.32 174.63,95.32 172.01,92.7 171.78,92.7 171.62,92.86 171.62,93.09 176.07,97.54 176.07,102.58
  BOTTOM w0.102: v2(153.73,53.53) 154.74,54.54 JDIMM4.108
DDR_B_BS2: length 86.1
  TOP w0.102: v2(164.34,53.51) 164.39,53.51 164.91,54.03 164.91,55.73 163.44,57.2 JDIMM3.79 ; v2(182.06,113.31) JCPU1.AA9
  IN3 w0.089: v2(182.06,113.31) 181.69,112.94 181.69,112.23 182.02,111.89 186,111.89 186.43,111.46 186.43,110.88 186.67,110.64 186.67,104.99 186.56,104.88 186.56,104.08
  IN3 w0.178: v2(164.34,53.51) 164.79,53.05 164.79,52.91 164.96,52.74 165.2,52.74 165.36,52.91 165.36,53.5 164.89,53.97 164.89,57.2 166.37,58.68 166.37,60.59 169.97,64.18 169.97,69.96 170.71,70.7 170.71,71.51 178.41,79.22 178.41,80.18 180.48,82.25 180.48,83.06 180.66,83.24 181.07,83.24 186.7,88.87 186.7,103.94 186.56,104.08
  BOTTOM w0.102: JDIMM4.79 163.44,51.44 163.85,51.85 163.85,53.02 v2(164.34,53.51)
DDR_B_CAS#: length 91.5
  TOP w0.102: v2(174.06,110.31) JCPU1.P7 ; v2(151.57,54.6) 151.42,54.45 151.23,54.45 151.14,54.53 151.14,56.06 151.76,56.68 152.22,56.68 152.64,57.1 JDIMM3.115
  IN3 w0.089: 175.56,102.58 175.56,102.76 176.68,103.88 176.68,107.59 176.34,107.93 175.9,107.93 175.68,108.15 175.68,108.21 175.21,108.68 174.89,108.68 174.43,109.14 174.43,109.93 v2(174.06,110.31)
  IN3 w0.178: 175.56,102.58 175.56,97.74 167.68,89.86 167.68,89.61 167.88,89.41 168.13,89.41 170.58,91.86 170.87,91.86 171.1,91.63 171.1,91.28 162.49,82.68 162.49,82.22 160.2,79.93 160.2,79.63 158.98,78.41 158.23,78.41 157.04,77.22 157.04,77.01 157.18,76.86 157.39,76.86 158.08,77.55 158.27,77.55 158.42,77.4 158.42,77.19 157.06,75.83 157.06,74.64 153.67,71.24 153.67,64.73 153.3,64.36 153.3,61.05 152.84,60.59 152.84,58.28 152.25,57.69 152.25,54.8 152.64,54.42 152.64,54.18 152.47,54.01 152.23,54.01 151.63,54.6 v2(151.57,54.6)
  BOTTOM w0.102: JDIMM4.115 152.64,50.85 152.04,51.45 152.04,54.13 v2(151.57,54.6)
