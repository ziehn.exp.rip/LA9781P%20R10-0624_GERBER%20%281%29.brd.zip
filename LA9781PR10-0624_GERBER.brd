# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_BITCLK: length 6.4
  BOTTOM w0.102: UH1.B25 77.96,58.45 77.86,58.36 77.86,56.09 77.93,56.03 77.93,55.19 78.49,54.63 78.5,54.63 v1(78.96,54.17) 79.59,54.17 RH65.2
PCH_AZ_CODEC_BITCLK: length 118.2
  TOP w0.102: v2(15.45,87.21) 15.37,87.3 JIO1.53
  IN3 w0.127: v2(15.45,87.21) 15.45,86.31 15.92,85.84 16.21,85.84 18.82,83.23 18.82,78.98 21.3,76.51 21.3,73.64 27.13,67.81 27.13,65.28 24.94,63.1 24.94,57.25 25.35,56.84 25.35,56.84 25.61,56.58 25.61,55.35 29.18,51.78 35.99,51.78 37.39,50.38 44.19,50.38 45.21,51.4 47.27,51.4 58.95,39.71 67.85,39.71 69.02,38.55 76.99,38.55 79.37,40.93 v2(79.37,42.06)
  BOTTOM w0.102: RH65.1 CH9.1 81.46,52.77 v1(81.68,52.55) 82.78,51.45 82.78,50.84 79.39,47.45 79.39,43.23 79.48,43.14 79.48,42.16 v2(79.37,42.06)
PCH_AZ_CODEC_RST#: length 111.4
  TOP w0.102: v2(17.31,86.39) 17.31,86.08 16.12,84.9 JIO1.61
  IN3 w0.127: v2(78.13,42.06) 78.13,41.19 76.62,39.69 69.32,39.69 68.27,40.73 59.83,40.73 48,52.56 44.94,52.56 43.77,51.4 37.87,51.4 36.47,52.79 29.6,52.79 26.63,55.77 26.63,56.58 26.63,57 26.36,57.26 25.96,57.67 25.96,62.07 28.14,64.25 28.14,69.76 26.71,71.2 26.71,73.84 20.22,80.33 20.22,83.48 v2(17.31,86.39)
  BOTTOM w0.102: v2(78.13,42.06) 78.13,42.46 76.27,44.31 v1(76.27,45.85) 76.27,46.6 77.95,48.27 RH63.1
PCH_AZ_CODEC_SDIN0: length 97.4
  TOP w0.102: v2(16.05,87.2) 15.55,86.7 JIO1.55
  IN4 w0.102: v2(76.3,63.08) 76.22,63.08 75.87,62.73 75.87,62.22 75.54,61.89 75.08,61.89 74.75,62.22 74.75,62.95 74.09,63.61 73.68,63.61 72.74,64.55 69.65,64.55 69.25,64.95 69.25,65.12 68.55,65.82 68.55,68.42 68.5,68.47 68.5,74.46 69.34,75.3 69.34,77.38 68.1,78.63 68.1,80.51 68.73,81.14 68.73,82.89 68.3,83.33 68.3,85.36 60.94,92.72 54.84,92.72 53.85,93.72 43.87,93.72 43.34,93.18 39.86,93.18 37.72,91.05 27.05,91.05 26.57,90.56 24.09,90.56 22.46,92.19 20.19,92.19 19.91,92.47 16.76,92.47 15.57,91.28 15.57,88.63 16.05,88.15 v2(16.05,87.2)
  BOTTOM w0.089: v2(76.3,63.08) 76.5,63.08 UH1.L22
PCH_AZ_CODEC_SDOUT: length 108.2
  TOP w0.102: v2(16.26,86.51) 15.84,86.1 JIO1.57
  IN3 w0.127: v2(78.76,42.06) 78.76,41.09 76.76,39.08 69.21,39.08 68.06,40.22 59.62,40.22 47.79,52.05 45.15,52.05 43.98,50.89 37.62,50.89 36.22,52.29 29.39,52.29 26.12,55.56 26.12,56.79 25.91,56.99 25.45,57.46 25.45,62.89 27.63,65.07 27.63,69.55 26.2,70.99 26.2,73.58 19.46,80.32 19.46,83.31 16.26,86.51 v2(16.26,86.51)
  BOTTOM w0.102: v2(78.76,42.06) v1(78.76,43.03) 78.89,43.15 78.89,48.76 RH59.1
PCH_AZ_CODEC_SYNC: length 105.4
  TOP w0.102: JIO1.59 16.04,85.5 16.74,86.2 16.74,86.5 v2(17.33,87.1)
  IN3 w0.127: v2(74.45,42.69) 62.48,42.69 57.14,48.03 53.75,48.03 47.04,54.74 46.39,54.74 43.56,51.91 38.08,51.91 36.68,53.3 29.82,53.3 27.13,55.99 27.13,56.37 27.13,56.37 27.13,56.94 27.13,57.21 26.87,57.47 26.47,57.88 26.47,61.85 29.16,64.55 29.16,69.46 27.21,71.41 27.21,75.88 24.36,78.74 24.36,83.05 21.44,85.96 19.64,85.96 19.55,86.06 18.37,86.06 v2(17.33,87.1)
  BOTTOM w0.102: RH61.1 75.41,48.1 74.36,47.04 74.36,44.43 74.45,44.34 v1(74.45,43.8) v2(74.45,42.69)
PCH_AZ_RST#: length 7.7
  BOTTOM w0.076: 77.48,57.82 77.48,58.04 77.24,58.28 77.24,58.56 77.54,58.87 77.54,59.33 UH1.C24
  BOTTOM w0.102: RH63.2 v1(77.95,53.06) 77.95,53.75 77.77,53.92 77.77,54.65 77.53,54.89 77.53,55.84 77.48,55.89 77.48,57.82
PCH_AZ_SDOUT: length 10.7
  BOTTOM w0.102: UH1.A24 77.53,58.42 77.67,58.28 77.67,55.99 77.72,55.94 77.72,55.11 78.21,54.63 78.21,54.38 78.97,53.62 RH35.2 79.75,51.25 79.75,51.08 79.98,50.85 v1(79.98,50.72) RH45.2 RH59.2
PCH_AZ_SYNC: length 9.2
  BOTTOM w0.076: UH1.A22 76.72,58.22 77.1,57.84
  BOTTOM w0.102: RH61.2 75.34,50.25 75.34,51.19 RH41.2 76.53,52.39 v1(76.53,52.97) 76.53,54.29 77.14,54.9 77.14,55.66 77.1,55.7 77.1,57.84
PCH_BATLOW#: length 12.7
  TOP w0.089: 68.53,61.89 68.48,61.94 67.38,61.94
  TOP w0.102: 67.38,61.94 65.99,61.94 65.51,61.46 64.87,61.46 64.58,61.16 64.58,60.73 v1(64.28,60.43) 62.58,58.74 61.06,58.74 60.86,58.53 60.7,58.53 60.04,57.87 RH112.2 ; 68.53,61.89 69.72,61.89 v2(69.9,62.07)
  BOTTOM w0.102: UH1.K7 70.34,62.51 v2(69.9,62.07)
PCH_CL_CLK1: length 179.7
  IN4 w0.102: 83.77,75.71 83.77,75.4 83.46,75.1 83.46,73.9 83.11,73.55 82.79,73.55 80.38,71.13 79.58,71.13 79.02,70.57 78.33,70.57 78.15,70.4 77.14,70.4 76.48,71.06 75.86,71.06 75.61,71.31 74.17,71.31 72.78,69.91 72.16,69.91 71.75,69.51 v2(71.75,69.51)
  IN4 w0.109: 83.77,75.71 83.77,76.31 84.47,77.01 84.47,77.5 85.52,78.55 85.52,80.41 87.08,81.98 87.08,107 90.13,110.04 90.13,115.32 91.11,116.29 91.11,120.84 90.35,121.6 90.35,123.26 88.48,125.12 84.83,125.12 78.42,131.53 75.31,131.53 73.33,133.52 73.33,136.67 74.13,137.47 74.13,139.74 73.6,140.28 73.6,147.42 75.24,149.06 75.24,154.33 77.18,156.27 77.18,158.84 79.6,161.25 80.68,161.25 81.44,162.01 81.44,162.73 84.83,166.11 84.83,167.07 85.44,167.69 90.7,167.69 90.91,167.48 95.32,167.48 95.6,167.75 97.2,167.75 97.86,167.09 108.83,167.09 109.02,167.28 112.01,167.28 112.85,166.44 112.85,164.99 v2(113.08,164.76)
  BOTTOM w0.102: UH1.AF11 71.75,69.42 v2(71.75,69.51) ; JMINI2.45 131.49,167.24 130.86,166.61 130.1,166.61 128.32,164.83 122.2,164.83 122.07,164.71 114.15,164.71 114.02,164.83 113.16,164.83 v2(113.08,164.76)
PCH_CL_DATA1: length 182.4
  IN4 w0.102: 83.26,75.3 83.26,74 83.01,73.75 82.71,73.75 80.3,71.34 79.66,71.34 79.56,71.44 78.36,71.44 78.23,71.31 75.89,71.31 75.69,71.51 74.09,71.51 72.69,70.12 72.08,70.12 71.87,69.91 71.47,69.91 71.17,69.61 v2(71.17,69.51)
  IN4 w0.109: 83.26,75.3 83.26,76.49 83.87,77.11 83.87,82.96 86.59,85.67 86.59,107.19 89.64,110.25 89.64,115.59 90.17,116.12 90.17,117.87 90.45,118.15 90.45,120.69 89.71,121.43 89.71,123.2 89.18,123.74 85.52,123.74 78.76,130.49 75.66,130.49 72.84,133.31 72.84,136.87 73.64,137.68 73.64,139.54 73.11,140.07 73.11,147.62 74.75,149.26 74.75,154.53 76.69,156.48 76.69,159.21 79.84,162.35 80.37,162.35 84.34,166.31 84.34,167.27 85.96,168.9 93.34,168.9 94,168.25 97.41,168.25 98.07,167.58 104.65,167.58 105.13,168.06 105.88,168.06 106.17,167.77 112.25,167.77 113.34,166.68 113.34,165.42 113.69,165.07 v2(113.69,164.33)
  BOTTOM w0.102: v2(113.69,164.33) 114.37,163.64 121.58,163.64 122.37,164.43 128.49,164.43 130.27,166.21 131.11,166.21 132.29,167.38 JMINI2.47 ; UH1.AF10 71.17,69.41 v2(71.17,69.51)
PCH_CL_RST1#: length 193.6
  IN4 w0.102: v2(70.58,69.5) 70.58,69.46 70.92,69.13 72.94,69.13 73.4,69.58 78.69,69.58 79.96,70.85 80.39,70.85 82.6,73.06 84.43,73.06 85.16,73.8
  IN4 w0.109: v2(113,163.97) 112.8,163.97 112.32,164.45 112.32,165.9 111.43,166.79 109.22,166.79 109.02,166.59 105.64,166.59 105.08,166.03 102.39,166.03 101.87,165.51 97.94,165.51 96.7,166.75 90.95,166.75 90.5,167.2 85.65,167.2 85.32,166.87 85.32,165.91 81.93,162.52 81.93,161.3 80,159.37 79.22,159.37 78.51,158.66 78.51,156.91 76.76,155.15 76.76,142.86 75.77,141.87 74.52,141.87 74.09,141.44 74.09,140.48 74.63,139.95 74.63,137.27 73.82,136.46 73.82,133.72 75.51,132.02 78.62,132.02 84.87,125.78 88.53,125.78 90.84,123.46 90.84,121.8 91.6,121.04 91.6,116.09 90.65,115.14 90.65,109.87 88.42,107.63 88.42,104.05 87.57,103.21 87.57,81.77 86.03,80.23 86.03,78.32 85.65,77.94 85.65,76.42 86.36,75.71 86.36,74.99 85.16,73.8
  BOTTOM w0.102: v2(70.58,69.5) 70.34,69.26 UH1.AF7 ; R709.1 133.2,171.21 133.93,171.95 134.78,171.95 v1(135.38,171.35) 135.38,167.58 134.34,166.54 132.02,166.54 131.28,165.8 130.43,165.8 128.63,164 122.51,164 121.75,163.23 113.74,163.23 v2(113,163.97)
PCH_CLK_BIASREF: length 5.2
  BOTTOM w0.102: RH165.1 89.98,74.36 87.49,71.87 86.01,71.87 UH1.AN44
PCH_CRT_BLU: length 62
  IN1 w0.109: v2(92.05,107.58) 92.35,107.58 93.68,106.25 93.68,100.31 95.45,98.54 95.45,88.41 95.65,88.21 95.65,86.67 95.45,86.47 95.45,84.65 95.27,84.47 95.27,77.46 93.55,75.73 93.55,73.01 95.63,70.93 95.63,69.05 95.83,68.85 95.83,67.03 94.95,66.15 94.95,64.21 94.28,63.54 94.28,61.81 93.24,60.77 v2(92.38,60.77)
  BOTTOM w0.102: v2(92.38,60.77) 92.05,60.44 90.71,60.44 RH115.2 ; U19.19 92.75,106.94 92.1,107.58 v2(92.05,107.58)
  BOTTOM w0.178: UH1.T45 86.59,64.76 87.12,64.76 87.32,64.55 87.32,64.07 88.14,63.26 88.14,63.21 90.13,61.21 RH115.2
PCH_CRT_DDC_CLK: length 56.7
  IN1 w0.109: v2(91.39,103.39) 91.33,103.33 91.33,84.25 92,83.58 92,77.16 91.41,76.58 91.41,71.89 92.83,70.47 92.83,65.6 90.7,63.48 90.7,60.14 v2(90.19,59.63)
  BOTTOM w0.102: v2(90.19,59.63) 90.17,59.63 89.81,59.98 89.03,59.98 88.21,60.8 88.21,61.58 87.17,62.62 86.74,62.62 86.47,62.89 86.39,62.89 86,63.28 UH1.M43 ; U19.15 92.17,105.34 92.15,105.32 91.34,105.32 R97.1 v1(91.11,104.04) 91.11,103.67 v2(91.39,103.39)
PCH_CRT_DDC_DAT: length 56.8
  IN1 w0.109: v2(90.71,101.13) 90.71,83.9 90.99,83.62 90.99,79.46 91.29,79.17 91.29,77.32 90.8,76.83 90.8,70.2 92.21,68.79 92.21,65.86 89.56,63.21 v2(89.56,60.62)
  BOTTOM w0.102: U19.16 91.74,105.74 R125.1 90.57,105.83 89.51,105.83 88.87,105.19 v1(88.87,103.76) 88.87,102.97 v2(90.71,101.13) ; UH1.M45 86.44,63.2 86.55,63.09 86.56,63.09 86.82,62.83 87.26,62.83 89.47,60.62 v2(89.56,60.62)
PCH_CRT_GRN: length 57.6
  IN1 w0.109: v2(92.05,106.9) 91.64,106.49 91.64,105.93 92.45,105.13 92.45,97.75 92.22,97.52 92.22,88.25 92.23,88.25 92.96,87.52 92.96,83.92 92.89,83.85 92.89,76.82 92.31,76.24 92.31,72.5 93.7,71.11 93.7,64.71 92.71,63.72 v2(92.71,61.43)
  BOTTOM w0.102: U19.18 92.41,106.54 v2(92.05,106.9) ; v2(92.71,61.43) 92.66,61.48 v1(92.19,61.48) 90.69,61.48 RH116.2
  BOTTOM w0.178: UH1.U44 86.49,65.34 86.8,65.04 87.23,65.04 87.7,64.57 87.7,64.09 89.12,62.68 89.5,62.68 RH116.2
PCH_CRT_HSYNC: length 43.8
  TOP w0.102: RH94.1 88.62,67.04 89.03,67.45 v1(90.23,67.45) 90.85,67.45 v2(91.67,68.26)
  IN1 w0.109: v2(91.77,104.05) 90.98,104.05 90.69,103.76 90.69,102.17 90.09,101.57 90.09,83.6 90.37,83.33 90.37,77.28 90.18,77.09 90.18,73.07 89.76,72.66 89.76,72.06 90.18,71.64 90.18,69.88 91.59,68.46 91.59,68.34 v2(91.67,68.26)
  BOTTOM w0.102: U19.13 92.25,104.54 v2(91.77,104.05)
PCH_CRT_RED: length 58
  IN1 w0.109: v2(92.28,106.16) 92.35,106.16 93.06,105.45 93.06,98.03 93.27,97.83 93.95,97.83 94.08,97.7 94.08,97.17 93.95,97.04 93.27,97.04 93.06,96.84 93.06,88.48 94.05,87.49 94.05,84.04 93.58,83.56 93.58,76.64 92.93,75.99 92.93,72.76 94.36,71.33 94.36,69.3 95.2,68.47 95.2,67.27 94.33,66.41 94.33,64.47 93.61,63.75 93.61,62.46 v2(93.62,62.45)
  BOTTOM w0.102: v2(93.62,62.45) 92.1,62.45 91.95,62.6 90.59,62.6 RH117.2 ; v2(92.28,106.16) 92.3,106.14 U19.17
  BOTTOM w0.178: UH1.V45 86.51,65.72 86.91,65.32 87.35,65.32 87.98,64.68 87.98,64.2 89.13,63.06 RH117.2
PCH_CRT_VSYNC: length 45.6
  TOP w0.102: RH95.1 88.8,65.77 v1(90.09,65.77) 90.52,65.77 91.67,66.92 v2(91.67,66.99)
  IN1 w0.109: v2(91.67,66.99) 89.35,69.31 89.35,72.88 89.76,73.29 89.76,77.26 89.94,77.43 89.94,83.15 89.68,83.41 89.68,101.74 90.28,102.35 90.28,103.96 91.01,104.69 v2(91.74,104.69)
  BOTTOM w0.102: v2(91.74,104.69) 91.99,104.94 U19.14
PCH_DDPD_AUX: length 111.1
  IN4 w0.117: v2(85.02,61.59) 84.88,61.72 84.75,61.72 84.64,61.58 84.64,61.33 84.82,61.16 85.41,61.16 86.21,60.36 86.21,59.22 85.08,58.09 85.08,55.73 83.95,54.61 83.95,54.02 82.44,52.51 79.7,52.51 79.17,51.97 77.01,51.97 76.76,51.72 75.81,51.72 74.57,50.48 69.81,50.48 68.61,51.67 64.42,51.67 63.88,52.2 62.31,52.2 60.6,53.92 60.6,55.64 59.66,56.58 59.66,58.12 59.83,58.3 59.83,81.86 59.48,82.22 59.48,83.01 59.48,83.1 57.4,85.18 56.86,85.18 v2(56.79,85.11)
  BOTTOM w0.102: UH1.J44 85.54,62.09 85.04,61.59 v2(85.02,61.59) ; v2(56.79,85.11) 56.51,85.39 56.51,85.4 56.49,85.42 56.42,85.42 56.15,85.7 56.15,87.27 47.43,95.99 42.76,95.99 39.46,99.29 38.87,99.87 38.87,103.45 32.63,109.7 32.63,112.24 C533.1
PCH_DDPD_AUX#: length 111.1
  IN4 w0.117: v2(84.37,62.07) 84.4,62.04 84.4,61.24 84.72,60.92 85.31,60.92 85.97,60.27 85.97,59.32 84.84,58.19 84.84,55.83 83.72,54.7 83.72,54.12 82.34,52.74 79.6,52.74 79.07,52.21 76.91,52.21 76.66,51.96 75.72,51.96 74.47,50.71 69.9,50.71 68.71,51.91 64.51,51.91 63.98,52.44 62.41,52.44 60.83,54.02 60.83,55.74 59.89,56.68 59.89,58.03 60.07,58.2 60.07,81.96 59.71,82.31 59.71,82.91 59.71,83.2 57.5,85.42 57.19,85.42 57.06,85.55 56.8,85.55 56.72,85.64 56.72,85.79 v2(56.79,85.87)
  BOTTOM w0.102: C534.1 33.17,112.59 32.97,112.59 32.84,112.46 32.84,109.79 39.09,103.54 39.09,99.96 39.61,99.44 42.85,96.2 47.52,96.2 56.36,87.36 56.36,85.79 56.51,85.64 56.67,85.64 56.79,85.76 v2(56.79,85.87) ; v2(84.37,62.07) 84.37,62.02 84.51,61.88 84.7,61.88 84.76,61.94 84.76,62.12 84.86,62.22 85.01,62.22 85.1,62.13 UH1.J42
PCH_DDPD_AUX#_C: length 3.5
  BOTTOM w0.102: U629.29 34.51,115.09 34.42,115 34.42,114.65 33.97,114.2 33.6,114.2 33.59,114.19 33.04,114.19 32.93,114.07 32.93,113.74 C534.2
PCH_DDPD_AUX_C: length 3.5
  BOTTOM w0.102: U629.30 34.11,115.09 34.21,115 34.21,114.74 33.88,114.41 v3(33.32,114.41) 32.97,114.41 32.71,114.16 32.71,113.78 C533.2
PCH_DDPD_CTRLCLK: length 119.5
  IN4 w0.089: 86.1,62.85 86.1,62.86 86.13,62.89 86.13,63.14 85.78,63.49 84.56,63.49 84.3,63.74 83.82,63.74 83.7,63.62 83.7,63.53 83.79,63.44 83.97,63.44 84.05,63.36 84.05,63.27 v2(84.24,63.08)
  IN4 w0.117: 86.1,62.85 86.1,61.17 86.71,60.57 86.71,58.99 85.94,58.23 85.94,55.86 84.58,54.5 84.58,53.94 82.62,51.98 80.06,51.98 79.55,51.47 77.29,51.47 77.04,51.22 76.17,51.22 74.89,49.93 66.26,49.93 65.06,51.13 63.44,51.13 63.16,51.41 61.97,51.41 59.54,53.84 59.54,55.97 59.14,56.37 59.14,58.34 59.33,58.53 59.33,81.45 57.1,83.68 56.87,83.68 v2(56.64,83.91)
  BOTTOM w0.102: U629.25 36.11,115.05 36.19,114.98 36.19,114.42 36.59,114.02 37.09,114.02 37.35,113.77 37.35,113.69 R126.1 37.25,113.35 37.43,113.17 37.43,107.47 36.94,106.99 36.94,106.43 39.76,103.61 39.76,99.97 42.99,96.75 47.69,96.75 57.34,87.1 57.34,84.02 57.02,83.71 56.84,83.71 v2(56.64,83.91) ; v2(84.24,63.08) 84.5,63.35 UH1.N40
PCH_DDPD_CTRLDATA: length 120.5
  IN4 w0.089: v2(83.03,63.08) 83.03,63.08 83.51,63.56 83.51,63.66 83.51,63.66 83.51,63.7 83.74,63.93 84.38,63.93 84.63,63.68 85.86,63.68 86.32,63.22 86.32,62.89 86.34,62.86 86.34,62.85
  IN4 w0.117: v2(56.64,83.33) 56.77,83.45 56.77,83.44 57,83.44 59.1,81.35 59.1,58.63 58.9,58.44 58.9,56.27 59.3,55.87 59.3,53.74 61.87,51.17 63.07,51.17 63.34,50.89 64.97,50.89 66.17,49.7 74.98,49.7 76.27,50.98 77.14,50.98 77.39,51.24 79.65,51.24 80.16,51.75 82.72,51.75 84.82,53.84 84.82,54.4 86.18,55.77 86.18,58.13 86.94,58.89 86.94,60.67 86.34,61.27 86.34,62.85
  BOTTOM w0.102: U629.24 36.51,115.09 36.4,114.98 36.4,114.51 36.68,114.24 37.18,114.24 37.57,113.86 37.57,113.65 R128.1 37.64,113.12 37.64,107.38 37.16,106.9 37.16,106.52 39.98,103.7 39.98,100.06 43.08,96.97 47.78,96.97 57.56,87.19 57.56,83.95 57.11,83.5 56.82,83.5 v2(56.64,83.33) ; UH1.N38 83.31,63.36 v2(83.03,63.08)
PCH_DPWROK: length 222.9
  TOP w0.076: v2(72.41,62.5) 72.08,62.17 72.08,61.84 71.83,61.58 69.9,61.58 69.39,61.07 68.76,61.07
  TOP w0.102: 68.76,61.07 67.97,61.07 67.79,60.9 65.16,60.9 v2(65.04,61.02) ; v2(214.96,67.5) 215.34,67.5 216.78,66.06 216.78,65.67 221.43,61.02 225.17,61.02 226.21,59.98 236.85,59.98 237.11,60.24 240.49,60.24 242.34,58.38 v2(242.62,58.38)
  IN3 w0.127: v2(67.18,53.3) 67.18,52.79 69.56,50.42 76.12,50.42 77.11,49.43 79.59,49.43 79.87,49.71 91.18,49.71 92.4,48.49 98.32,48.49 99.02,47.79 100.65,47.79 101.89,46.55 111.09,46.55 112.59,45.05 123.28,45.05 124.83,43.5 141.1,43.5 141.81,44.21 145.44,44.21 145.45,44.2 145.7,44.2 145.96,43.94 145.96,43.69 148.18,41.47 165.24,41.47 166.08,42.3 166.98,42.3 170.88,46.2 189.42,46.2 191.64,48.43 193.7,48.43 200.74,55.46 205.21,55.46 211.21,61.46 211.21,63.39 214.12,66.3 214.12,66.66 v2(214.96,67.5)
  BOTTOM w0.102: v2(67.18,53.3) 64.78,55.7 v1(64.78,55.99) 64.78,57.1 64.57,57.32 63.69,57.32 R808.1 63,58 63,59.39 RH79.1 62.7,60.48 63.38,60.48 63.5,60.59 64.61,60.59 v2(65.04,61.02) ; v2(72.41,62.5) 72.68,62.76 UH1.L13 ; R802.1 244.96,59.98 243.36,58.38 v2(242.62,58.38)
PCH_GPIO3: length 14.4
  TOP w0.102: v2(74.38,60.59) 74.55,60.42 v1(74.55,59.78) 74.55,58.37 74.44,58.27 74.44,54.36 75.23,53.57 75.23,48.64 75.41,48.46 RH83.2
  BOTTOM w0.102: UH1.F17 74.59,60.38 v2(74.38,60.59)
PCH_GPIO06: length 15
  TOP w0.102: v2(73.4,57.06) 73,56.66 73,56.31 73.38,55.93 73.38,53.84 73.56,53.66 v1(73.56,53.57) 73.56,53.49 73.38,53.32 73.38,51.81 74.12,51.08 74.12,48.87 73.34,48.1 73.1,48.1 72.98,47.97 72.64,47.97 71.54,46.88 71.32,46.88 70.98,46.53 RPH8.8
  BOTTOM w0.076: v2(73.4,57.06) 73,57.47 73,57.77 73.47,58.24 UH1.A14
PCH_GPIO13: length 7.7
  BOTTOM w0.076: 77.29,57.7 77.29,57.93 77.01,58.2 77.01,58.56 76.79,58.78 76.79,59.27 UH1.C22
  BOTTOM w0.102: RH60.2 77.06,54.03 77.39,54.36 v1(77.39,54.56) 77.34,54.61 77.34,55.75 77.29,55.8 77.29,57.7
PCH_GPIO15: length 11.1
  TOP w0.076: 68.45,67.34 71.97,67.34 v2(72.32,66.99)
  TOP w0.102: 68.45,67.34 68.43,67.31 63.82,67.31 v1(63.33,66.82) 62.86,66.36 RH211.1
  BOTTOM w0.089: v2(72.32,66.99) 72.13,67.17 UH1.AB11
PCH_GPIO24: length 11.8
  TOP w0.076: 68.93,67.12 69.16,67.12 69.75,66.54 70.58,66.54 v2(71.13,65.99)
  TOP w0.102: 68.93,67.12 67.26,67.12 67.11,66.97 67.11,65.8 66.8,65.49 64.01,65.49 v1(63.6,65.09) 62.84,64.33 RH213.1
  BOTTOM w0.102: UH1.Y10 71.13,66.06 v2(71.13,65.99)
PCH_GPIO33: length 11.2
  TOP w0.102: v2(75.87,55.83) 76.29,55.41 76.29,54.94 77.06,54.16 77.06,51.11 78.05,50.12 RH40.2
  BOTTOM w0.089: UH1.B17 74.77,58.83
  BOTTOM w0.102: 74.77,58.83 74.77,58.21 74.8,58.18 74.8,56.88 v1(75.28,56.41) 75.86,55.83 v2(75.87,55.83)
PCH_GPIO34: length 9.3
  TOP w0.076: 68.57,73.41 68.85,73.13 v1(68.9,73.13) 69.12,73.13 69.44,72.81 69.75,72.81 v2(70.05,72.5)
  TOP w0.089: 67.36,74.61 68.57,73.41
  TOP w0.102: 67.36,74.61 67.16,74.82 67.16,75.17 66.98,75.35 66.98,75.5 64.83,77.65 64.83,78.03 64.55,78.31 RPH10.5
  BOTTOM w0.102: v2(70.05,72.5) 70.05,72.4 69.75,72.1 UH1.AN6
PCH_GPIO35: length 11.2
  BOTTOM w0.102: RH25.1 58.67,75.71 59.54,75.71 RH208.1 60.25,74.99 62.64,74.99 64.45,73.18 v1(65.06,73.18) 65.78,73.18 66.07,72.89 66.93,72.89 67.59,72.23 UH1.AP1
PCH_GPIO36: length 11.9
  BOTTOM w0.102: UH1.AT3 68.25,73.04 67.95,72.74 67.63,72.74 67.08,73.29 66.24,73.29 65.89,73.64 65.89,73.65 65.45,74.08 v1(64.13,74.08) 63.9,74.08 62.58,75.4 62.58,75.5 RH230.1 61.87,75.3 60.73,75.3 59.99,76.04 RH228.1 59.99,76.9 RH12.1
PCH_GPIO37: length 24.6
  TOP w0.102: v2(56.16,72.12) v1(55.36,72.12) 54.56,72.12 53.8,72.89 53.8,75.02 52.37,76.44 52.37,79.29 v2(52.09,79.57)
  BOTTOM w0.076: 65.53,71.45 65.8,71.45 66.39,70.85 67.41,70.85 67.66,70.6 UH1.AK1
  BOTTOM w0.102: v2(52.09,79.57) 52.98,79.57 53.39,79.16 RH14.1 ; 65.53,71.45 62.29,71.45 RH229.1 61.77,71.95 60.55,71.95 59.99,71.39 RH231.1 59.54,71.77 56.51,71.77 v2(56.16,72.12)
PCH_GPIO55: length 10.5
  TOP w0.076: v2(70.11,71.47) 69.89,71.47 69.44,71.92 68.75,71.92 67.98,72.69 67.91,72.69
  TOP w0.102: RH76.1 v1(63.3,75.88) 64.21,75.88 65.4,74.69 65.4,74.18 66.9,72.69 67.91,72.69
  BOTTOM w0.102: UH1.AL6 69.75,71.11 v2(70.11,71.47)
PCH_GPIO69: length 17.8
  TOP w0.102: v2(73.25,45.68) 73.25,45.89 72.78,46.36 RPH8.5
  BOTTOM w0.076: 72.97,56.99 72.97,57.16 72.8,57.34 72.8,57.8 73.18,58.18 73.18,58.56 73.38,58.76 73.38,59.02 73.05,59.35 73.05,59.78 UH1.D13
  BOTTOM w0.102: 72.97,56.99 72.97,56.33 73.33,55.97 74.07,55.97 74.75,55.29 74.75,53.87 75.13,53.49 75.13,52.19 74.85,51.91 74.85,48.63 v1(73.73,47.51) 73.25,47.03 v2(73.25,45.68)
PCH_GPIO71: length 18.9
  TOP w0.076: 72.79,59.27 72.79,59.35 73,59.55 73,60.8 v2(73.38,61.18)
  TOP w0.102: RPH9.5 70.1,46.9 70.88,46.9 71.49,47.51 71.89,47.51 72.82,48.44 v1(73,48.44) 73.39,48.44 73.71,48.76 73.71,50.91 73.18,51.45 73.18,55.84 72.79,56.22 72.79,59.27
  BOTTOM w0.102: v2(73.38,61.18) 73.57,61.18 73.89,61.49 UH1.H15
PCH_INTVRMEN: length 13.2
  TOP w0.076: 71.42,59.25 71.4,59.27 71.4,60.06 71.04,60.41 71.04,60.78 v2(71.42,61.16)
  TOP w0.102: RH18.1 RH5.2 70.79,51.75 v1(70.94,51.91) 72.16,53.12 72.16,55.36 71.78,55.74 71.78,58.89 71.42,59.25
  BOTTOM w0.102: UH1.G10 71.93,60.99 71.76,61.16 v2(71.42,61.16)
PCH_JTAG_RST: length 34.8
  IN3 w0.127: v2(54.56,80.96) 54.76,80.76 55.35,80.76 55.73,80.38 59.74,80.38 60.04,80.68 60.98,80.68 64.61,77.05 66.95,77.05 67.47,76.52 67.47,74.94 68.12,74.3 68.12,69.36 69.87,67.6 v2(69.87,66.96)
  BOTTOM w0.102: v2(69.87,66.96) 69.75,67.09 UH1.AB6 ; v2(54.56,80.96) 53.95,81.57 v4(53.95,83.06) 53.95,85 54.3,85.36 54.56,85.36 55.04,85.84 55.04,86.83 54.18,87.69 RH32.2
PCH_JTAG_RST_R: length 3.3
  BOTTOM w0.102: RH32.1 52.45,87.8 v1(51.38,87.8) 50.62,87.8 50.47,87.95 JXDP2.54
PCH_JTAG_TCK: length 47.3
  IN1 w0.109: v2(51.94,69.38) 51.33,69.38 50.27,70.44 49.63,70.44 47.95,72.12 47.95,74.69 44.19,78.45 44.19,85.84 v2(40.89,89.14)
  BOTTOM w0.076: UH1.AB3 68.65,67.29 68.65,66.89 68.4,66.64 68.15,66.64 67.94,66.84 67.23,66.84 66.57,67.5 66.37,67.5
  BOTTOM w0.102: JXDP2.57 43.53,89.04 40.99,89.04 v2(40.89,89.14) ; v2(51.94,69.38) 53.43,69.38 v4(54.13,68.68) 55.45,67.36 57.06,67.36 RH47.1 57.96,67.5 59.92,67.5 60.53,66.89 62.89,66.89 63.02,67.02 64.5,67.02 64.98,67.5 66.37,67.5
PCH_JTAG_TDI: length 37.6
  IN4 w0.109: v2(54.25,73.65) 53.76,74.14 53.76,81.44 v2(54.66,82.33)
  BOTTOM w0.102: JXDP2.56 50.5,88.45 50.8,88.15 51.79,88.15 51.84,88.2 53.96,88.2 55.24,86.92 55.24,82.92 v2(54.66,82.33) ; UH1.AE2 68.26,68.54 66.29,68.54 65.91,68.92 65.23,68.92 63.73,70.42 RH55.1 62.28,70.47 61.77,70.98 60.45,70.98 60.2,70.73 60.2,70.5 RH50.2 59.54,70.75 57.83,70.75 57.66,70.93 56.77,70.93 v4(55.17,72.52) 54.71,72.99 54.71,73.19 v2(54.25,73.65)
PCH_JTAG_TDO: length 39.9
  IN1 w0.109: v2(51.94,70.68) 51.94,71.11 48.77,74.28 48.77,79.16 46.61,81.32 v2(46.61,83.38)
  BOTTOM w0.102: UH1.AD3 68.26,68.16 67.95,67.86 67.68,67.86 67.43,68.11 64.26,68.11 63.85,68.52 RH56.1 61.82,68.06 60.07,68.06 RH52.2 59.49,68.64 57.02,68.64 56.89,68.77 54.96,68.77 53.33,70.41 v4(52.45,70.41) 52.21,70.41 v2(51.94,70.68) ; v2(46.61,83.38) 45.95,84.04 45.95,85.41 47.98,87.45 JXDP2.52
PCH_JTAG_TMS: length 41
  IN4 w0.109: v2(55.85,80.86) 56.93,79.78 56.93,73.03 56.6,72.7 54.6,72.7 v2(54.3,72.99)
  BOTTOM w0.102: v2(54.3,72.99) 54.3,72.76 56.54,70.52 57.38,70.52 58.19,69.71 59.43,69.71 RH48.2 59.99,69.46 60.4,69.86 61.87,69.86 62.28,69.46 RH54.1 v4(63.66,69.41) 64.55,68.52 65.96,68.52 66.17,68.31 67.66,68.31 UH1.AD1 ; JXDP2.58 50.58,88.95 50.97,88.55 51.62,88.55 51.67,88.61 54.13,88.61 55.65,87.09 55.65,81.06 v2(55.85,80.86)
PCH_PCIE_IREF: length 4.9
  BOTTOM w0.102: UH1.BE30 80.08,77.18 80.08,79.03 ; RH188.2 81.28,80.51 v1(81.69,80.91)
  BOTTOM w0.305: 80.08,79.03 80.08,79.97 RH188.2
PCH_PCIE_RCOMP: length 1.7
  TOP w0.381: v2(79.59,77.36) 80.01,77.36 RH192.2
  BOTTOM w0.254: v2(79.59,77.36) 79.54,77.31 UH1.BD29
PCH_PCIE_WAKE#: length 232
  TOP w0.102: RH88.2 RH78.2 59.92,61.71 63.26,61.71 v2(63.6,62.05)
  IN1 w0.109: v2(250.16,44.84) 250.18,44.86 250.53,44.86 251.47,45.79 251.47,49.94 250.49,50.91 246.48,50.91 244.66,52.74 244.31,52.74 244.07,52.49 244.07,52.18 243.44,51.55 233.25,51.55 231.7,50 218.11,50 215.88,47.77 211.67,47.77 210.7,46.81 200.32,46.81 193.15,39.64 188.72,39.64 188.26,39.18 183.37,39.18 183.06,39.49 177.87,39.49 177.03,40.33 174.61,40.33 173.07,38.8 122.78,38.8 120.26,41.32 114.22,41.32 113.39,42.15 103.97,42.15 103.01,43.11 94.89,43.11 94.15,42.37 81.22,42.37 80.49,43.11 77.31,43.11 75.81,44.61 73.12,44.61 72.26,45.46 70.19,45.46 67.33,48.32 67.33,49.3 65.17,51.46 64.13,51.46 62.07,53.53 62.07,55.46 62.36,55.76 62.36,59.01 63.25,59.9 63.25,61.71 v2(63.6,62.05)
  BOTTOM w0.076: UH1.K3 68.62,62.57 68.15,62.57 67.97,62.75 67.64,62.75 67.46,62.93 66.93,62.93 66.67,62.67 66.29,62.67
  BOTTOM w0.102: v2(250.16,44.84) 249.81,44.84 v1(249.66,44.7) 249.55,44.59 249.27,44.59 249.1,44.42 U51.A44 ; 66.29,62.67 64.22,62.67 v2(63.6,62.05)
PCH_PLTRST#: length 352.8
  TOP w0.102: v2(58.56,78.61) 57.67,77.72 UH3.1 UH3.2 56.87,79.05 RH109.2 ; v2(210.08,136.34) 210.08,136.39 212.14,138.45 212.14,148.98 211.11,150.01 v1(210.69,150.01) 209.11,150.01 208.63,150.48 UC1.2 ; RH109.2 RH114.2 RH111.2 ; RH109.2 RH110.2
  IN3 w0.127: v2(210.08,136.34) 211.28,135.14 211.28,126.58 213.02,124.84 213.02,120.65 211.63,119.27 211.63,118.66 212.27,118.02 212.27,106.83 212.61,106.49 212.61,105.22 216.24,101.59 216.24,95.79 219.44,92.59 219.44,83.64 216.42,80.62 216.42,71.73 213.61,68.92 213.61,66.46 210.74,63.59 210.74,62.47 207.08,58.81 207.08,58.12 204.89,55.93 200.54,55.93 193.51,48.9 191.45,48.9 189.22,46.67 170.68,46.67 166.78,42.77 165.89,42.77 165.05,41.94 148.6,41.94 146.97,43.56 146.98,43.57 146.98,44.45 146.75,44.68 132.35,44.68 131.67,44.01 124.98,44.01 121.34,47.65 118.92,47.65 116.49,50.09 100.34,50.09 100.07,50.36 93.04,50.36 92.75,50.65 80.07,50.65 79.44,51.28 77.71,51.28 77.09,51.91 75.69,51.91 73.61,53.99 68.8,53.99 66.5,56.3 66.5,57.07 65.63,57.94 65.63,58.75 64.27,60.11 62.18,60.11 61.1,59.03 55.99,59.03 55.93,58.97 54.5,58.97 53.33,60.14 52.93,60.14 51.43,61.63 51.43,69.48 52.71,70.76 52.71,71.14 53.82,72.26 53.82,74.51 54.2,74.89 55.59,74.89 56.22,75.53 56.82,75.53 58.56,77.26 v2(58.56,78.61)
  IN4 w0.102: v2(71.72,66) 71.24,66.49 69.7,66.49 69.44,66.74 69.44,67.61 69.46,67.63
  IN4 w0.109: 69.46,67.63 69.54,67.71 69.54,67.94 68.81,68.67 68.81,71.18 69.49,71.87 69.49,72.84 68.76,73.57 68.76,74.23 70.31,75.78 70.31,85.32 67.89,87.74 v2(67.89,88.18)
  BOTTOM w0.102: UH1.Y11 71.72,66.06 v2(71.72,66) ; v2(67.89,88.18) 63.32,88.18 61.62,86.47 61.62,85.48 58.9,82.77 58.9,78.96 v2(58.56,78.61) 58.05,78.61 57.16,79.5 QH5.2
PCH_PLTRST#_BUF: length 4.5
  TOP w0.102: v1(206.6,148.88) RC10.1 RC17.2 RC11.1 207.98,148.11 UC1.4
PCH_PLTRST#_EC: length 544.6
  TOP w0.102: v2(24.31,92.93) 23.93,92.55 21.84,92.55 21.4,92.1 JIO1.38 ; v2(56.44,75.1) 56.22,75.31 UH3.4 ; v2(245.87,60.29) 245.87,60.34 245.04,61.17 245.04,62.01 244.17,62.88 243.74,62.88 242.39,64.22 241.37,64.22 240.15,65.45 v2(240.03,65.45)
  IN1 w0.109: v2(259.21,53.16) 259.37,53 259.37,45.97 258.6,45.2 258.6,43.96 253.34,38.7 250.14,38.7 248.28,36.84 248.28,36.51 247.5,35.73 242.7,35.73 240.29,33.32 235.31,33.32 234.72,33.9 223.56,33.9 218.62,38.85 206.06,38.85 204.65,37.44 200.52,37.44 192.25,29.17 178.14,29.17 177.28,28.31 156.85,28.31 154.06,31.1 121.65,31.1 121.17,30.62 116.95,30.62 116.5,31.06 110.58,31.06 109.02,32.63 103.21,32.63 102.55,33.28 94.41,33.28 91.79,30.66 80.04,30.66 v2(79.56,30.19) 78.97,30.78 67.74,30.78 50.38,48.14 50.38,62.95 50.06,63.28 50.06,64.75 45.12,69.68 45.12,70.1 v2(44.78,70.45) 44.36,70.45 43.48,71.32 42.14,71.32 39.33,74.14 39.33,74.3 37.51,76.11 37.51,77.1 34.53,80.09 29.4,80.09 26.64,82.84 26.64,84.94 23.76,87.82 23.76,89.88 24.22,90.33 24.22,92.84 v2(24.31,92.93) ; v2(21.51,144.51) 21.18,144.18 21.18,126.56 v2(21.23,126.51)
  IN3 w0.127: v2(121.44,157.98) 120.79,158.62 109.41,158.62 106.18,155.39 103.26,155.39 101.92,156.72 90.05,156.72 85.85,152.51 80.42,152.51 79.98,152.95 74.6,152.95 73.2,151.55 69.82,151.55 v2(69.67,151.7) ; v2(244.98,50.1) 246.12,51.23 246.12,52.26 248.63,54.77 v2(248.63,56.02)
  IN4 w0.109: v2(69.67,151.7) 69.82,151.55 69.82,147.69 67.23,145.1 42.09,145.1 40.66,146.52 39.37,146.52 37.06,144.22 22.35,144.22 22.05,144.51 v2(21.51,144.51)
  BOTTOM w0.102: v2(240.03,65.45) 240.23,65.25 U46.B22 ; v2(56.44,75.1) 54.1,75.1 53.11,74.11 53.11,73.8 51.97,72.66 50.9,72.66 48.69,70.45 v2(44.78,70.45) ; v2(21.51,144.51) 21.08,144.51 20.18,145.42 20.18,147.64 21.24,148.7 JMINI4.22 21.24,155.33 20.74,155.83 20.1,155.83 19.24,156.69 JMINI4.17 ; v2(24.31,92.93) 23.98,93.26 23.98,97.55 23.19,98.34 23.19,105.92 25.02,107.74 25.02,122.72 v1(22.23,125.51) v2(21.23,126.51) ; v2(121.44,157.98) 121.44,158.04 122.29,158.89 JMINI2.22 ; JMINI1.22 259.44,53.4 v2(259.21,53.16) 258.01,53.16 255.2,55.97 253.15,55.97 251.67,57.45 U39.16 249.79,57.45 248.63,56.29 v2(248.63,56.02) 247.59,57.06 247.24,57.06 246.91,57.39 246.91,57.43 245.9,58.45 245.9,60.26 v2(245.87,60.29) ; v2(244.98,50.1) 245.05,50.17 U51.B30 ; JMINI3.22 78.94,29.56 v2(79.56,30.19)
PCH_PWRBTN#_XDP: length 2.6
  BOTTOM w0.102: RH28.2 41.5,84.95 JXDP2.41
PCH_PWRGD#: length 324.8
  IN4 w0.109: v2(255.74,50.03) 255.13,50.64 253.41,50.64 251.84,49.07 251.84,43.47 252.14,43.18 252.14,41.2 251.5,40.57 251.5,39.53 250.81,38.83 250.81,35.97 249.43,34.59 247.01,34.59 244.81,32.4 234.63,32.4 234.49,32.54 232.77,32.54 231.89,33.42 230.72,33.42 229.04,35.11 227.34,35.11 222.59,39.87 221.82,39.87 219.41,42.27 208.71,42.27 207.24,40.8 204.72,40.8 204.39,41.13 203.45,41.13 202.65,40.33 200.36,40.33 198.87,38.83 192.26,38.83 190.1,36.68 190.1,35.77 189.74,35.41 188.42,35.41 188.38,35.45 181.52,35.45 180.96,34.89 174.37,34.89 173.8,35.46 168.19,35.46 167.64,34.91 119.61,34.91 117.38,37.14 113.14,37.14 112.72,37.57 103.55,37.57 102.05,36.06 97.38,36.06 96.31,34.99 76.9,34.99 75.63,36.26 61.45,36.26 50.38,47.33 50.38,51.98 46.58,55.79 46.58,60.85 43.66,63.77 41.51,65.92 39.68,65.92 37.23,68.38 26.05,68.38 25.87,68.56 21.88,68.56 21.83,68.6 20.31,68.6 13.89,75.02 13.89,78.8 12.19,80.5 12.19,81.57 13.5,82.88 15.07,82.88 v2(16.56,84.37)
  BOTTOM w0.102: R391.1 28.95,93.13 27.74,93.13 26.85,92.24 v1(26.85,90.18) 26.85,87.8 25.65,86.6 23.28,86.6 22.79,86.11 19.01,86.11 17.27,84.37 v2(16.56,84.37) ; Q52.1 255.94,48.96 255.74,49.16 v2(255.74,50.03) 256.58,50.86 R893.2
PCH_PWROK: length 18.8
  TOP w0.102: RH103.2 58.32,65.88 63.4,65.88 64.39,66.87 v4(65.06,66.87) v2(66.09,66.87)
  IN4 w0.109: v2(66.09,66.87) 66.55,66.41 66.85,66.41 67.26,66 67.26,65.32 67.77,64.81 67.77,64.05 69.01,62.81 69.01,62.24 69.64,61.61 70.28,61.61 71.33,60.56 v2(71.44,60.56)
  BOTTOM w0.102: UH1.F10 71.75,60.56 v2(71.44,60.56)
PCH_RI#: length 7.5
  BOTTOM w0.076: UH1.N4 69.1,63.74 68.63,63.74 68.38,64 68.15,64 67.97,63.82 67.61,63.82 67.51,63.71 66.39,63.71
  BOTTOM w0.102: 66.39,63.71 66.17,63.49 63.71,63.49 63.59,63.36 v1(63.51,63.36) 63.39,63.36 62.55,62.52 RH84.2
PCH_RSMRST#: length 223.2
  IN1 w0.109: v2(255.04,46.32) 254.94,46.42 252.45,46.42 252.07,46.04 252.07,45.67 249.96,43.56 247.87,43.56 247.15,44.29 246.73,44.29 246.4,44.62 v2(246.4,44.7) 246.26,44.56 240.61,44.56 240.21,44.16 238.53,44.16 238.27,43.9 233.4,43.9 233.18,44.12 230.14,44.12 229.35,43.34 200.35,43.34 193.32,36.31 191.95,36.31 190.6,34.97 179.95,34.97 179.26,34.28 171.86,34.28 170.28,32.7 157.33,32.7 155.75,34.28 118.15,34.28 115.9,36.54 113.11,36.54 112.03,37.62 102.79,37.62 101.68,36.51 88.29,36.51 87.3,37.5 84.57,37.5 84.33,37.26 82.19,37.26 81.1,38.34 68.81,38.34 59.79,47.36 v2(59.79,48.48)
  BOTTOM w0.102: U51.B47 247.34,44.17 247.22,44.29 246.82,44.29 v2(246.4,44.7) ; R892.2 254.43,46.93 v2(255.04,46.32) ; U12.1 61.08,56.97 R1623.1 61.25,56.81 61.25,54.69 59.79,53.23 v1(59.79,49.62) v2(59.79,48.48)
PCH_RSMRST#_Q: length 54.3
  IN1 w0.109: v2(51.89,62.4) 50.68,63.6 50.68,65 48.33,67.36 48.33,68.16 41.75,74.74 39.78,74.74 38.19,76.34 38.19,77.32 36.6,78.9 36.6,80.73 35.56,81.78 v2(35.56,82.82)
  IN3 w0.127: v2(55.6,57.11) 55.78,56.93 56.64,56.93 56.79,56.78 61.04,56.78 61.72,57.46 v2(61.72,57.7)
  BOTTOM w0.102: U12.4 56.84,55.68 R1624.1 56.35,55.96 55.6,56.71 v2(55.6,57.11) 54.73,57.98 v1(54.73,58.71) 54.05,59.39 54.05,60.26 51.92,62.4 v2(51.89,62.4) ; R1623.2 62.15,57.26 v2(61.72,57.7) 62.3,58.28 RH89.2 RH105.1 ; RH26.1 40.18,83.76 39.24,82.82 v2(35.56,82.82)
PCH_RSMRST#_R: length 8.6
  BOTTOM w0.102: UH1.J2 68.2,61.98 66.08,61.98 65.63,61.53 64.06,61.53 v1(63.58,61.06) 63.22,60.69 62,60.69 RH79.2 RH105.2
PCH_RTCRST#: length 114.7
  TOP w0.102: v2(64.69,53.68) 64.69,53.96 65.02,54.29 66.04,54.29 66.7,54.95 RH44.2 66.78,55.74 CH7.2 66.95,55.82 68.65,55.82 CMOS1.2 69.06,56.1 70.64,57.67 v2(70.89,57.67)
  IN3 w0.127: v2(23.58,111.21) 35.37,99.43 35.37,86.44 34.82,85.89 34.82,85.15 35.38,84.6 36.36,84.6 37.71,83.25 38.88,83.25 45.38,76.75 45.38,73.35 48.41,70.32 48.41,67.12 48.82,66.71 48.82,59.54 55.42,52.93 63.03,52.93 63.68,53.58 64.59,53.58 v2(64.69,53.68)
  BOTTOM w0.076: UH1.D9 71.44,59.33 71.14,59.04 71.14,58.74 71.32,58.56 71.32,58.1 v2(70.89,57.67)
  BOTTOM w0.102: v2(23.58,111.21) 23.98,111.61 v4(23.98,112.01) 23.98,119.72 18.78,124.92 17.88,124.92 17.41,124.44 JAPS1.9
PCH_RTCX1: length 6.3
  TOP w0.203: RH38.2 RH39.1 66.19,57.14 66.78,57.72 v1(66.94,57.72) 67.66,57.72 68.58,58.64 68.66,58.64 v2(69.48,59.46)
  BOTTOM w0.203: UH1.B5 69.77,59.16 v2(69.48,59.46)
PCH_RTCX1_R: length 2.6
  TOP w0.203: YH1.1 64.65,55.33 CH4.2 RH38.1
PCH_RTCX2: length 7.1
  TOP w0.203: v2(68.79,59.44) 68.2,59.44 v1(67.91,59.16) 67.73,59.16 67.46,58.89 67.03,58.89 66.19,58.05 RH39.2 65.89,58.03 CH5.2 64.16,57.14 YH1.2
  BOTTOM w0.089: v2(68.79,59.44) 69.13,59.11 UH1.B4
PCH_SATA_MOD_EN#: length 239.2
  IN4 w0.109: v2(56.13,82.03) 56.16,82.03 57.35,80.84 57.35,72.86 56.89,72.4 56.89,66.56 56.31,65.98 56.31,64.71 56.51,64.52 56.51,63.81 55.7,63.01 54.58,63.01 54.18,62.6 54.18,58.71 55.35,57.54 55.9,57.54 57.3,56.15 57.3,55.72 58.29,54.73 58.29,53.4 62.53,49.16 64.39,49.16 65.71,47.84 84.38,47.84 86.63,45.58 110.41,45.58 112.36,43.63 120.88,43.63 122.51,41.99 165.85,41.99 166.97,43.11 176.54,43.11 176.89,43.46 184.64,43.46 185.46,44.29 195.68,44.29 199.06,47.66 209.02,47.66 209.26,47.42 229.23,47.42 229.65,47 232.52,47 233.44,46.08 234.25,46.08 234.86,45.47 234.86,44.65 235.75,43.76 237.49,43.76 237.89,44.16 240.23,44.16 240.87,44.8 242.51,44.8 245.71,48.01 245.71,48.46 v2(246.37,49.11)
  BOTTOM w0.102: QH5.3 56.11,79.16 56.11,80.34 56.36,80.59 v1(56.36,81.56) 56.36,81.8 v2(56.13,82.03) ; U51.B36 246.73,49.67 246.37,49.3 v2(246.37,49.11)
PCH_SMB_ALERT#: length 14.6
  TOP w0.102: v2(60.74,59.96) 60.74,59.43 60.17,58.87 RH166.2
  IN2 w0.127: v2(70.64,63.06) 70.64,63.39 70.41,63.61 63.47,63.61 61.29,61.43 61.29,60.51 v2(60.74,59.96)
  BOTTOM w0.102: v2(70.64,63.06) 70.34,63.35 UH1.N7
PCH_SPI_CLK: length 76.7
  IN1 w0.109: v2(71.88,70.48) 72.32,70.04 72.72,70.04 73,69.76 75.74,69.76 76.4,69.1 76.4,68.16 77.88,66.68 77.88,63.76 78.33,63.31 78.33,60.08 77.92,59.67 77.92,54.94 81.19,51.67 83.91,51.67 85.21,50.38 91.06,50.38 91.16,50.27 91.16,50.1 90.68,49.61 90.68,49.44 90.89,49.23 91.07,49.23 91.88,50.04 92.04,50.04 92.42,49.66 92.74,49.66 92.84,49.55 92.84,49.31 92.97,49.19 93.26,49.19 93.39,49.31 93.39,49.55 93.5,49.66 93.83,49.66 93.94,49.55 93.94,49.32 94.05,49.21 94.37,49.21 94.48,49.32 94.48,49.55 94.59,49.66 94.92,49.66 95.03,49.55 95.03,49.32 95.14,49.21 95.47,49.21 95.58,49.32 95.58,49.55 95.68,49.66 96.01,49.66 96.12,49.55 96.12,49.32 96.23,49.21 96.56,49.21 96.67,49.32 96.67,49.55 96.78,49.66 97.1,49.66 97.21,49.55 97.21,49.32 97.32,49.21 97.65,49.21 97.76,49.32 97.76,49.55 97.87,49.66 98.2,49.66 98.31,49.55 98.31,49.32 98.42,49.21 98.74,49.21 98.85,49.32 98.85,49.55 98.96,49.66 99.29,49.66 99.4,49.55 99.4,48.86 99.53,48.73 99.82,48.73 99.94,48.86 99.94,49.55 100.05,49.66 103.34,49.66 103.45,49.55 103.45,48.88 103.58,48.76 103.87,48.76 103.99,48.88 103.99,49.55 104.1,49.66 104.43,49.66 104.54,49.55 104.54,48.86 104.67,48.73 104.96,48.73 105.09,48.86 105.09,49.55 105.2,49.66 105.52,49.66 105.63,49.55 105.63,48.89 105.74,48.78 106.07,48.78 106.18,48.89 106.18,49.55 106.29,49.66 106.62,49.66 106.73,49.55 106.73,48.89 106.83,48.78 107.23,48.78 107.34,48.89 107.34,49.15 107.45,49.26 107.77,49.26 107.88,49.15 107.88,48.89 107.99,48.78 108.32,48.78 108.43,48.89 108.43,49.15 108.54,49.26 108.86,49.26 108.97,49.15 108.97,48.89 109.08,48.78 109.85,48.78 109.98,48.91 109.98,49.53 109.85,49.66 v2(107.92,49.66)
  BOTTOM w0.102: UH1.AJ11 72.13,70.23 v2(71.88,70.48) ; RH181.2 107.72,54.17 107.72,52.74 108.03,52.43 JSPI1.8 108.03,49.77 v2(107.92,49.66)
PCH_SPI_CS0#: length 87
  IN1 w0.109: v2(69.92,70.5) 69.7,70.27 68.2,70.27 68.05,70.42 66.39,70.42 66.09,70.12 66.09,69.2 64.59,67.7 64.59,65.42 65.47,64.54 65.47,58.97 66.05,58.39 66.05,52.07 68.41,49.72 68.41,48.74 69.94,47.21 73.81,47.21 74.47,46.55 76.71,46.55 77.62,45.63 79.18,45.63 79.93,44.88 81.51,44.88 82.54,43.85 93.42,43.85 94.21,44.64 103.21,44.64 103.61,45.05 106.08,45.05 106.73,44.4 v2(106.73,44.36)
  BOTTOM w0.102: RH182.2 105.81,53.43 v1(106.21,53.03) 107.03,52.21 JSPI1.10 107.03,50.02 106.27,49.26 106.27,48.95 106.37,48.85 107.14,48.85 107.26,48.72 107.26,48.47 107.14,48.34 106.37,48.34 106.27,48.24 106.27,47.94 106.37,47.84 107.11,47.84 107.24,47.71 107.24,47.45 107.11,47.33 106.37,47.33 106.27,47.23 106.27,46.92 106.37,46.82 107.11,46.82 107.24,46.69 107.24,46.44 107.11,46.31 106.37,46.31 106.27,46.21 106.27,45.9 106.37,45.8 107.06,45.8 107.19,45.68 107.19,45.42 107.06,45.3 106.37,45.3 106.27,45.19 106.27,44.82 v2(106.73,44.36) ; v2(69.92,70.5) 70.34,70.08 UH1.AJ7
PCH_SPI_CS1#: length 81.4
  IN1 w0.109: v2(70.64,70.48) 70.22,70.06 68.14,70.06 66.95,68.87 66.79,68.87 65.23,67.31 65.23,65.67 66.1,64.8 66.1,59.43 66.69,58.85 66.69,52.33 69.04,49.98 69.04,49 70.2,47.84 74.07,47.84 74.68,47.23 76.97,47.23 77.94,46.27 79.44,46.27 80.2,45.51 81.77,45.51 82.8,44.48 93.16,44.48 93.95,45.28 102.94,45.28 103.35,45.68 106.34,45.68 106.68,45.35 107.5,45.35 v2(108.48,44.36)
  BOTTOM w0.102: v2(70.64,70.48) 70.34,70.78 UH1.AL7 ; RH177.2 v1(111.33,52.7) 111.03,52.4 JSPI1.2 111.03,49.6 108.48,47.06 v2(108.48,44.36)
PCH_SPI_DIN: length 78.3
  IN1 w0.109: v2(66.54,69.97) 66.54,69.35 64.8,67.62 64.8,65.51 65.68,64.63 65.68,59.06 66.26,58.48 66.26,52.16 68.62,49.81 68.62,48.82 70.02,47.42 73.9,47.42 74.54,46.77 76.81,46.77 77.74,45.84 79.27,45.84 80.02,45.09 81.6,45.09 82.63,44.06 93.33,44.06 94.12,44.85 103.12,44.85 103.53,45.26 106.17,45.26 106.5,44.92 106.75,44.92 v2(107.31,44.36)
  BOTTOM w0.102: v2(107.31,44.36) 107.67,44.72 107.67,48.63 109.03,49.99 JSPI1.6 v1(109.03,53.21) 109.03,53.95 RH179.2 ; UH1.AH3 68.72,69.78 68.25,69.78 67.94,69.48 67.02,69.48 v2(66.54,69.97)
PCH_SPI_DO: length 77.5
  IN1 w0.109: v2(67.13,69.96) 67.13,69.51 65.02,67.4 65.02,65.58 65.89,64.71 65.89,59.15 66.48,58.57 66.48,52.25 68.83,49.9 68.83,48.91 70.11,47.63 73.99,47.63 74.61,47 76.9,47 77.85,46.06 79.36,46.06 80.11,45.3 81.68,45.3 82.72,44.27 93.24,44.27 94.04,45.07 103.03,45.07 103.44,45.47 106.25,45.47 106.59,45.13 107.13,45.13 v2(107.9,44.36)
  BOTTOM w0.102: v2(67.13,69.96) 67.22,69.87 67.73,69.87 UH1.AH1 ; RH178.2 110.03,53.17 v1(110.03,52.08) JSPI1.4 110.03,50.13 107.9,47.99 v2(107.9,44.36)
PCH_SPI_DO2: length 80.1
  IN1 w0.109: v2(65.86,70.75) 65.48,70.37 64.82,70.37 64.37,69.92 64.37,65.34 64.87,64.84 64.87,63.51 64.65,63.29 64.65,61.41 64.62,61.38 64.62,59.53 65.84,58.3 65.84,51.99 68.2,49.63 68.2,48.65 70.52,46.33 76.62,46.33 77.52,45.42 79.1,45.42 79.85,44.67 81.42,44.67 82.45,43.64 93.5,43.64 94.3,44.43 103.55,44.43 103.96,44.84 105.67,44.84 v2(106.15,44.36)
  BOTTOM w0.102: v2(65.86,70.75) 65.96,70.65 67.33,70.65 67.69,70.3 67.95,70.3 68.12,70.47 68.41,70.47 68.69,70.19 69.15,70.19 UH1.AJ4 ; RH183.2 104.04,54.09 v1(104.82,53.31) 106.03,52.1 JSPI1.12 106.03,44.48 v2(106.15,44.36)
PCH_SPI_DO3: length 81.8
  IN1 w0.109: v2(65.2,70.78) 64.79,70.78 64.16,70.14 64.16,65.25 64.62,64.8 64.62,63.8 64.44,63.62 64.44,61.7 64.39,61.65 64.39,59.46 65.63,58.22 65.63,55.4 64.15,53.92 64.15,52.64 64.69,52.1 65.43,52.1 67.98,49.55 67.98,48.56 70.43,46.11 76.08,46.11 76.54,45.66 76.54,44.91 77,44.46 81.33,44.46 82.37,43.43 93.59,43.43 94.39,44.22 103.74,44.22 104.03,43.93 105.08,43.93 v2(105.51,44.36)
  BOTTOM w0.102: v2(65.2,70.78) 65.63,70.35 66.06,70.35 66.17,70.45 67.25,70.45 67.6,70.09 68.19,70.09 UH1.AJ2 ; RH184.2 v1(103.31,53.25) 105.03,51.52 JSPI1.14 105.03,49.79 105.51,49.31 v2(105.51,44.36)
PCH_TD_IREF: length 9.3
  BOTTOM w0.076: UH1.AY43 85.61,74.74 86.08,74.74 86.33,74.99 86.56,74.99 86.79,75.22 86.79,75.4
  BOTTOM w0.089: 86.84,75.57 86.79,75.52 86.79,75.4
  BOTTOM w0.102: 86.84,75.57 87.23,75.96 87.23,76.26 87.4,76.43 87.4,77.94 87.23,78.11 87.23,81.92 RH176.1
PCH_THRMTRIP#_R: length 9
  BOTTOM w0.076: 66.34,74.56 66.95,74.56 67.54,73.98 67.69,73.98 UH1.AV1
  BOTTOM w0.102: RH206.2 CH17.1 62.51,78.68 v1(63.2,77.98) 63.52,77.66 63.52,77.13 64.81,75.84 64.81,75.66 65.19,75.28 65.19,75.01 65.46,74.74 65.66,74.74 65.84,74.56 66.34,74.56
PCH_TP25: length 6
  TOP w0.076: 68.88,60.77 69.32,60.77 69.37,60.82 69.84,60.82 69.92,60.74 70.43,60.74 v2(70.49,60.68)
  TOP w0.102: 68.88,60.77 68.15,60.77 v1(67.95,60.56) 66.39,59 RH53.2
  BOTTOM w0.102: v2(70.49,60.68) 70.8,60.38 UH1.F8
PCH_TPM_EN: length 215
  TOP w0.102: RH218.1 RH214.1 66.86,80.35 66.86,79.37 67.33,78.89 67.33,77.19 67.9,76.62 67.9,75.72 68.18,75.45 v2(68.78,75.45)
  IN2 w0.127: v2(68.78,75.45) 68.36,75.87 68.36,76.75 69.96,78.35 69.96,89.55 71.08,90.67 82.71,90.67 84.19,89.19 84.19,87.44 84.63,87 91.37,87 92.39,88.01 97.39,88.01 98.12,87.27 v2(101.88,87.27)
  IN4 w0.109: v2(101.88,87.27) 101.95,87.34 106.48,87.34 107.83,85.99 113.85,85.99 116.44,83.41 175.13,83.41 182.74,75.8 192.8,75.8 200.3,68.3 203.47,68.3 205.54,66.23 207.62,66.23 211.07,62.79 219.99,62.79 220.19,62.99 225.33,62.99 225.58,62.73 228.19,62.73 229.29,63.83 231.35,63.83 232.2,64.68 243.59,64.68 243.59,64.68 244.36,64.68 244.57,64.89 v2(245.13,64.89)
  BOTTOM w0.089: UH1.BB4 69.08,75.74 v2(68.78,75.45)
  BOTTOM w0.102: v2(245.13,64.89) 245.13,65.21 R2195.1 ; v1(102.41,87.27) v2(101.88,87.27)
PCI_5048: length 1.5
  TOP w0.102: RH158.1 85.64,59.63 v2(85.45,59.43)
  BOTTOM w0.102: UH1.D44 85.77,59.76 v2(85.45,59.43)
PCI_DOCK: length 2.5
  TOP w0.102: v2(84.52,59.01) v1(85.08,59.01) 85.2,59.01 85.85,58.36 RH162.1
  BOTTOM w0.102: v2(84.52,59.01) 84.59,59.08 UH1.B42
PCI_LOOPBACKOUT: length 7.1
  BOTTOM w0.102: RH164.1 89.95,56.9 v1(89.37,56.9) 85.41,56.9 84.05,58.26 UH1.A40
PCI_MEC: length 1.6
  TOP w0.102: v2(85.44,60.11) 85.97,60.64 RH160.1
  BOTTOM w0.102: UH1.E44 85.73,60.4 v2(85.44,60.11)
PCI_PIRQA#: length 16.7
  TOP w0.102: v2(75.33,61.18) 75.31,61.15 75.31,58.27 75.05,58.02 75.05,54.61 75.68,53.98 75.82,53.98 76.45,53.35 76.45,51.63 v1(76.28,51.45) 76.05,51.22 76.05,49.53 77.96,47.62 RPH1.3
  BOTTOM w0.102: UH1.H20 75.73,61.57 v2(75.33,61.18)
PCI_PIRQB#: length 18.2
  TOP w0.102: v2(75.33,62.4) 75.92,61.81 75.92,58.31 75.46,57.85 75.46,54.78 75.85,54.39 76.05,54.39 76.86,53.58 76.86,51.02 77.57,50.31 v1(77.57,50.11) 77.57,48.78 78.95,47.4 RPH1.1
  BOTTOM w0.102: UH1.L20 75.7,62.76 v2(75.33,62.4)
PCI_PIRQC#: length 17.1
  TOP w0.102: RPH1.4 77.46,47.65 v1(76.68,48.43) 75.64,49.47 75.64,53.73 74.85,54.52 74.85,58.1 75.11,58.36 75.11,60.75 74.79,61.07 74.79,61.42 v2(74.34,61.86)
  BOTTOM w0.102: UH1.K17 74.65,62.17 v2(74.34,61.86)
PCI_PIRQD#: length 19.9
  TOP w0.102: v2(75.33,63.61) 74.93,63.21 74.93,62.14 75.11,61.96 75.23,61.96 v1(75.4,61.79) 75.72,61.48 75.72,58.39 75.26,57.93 75.26,54.69 75.76,54.19 75.92,54.19 76.66,53.45 76.66,51.17 76.25,50.76 76.25,49.64 78.46,47.44 RPH1.2
  BOTTOM w0.102: v2(75.33,63.61) 75.59,63.36 UH1.M20
PCI_TPM_TCM: length 12.1
  BOTTOM w0.102: UH1.C40 84.03,58.94 84.38,58.59 84.38,58.46 84.38,58.24 85.11,57.51 85.66,57.51 86.5,58.36 88.95,58.36 89.58,57.72 CH78.1 90.83,57.09 91.29,57.09 92.1,57.9 RH155.2 v1(92.58,59.07)
PCIE_CARD: length 7.8
  BOTTOM w0.076: UH1.AB45 86.42,67.35 86.36,67.41 86.36,67.46 86.46,67.56 86.98,67.56 87.06,67.48 87.06,67.41 87.07,67.4
  BOTTOM w0.102: 87.07,67.4 87.39,67.08 88.31,67.08 89.07,66.32 91.95,66.32 92.04,66.41 92.74,66.41 92.89,66.26 92.89,66.1 92.77,65.98 RH122.1
PCIE_CARD#: length 7.9
  BOTTOM w0.076: UH1.AB43 85.65,67.47 86.13,67.47 86.39,67.73 87.05,67.73 87.18,67.6 87.25,67.6 87.26,67.59
  BOTTOM w0.102: 87.26,67.59 87.5,67.35 88.42,67.35 89.18,66.59 91.84,66.59 91.93,66.68 92.48,66.68 RH121.1
PCIE_EXP: length 7.5
  BOTTOM w0.076: UH1.AF45 86.4,69.01 86.4,69.03 86.47,69.09 86.92,69.09 87.26,68.75 87.97,68.75 88.03,68.7 88.04,68.7
  BOTTOM w0.102: RH139.1 92.86,68.39 92.97,68.49 92.97,68.7 92.84,68.82 91.6,68.82 91.48,68.7 88.04,68.7
PCIE_EXP#: length 7.5
  BOTTOM w0.076: 88.04,68.97 88.03,68.97 87.97,68.92 87.33,68.92 86.99,69.26 86.31,69.26 86.08,69.03 85.58,69.03 UH1.AF43
  BOTTOM w0.102: 88.04,68.97 v3(89.01,68.97) 91.37,68.97 91.49,69.09 92.48,69.09 RH137.1
PCIE_LAN: length 6.1
  BOTTOM w0.076: UH1.AA42 85.6,66.94 85.85,66.68 86.19,66.68 86.33,66.83 86.62,66.83 87.08,66.37 87.34,66.37 87.39,66.32 87.4,66.32
  BOTTOM w0.102: RH92.1 89.82,64.89 89.69,64.89 89.02,65.57 88.45,65.57 87.7,66.32 87.4,66.32
PCIE_LAN#: length 6.1
  BOTTOM w0.076: UH1.AA44 85.88,66.96 85.8,67.05 85.8,67.18 85.91,67.29 86.09,67.29 86.39,66.99 86.69,66.99 87.15,66.54 87.34,66.54 87.39,66.59 87.4,66.59
  BOTTOM w0.102: RH82.1 90.19,65.4 90.19,65.23 90.12,65.16 89.8,65.16 89.13,65.84 v3(88.81,65.84) 88.56,65.84 88.31,66.09 88.31,66.24 88.09,66.45 87.94,66.45 87.81,66.59 87.4,66.59
PCIE_MINI1: length 8.5
  BOTTOM w0.076: 87.3,65.86 87.29,65.86 87.24,65.81 87,65.81 86.6,66.21 86.6,66.28 86.72,66.4 86.72,66.49 86.6,66.61 86.52,66.61 UH1.Y45
  BOTTOM w0.102: 87.3,65.86 87.54,65.86 87.72,65.67 87.88,65.67 88.09,65.46 88.09,65.31 89.3,64.1 91.97,64.1 92.3,63.77 92.65,63.77 92.82,63.94 92.82,64.1 92.73,64.2 RH308.1
PCIE_MINI1#: length 8.5
  BOTTOM w0.076: 87.3,65.6 87.28,65.6 87.23,65.65 86.93,65.65 86.09,66.49 85.58,66.49 UH1.Y43
  BOTTOM w0.102: 87.3,65.6 87.43,65.6 v3(88.84,64.18) 89.19,63.83 91.86,63.83 92.19,63.5 92.48,63.5 RH307.1
PCIE_MINI2: length 124.9
  IN4 w0.089: 85.21,66.3 85.2,66.3 85.15,66.36 83.97,66.36 83.77,66.56 83.77,66.76 v2(83.56,66.97)
  IN4 w0.117: 85.21,66.3 86.23,66.3 89.79,69.87 89.79,73.05 90.22,73.47 90.22,87.8 100.68,98.26 103.24,98.26 103.84,98.85 103.84,99.44 104.6,100.2 104.6,101.72 105.7,102.83 105.99,102.83 108.64,105.48 108.64,106.52 110.03,107.91 110.03,114.97 111.63,116.57 111.63,117.92 112.22,118.51 112.22,134.19 114.33,136.29 114.33,138.87 115.87,140.41 115.87,163.71 116.56,164.4 116.56,167.77 115.35,168.98 115.35,171.54 v2(115.49,171.69)
  BOTTOM w0.089: UH1.AB39 83.91,67.31 v2(83.56,66.97)
  BOTTOM w0.102: v2(115.49,171.69) 115.21,171.41 115.21,171.29 RH126.1
PCIE_MINI2#: length 124.8
  IN4 w0.089: 85.21,66.59 85.19,66.59 85.14,66.54 84.04,66.54 83.95,66.63 83.95,66.84 84.07,66.97 v2(84.2,66.97)
  IN4 w0.117: 85.21,66.59 86.11,66.59 86.33,66.81 86.33,66.99 86.58,67.24 86.76,67.24 87,67.49 87,67.66 87.25,67.91 87.43,67.91 89.51,69.99 89.51,73.17 89.94,73.59 89.94,87.91 100.56,98.54 103.12,98.54 103.55,98.97 103.55,99.56 104.32,100.32 104.32,101.84 105.59,103.11 105.87,103.11 108.36,105.6 108.36,106.64 109.74,108.02 109.74,115.09 111.35,116.69 111.35,118.04 111.94,118.63 111.94,134.3 114.04,136.41 114.04,138.99 115.59,140.53 115.59,163.83 116.27,164.52 116.27,167.65 115.06,168.86 115.06,171.69 114.93,171.82 114.78,171.82 114.69,171.72 v2(114.69,171.69)
  BOTTOM w0.089: UH1.AB40 84.2,67.15 v2(84.2,66.97)
  BOTTOM w0.102: RH127.1 114.94,171.24 114.94,171.44 v2(114.69,171.69)
PCIE_MINI3: length 5.1
  BOTTOM w0.076: 87.15,68.02 87.14,68.02 87.09,68.07 86.93,68.07 86.59,68.41 86.46,68.41 86.38,68.33 86.38,68.22 UH1.AD45
  BOTTOM w0.102: RH135.1 90.25,67.12 90.35,67.22 90.35,67.4 90.22,67.53 v3(89.11,67.53) 88.93,67.53 88.43,68.02 87.96,68.02 87.86,67.92 87.55,67.92 87.45,68.02 87.15,68.02
PCIE_MINI3#: length 5.2
  BOTTOM w0.076: 87.15,68.29 87.14,68.29 87.09,68.24 86.99,68.24 86.66,68.57 86.39,68.57 85.98,68.16 UH1.AD43
  BOTTOM w0.102: 87.15,68.29 88.54,68.29 89.04,67.79 89.92,67.79 RH133.1
PCIE_NVR: length 8.5
  BOTTOM w0.076: UH1.AJ42 85.15,70.14 85.65,70.14 85.88,69.91 86.1,69.91 86.34,70.15 87.05,70.15 87.1,70.1 87.12,70.1
  BOTTOM w0.102: 87.12,70.1 87.44,70.1 v3(88.12,70.79) 88.64,71.31 88.99,71.31 89.14,71.16 91.41,71.16 91.46,71.12 92.48,71.12 RH142.1
PCIE_NVR#: length 8.4
  BOTTOM w0.076: 87.12,70.37 87.1,70.37 87.05,70.32 86.27,70.32 86.1,70.14 86.04,70.14 85.99,70.19 UH1.AJ44
  BOTTOM w0.102: RH144.1 92.84,71.82 92.95,71.71 92.95,71.52 92.81,71.39 91.57,71.39 91.52,71.43 v3(89.56,71.43) 89.25,71.43 89.1,71.57 88.53,71.57 88.4,71.45 88.26,71.45 88.05,71.23 88.05,71.09 87.94,70.98 87.83,70.87 87.69,70.87 87.47,70.66 87.47,70.51 87.32,70.37 87.12,70.37
PCIE_PRX_EXPTX_N7: length 94.8
  TOP w0.102: JIO1.64 20.21,84.3 20.4,84.11 20.93,84.11 v2(21.12,84.3)
  IN1 w0.117: v2(84.22,73.44) 84.12,73.55 84.12,73.62 84.31,73.8 85.7,73.8 86.57,74.67 86.57,76.33 85.79,77.11 85.79,80.54 79.02,87.31 77.14,87.31 71.1,93.36 62.74,93.36 59.23,96.86 32.69,96.86 31.67,97.88 25.57,97.88 22.57,94.88 22.57,90.87 22.29,90.59 22.29,85.22 21.38,84.3 v2(21.12,84.3)
  BOTTOM w0.089: UH1.AT40 84.5,73.17 v2(84.22,73.44)
PCIE_PRX_EXPTX_P7: length 94.8
  TOP w0.102: JIO1.66 19.34,83.69 20.21,83.69 20.21,83.7 20.4,83.89 20.95,83.89 v2(21.12,83.71)
  IN1 w0.117: v2(21.12,83.71) 21.29,83.88 21.3,83.88 21.67,84.26 21.81,84.26 22.09,84.53 22.09,84.67 22.53,85.12 22.53,85.49 22.63,85.6 22.63,86 22.53,86.1 22.53,90.49 22.81,90.77 22.81,94.78 25.67,97.64 31.57,97.64 32.59,96.63 59.13,96.63 62.64,93.12 71,93.12 77.04,87.08 78.92,87.08 85.55,80.45 85.55,77.02 86.33,76.23 86.33,74.77 85.6,74.04 84.21,74.04 v2(83.62,73.44)
  BOTTOM w0.089: UH1.AT39 83.91,73.15 v2(83.62,73.44)
PCIE_PRX_GLANTX_N2: length 39.5
  TOP w0.102: v2(110.44,84.72) 110.25,84.91 110.25,85.38 C459.2
  IN3 w0.089: v2(80.87,73.11) 80.87,72.96 80.8,72.89 80.59,72.89 80.47,73.01 80.47,75.05 80.74,75.32 80.79,75.32 80.79,75.33
  IN3 w0.127: v2(110.44,84.72) 110.28,84.56 110.28,84.03 109.98,83.73 103.5,83.73 103.1,83.33 99.62,83.33 99.24,82.94 92.76,82.94 92.45,82.64 89.02,82.64 86.05,79.67 86.05,78.73 84.68,77.36 82.83,77.36 82.32,76.85 82.32,76.72 81.99,76.4 81.86,76.4 81.59,76.13 81.59,76 81.27,75.67 81.14,75.67 80.79,75.33
  BOTTOM w0.089: v2(80.87,73.11) 80.64,73.34 UH1.AT31
PCIE_PRX_GLANTX_N2_C: length 2.5
  TOP w0.102: C459.1 110.24,86.98 110.24,87.38 110.25,87.39 110.25,87.92 110.24,87.93 110.24,88.3 110.33,88.39 U31.39
PCIE_PRX_GLANTX_P2: length 39.5
  TOP w0.102: C458.2 110.04,85.38 110.04,84.91 v2(109.85,84.72)
  IN3 w0.089: 80.62,75.5 80.61,75.49 80.61,75.44 80.29,75.12 80.29,72.94 80.52,72.71 80.68,72.71 v2(80.87,72.52)
  IN3 w0.127: v2(109.85,84.72) 110.03,84.54 110.03,84.13 109.88,83.98 103.4,83.98 103,83.58 99.52,83.58 99.13,83.19 92.66,83.19 92.35,82.89 88.92,82.89 85.81,79.77 85.81,78.83 84.58,77.61 82.73,77.61 80.62,75.5
  BOTTOM w0.089: UH1.AR31 80.64,72.75 v2(80.87,72.52)
PCIE_PRX_GLANTX_P2_C: length 2.5
  TOP w0.102: C458.1 110.03,86.95 v3(110.03,87.66) 110.03,88.3 109.93,88.39 U31.38
PCIE_PRX_MMITX_N8: length 87.4
  TOP w0.102: v2(20.9,98.59) 20.6,98.89 20.43,98.89 20.24,98.7 JIO1.16
  IN1 w0.089: 84.83,73.24 84.81,73.24 84.78,73.21 84.6,73.21 84.43,73.04 84.25,73.04 83.71,72.49 v2(83.71,72.46)
  IN1 w0.117: 84.83,73.24 85.85,73.24 87.19,74.58 87.19,76.9 87.02,77.07 87.02,77.84 86.48,78.38 86.48,81.12 79.78,87.82 77.44,87.82 71.15,94.11 62.8,94.11 59.29,97.62 33.02,97.62 31.74,98.9 23.74,98.9 23.62,99.01 20.77,99.01 20.65,98.9 20.65,98.72 20.78,98.59 v2(20.9,98.59)
  BOTTOM w0.089: v2(83.71,72.46) 83.31,72.06 UH1.AN38
