# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_C_N1: length 110.6
  TOP w0.109: v2(75.92,149.52) 75.92,149.62 76.07,149.77 76.28,149.77 76.45,149.6 76.45,148.83 76.35,148.73 CC45.2 ; v2(168.06,138.31) 168.53,137.84 JCPU1.H34
  IN3 w0.089: v2(168.06,138.31) 167.8,138.56 167.64,138.56 167.51,138.43 167.51,138.28 167.89,137.9 168.27,137.9 168.47,138.09 168.47,138.62 168.15,138.95 168.15,140.54 168.11,140.57 168.11,140.6
  IN3 w0.14: 168.11,140.6 168.11,142.65 155.63,155.13 139.08,155.13 138.61,154.66 120.76,154.66 119.94,153.84 116.15,153.84 115.62,153.3 107.02,153.3 106.7,152.98 98.92,152.98 97.97,152.03 95.89,152.03 94.81,150.95 90.15,150.95 89.02,149.82 84.65,149.82 84.46,149.63 82.29,149.63 81.38,148.72 79.59,148.72 79.48,148.61 79,148.61 78.89,148.72 78.47,148.72 78.36,148.61 77.87,148.61 77.76,148.72 77.36,148.72 76.63,149.45 76.63,149.73 76.46,149.9 76.27,149.9 76.1,149.73 76.02,149.73 75.92,149.62 v2(75.92,149.52)
PEG_CTX_GRX_C_N2: length 114
  TOP w0.109: v2(74.14,149.52) 74.14,149.62 74.29,149.77 74.5,149.77 74.67,149.6 74.67,148.83 74.57,148.73 CC53.2 ; JCPU1.J33 169.53,136.84 v2(169.06,137.31)
  IN3 w0.089: 166.16,140.65 166.16,140.62 166.19,140.59 166.19,139.87 166.46,139.6 166.46,138.08 166.82,137.72 167.2,137.72 167.45,137.47 167.45,136.94 167.7,136.69 168.44,136.69 v2(169.06,137.31)
  IN3 w0.14: v2(74.14,149.52) 74.14,149.64 74.23,149.73 74.32,149.73 74.49,149.9 74.69,149.9 74.84,149.75 74.84,149.47 75.09,149.22 75.09,149.07 75.44,148.72 75.59,148.72 75.89,148.42 75.89,148.28 76.24,147.93 76.39,147.93 76.76,147.55 81.83,147.55 82.38,148.09 84.92,148.09 85.83,149 89.37,149 89.91,149.54 99.59,149.54 102.03,151.98 106.88,151.98 107.39,152.49 117.96,152.49 118.06,152.59 123.49,152.59 124.69,153.78 127.56,153.78 128.14,153.2 129,153.2 129.99,152.21 138.91,152.21 140.92,154.22 155.34,154.22 166.16,143.4 166.16,140.65
PEG_CTX_GRX_C_N3: length 114.8
  TOP w0.109: CC73.2 72.79,148.73 72.9,148.83 72.9,149.6 72.73,149.77 72.52,149.77 72.36,149.62 v2(72.36,149.52) ; v2(169.06,136.31) JCPU1.H32
  IN3 w0.089: 165.27,140.6 165.27,140.57 165.3,140.54 165.3,138.83 165.45,138.68 165.45,138.15 165.9,137.69 166.24,137.69 166.44,137.49 166.44,137.03 167.76,135.71 168.46,135.71 v2(169.06,136.31)
  IN3 w0.14: 165.27,140.6 165.27,143.1 155.44,152.92 141.3,152.92 139.67,151.3 121.36,151.3 121,151.65 107.77,151.65 107.21,151.09 102.29,151.09 99.27,148.07 89.83,148.07 89.7,148.2 86.46,148.2 85.01,146.75 75.52,146.75 74.96,147.31 74.81,147.31 74.46,147.67 74.46,147.81 74.16,148.11 74.02,148.11 73.66,148.46 73.66,148.6 73.31,148.96 73.31,149.58 72.99,149.9 72.71,149.9 72.54,149.73 72.45,149.73 72.36,149.64 v2(72.36,149.52)
PEG_CTX_GRX_C_N4: length 115.9
  TOP w0.109: v2(169.06,135.31) 169.53,134.84 JCPU1.J31 ; v2(70.59,149.52) 70.59,149.62 70.74,149.77 70.95,149.77 71.12,149.6 71.12,148.83 71.02,148.73 CC46.2
  IN3 w0.089: v2(169.06,135.31) 169.06,135.31 168.45,134.7 167.79,134.7 167.45,135.04 167.45,135.47 166.21,136.7 165.78,136.7 165.44,137.04 165.44,137.48 165.21,137.71 164.84,137.71 164.48,138.07 164.48,140.54 164.44,140.57 164.44,140.59
  IN3 w0.14: v2(70.59,149.52) 70.59,149.65 70.67,149.73 70.76,149.73 70.93,149.9 71.22,149.9 71.46,149.66 71.46,149.2 71.79,148.86 71.79,148.7 72.14,148.36 72.3,148.36 72.59,148.06 72.59,147.9 72.94,147.56 73.1,147.56 74.71,145.95 85.49,145.95 86.83,147.3 89.29,147.3 89.45,147.14 99.53,147.14 102.61,150.23 107.54,150.23 108.15,150.84 120.65,150.84 121.03,150.46 156.77,150.46 164.44,142.78 164.44,140.59
PEG_CTX_GRX_C_N5: length 117.7
  TOP w0.109: v2(167.06,134.31) 167.53,133.84 JCPU1.G30 ; v2(68.81,149.52) 68.81,149.62 68.96,149.77 69.17,149.77 69.34,149.6 69.34,148.83 69.24,148.73 CC74.2
  IN3 w0.089: 163.44,140.59 163.44,140.57 163.47,140.54 163.47,138.06 163.8,137.73 164.2,137.73 164.46,137.46 164.46,135.04 164.79,134.71 167.22,134.71 167.38,134.56 167.42,134.52 167.42,134.37 167.29,134.24 167.13,134.24 v2(167.06,134.31)
  IN3 w0.14: v2(68.81,149.52) 68.81,149.63 68.9,149.73 68.98,149.73 69.15,149.9 69.37,149.9 69.67,149.6 69.67,149.19 69.57,149.09 69.57,148.57 69.67,148.47 69.67,148.03 70.21,147.49 70.21,147.34 70.56,146.99 70.7,146.99 72.55,145.15 87.86,145.15 88.58,145.87 99.43,145.87 102.92,149.37 107.9,149.37 108.56,150.03 120.32,150.03 120.8,149.54 156.48,149.54 163.44,142.59 163.44,140.59
PEG_CTX_GRX_C_N6: length 109.5
  TOP w0.109: JCPU1.C33 v2(163.06,136.31) ; v2(67.03,149.52) 67.03,149.62 67.18,149.77 67.39,149.77 67.56,149.6 67.56,148.83 67.46,148.73 CC47.2
  IN3 w0.14: v2(67.03,149.52) 67.17,149.66 67.42,149.66 67.66,149.41 67.66,148.47 71.79,144.35 88.44,144.35 89.13,145.03 99.84,145.03 103.02,148.22 130.1,148.22 130.5,148.63 132.82,148.63 140.49,140.96 160.15,140.96 162.26,138.85 162.26,137.11 v2(163.06,136.31)
PEG_CTX_GRX_C_N7: length 111
  TOP w0.109: v2(162.13,135.29) 162.26,135.29 162.59,135.63 JCPU1.B32 ; v2(65.25,149.52) 65.25,149.62 65.4,149.77 65.61,149.77 65.78,149.6 65.78,148.83 65.68,148.73 CC56.2
  IN3 w0.089: v2(162.13,135.29) 162.13,135.46 161.74,135.84 161.5,136.08 161.5,137.52 161.2,137.82 161.14,137.88 161.1,137.88 161.08,137.89
  IN3 w0.14: 161.08,137.89 158.83,140.15 138.63,140.15 131.49,147.28 121.86,147.28 121.74,147.41 103.35,147.41 100.18,144.23 96.29,144.23 95,142.94 88.41,142.94 87.81,143.55 70.85,143.55 65.9,148.5 65.9,149.53 65.7,149.73 65.46,149.73 v2(65.25,149.52)
PEG_CTX_GRX_C_N8: length 113.4
  TOP w0.109: CC75.2 63.9,148.73 64.01,148.83 64.01,149.6 63.84,149.77 63.63,149.77 63.47,149.62 v2(63.47,149.52) ; JCPU1.B31 162.59,134.83 v2(163.09,134.33)
  IN3 w0.089: 160.13,136.82 160.15,136.8 160.19,136.8 161.49,135.5 161.49,135.07 161.84,134.72 162.33,134.72 162.36,134.75 162.67,134.75 v2(163.09,134.33)
  IN3 w0.14: 160.13,136.82 157.72,139.23 136.75,139.23 130.05,145.94 121.76,145.94 121.18,146.52 103.78,146.52 99.36,142.1 87.73,142.1 87.44,142.39 70.11,142.39 69.47,143.04 69.47,143.22 64.13,148.55 64.13,149.49 63.89,149.74 63.69,149.74 v2(63.47,149.52)
PEG_CTX_GRX_C_N9: length 115.2
  TOP w0.109: JCPU1.A30 161.53,133.84 v2(161.06,134.31) ; CC48.2 62.13,148.73 62.23,148.83 62.23,149.6 62.06,149.77 61.85,149.77 61.7,149.62 v2(61.7,149.52)
  IN3 w0.089: 160.28,135.23 160.3,135.21 160.35,135.21 160.51,135.04 160.82,134.73 161.29,134.73 161.59,134.43 161.59,134.31 161.48,134.2 161.17,134.2 v2(161.06,134.31)
  IN3 w0.14: 160.28,135.23 157.36,138.15 136.2,138.15 130.46,143.9 122.23,143.9 120.7,145.43 104.57,145.43 102.82,143.67 102.82,142.25 102.21,141.64 100.19,141.64 99.84,141.29 87.37,141.29 87.08,141.59 69.32,141.59 68.09,142.81 67.18,142.81 66.55,143.44 66.55,144.56 62.51,148.6 62.51,149.45 62.26,149.69 61.87,149.69 v2(61.7,149.52)
PEG_CTX_GRX_C_N10: length 116.4
  TOP w0.109: JCPU1.B29 162.53,132.84 v2(162.06,133.31) ; CC59.2 60.35,148.73 60.45,148.83 60.45,149.6 60.28,149.77 60.07,149.77 59.92,149.62 v2(59.92,149.52)
  IN3 w0.089: 160.86,133.69 160.88,133.69 160.91,133.72 162.39,133.72 162.53,133.58 162.53,133.31 162.41,133.19 162.18,133.19 v2(162.06,133.31)
  IN3 w0.14: v2(59.92,149.52) 60.09,149.7 60.27,149.7 65.1,144.87 65.1,143.6 66.82,141.87 67.77,141.87 69.28,140.36 108.16,140.36 111.46,143.65 118.26,143.65 119.7,142.2 130.96,142.2 135.9,137.25 157.12,137.25 160.69,133.69 160.86,133.69
PEG_CTX_GRX_C_N11: length 115.2
  TOP w0.109: v2(58.14,149.52) 58.14,149.62 58.29,149.77 58.5,149.77 58.67,149.6 58.67,148.83 58.57,148.73 CC76.2 ; v2(161.06,132.31) 161.53,131.84 JCPU1.A28
  IN3 w0.089: 160.84,132.69 160.86,132.69 160.89,132.72 161.45,132.72 161.57,132.6 161.57,132.37 161.42,132.22 161.15,132.22 v2(161.06,132.31)
  IN3 w0.14: 160.84,132.69 160.55,132.69 156.91,136.34 132.57,136.34 130.97,137.94 126.44,137.94 124.82,139.56 66.93,139.56 65.62,140.87 65.62,141.55 63.63,143.54 63.63,144.56 58.49,149.7 58.32,149.7 v2(58.14,149.52)
PEG_CTX_GRX_C_N12: length 118
  TOP w0.109: v2(162.06,131.31) 162.53,130.84 JCPU1.B27 ; v2(56.36,149.52) 56.36,149.62 56.51,149.77 56.72,149.77 56.89,149.6 56.89,148.83 56.79,148.73 CC49.2
  IN3 w0.089: v2(162.06,131.31) 162.06,131.31 162.14,131.23 162.46,131.23 162.56,131.33 162.56,131.54 162.37,131.73 160.76,131.73 160.73,131.7 160.71,131.7
  IN3 w0.14: 160.71,131.7 160.41,131.7 156.59,135.52 132.23,135.52 130.63,137.12 125.86,137.12 124.22,138.76 66.59,138.76 64.67,140.68 64.67,140.91 62.13,143.45 62.13,144.31 56.72,149.72 56.54,149.72 56.36,149.54 v2(56.36,149.52)
PEG_CTX_GRX_C_N13: length 121.2
  TOP w0.109: v2(162.06,130.31) JCPU1.A26 ; CC62.2 55.01,148.73 55.12,148.83 55.12,149.6 54.95,149.77 54.74,149.77 54.58,149.62 v2(54.58,149.52)
  IN3 w0.089: v2(162.06,130.31) 162.15,130.21 162.43,130.21 162.56,130.34 162.56,130.59 162.41,130.74 161.91,130.74 161.82,130.65 160.55,130.65 160.51,130.62 160.49,130.62
  IN3 w0.14: v2(54.58,149.52) 54.79,149.72 54.94,149.72 60.68,143.98 60.68,143.44 62.28,141.84 62.28,140.17 63.76,138.69 63.76,138.11 64.27,137.6 102.49,137.6 102.76,137.32 123.12,137.32 124.23,136.21 129.95,136.21 130.35,135.81 130.75,135.81 131.86,134.71 156.26,134.71 160.35,130.62 160.49,130.62
PEG_CTX_GRX_C_N14: length 123.8
  TOP w0.109: CC77.2 53.24,148.73 53.34,148.83 53.34,149.6 53.17,149.77 52.96,149.77 52.81,149.62 v2(52.81,149.52) ; JCPU1.B25 162.53,128.84 v2(162.06,129.31)
  IN3 w0.089: 160.49,129.82 160.5,129.82 160.53,129.85 161.68,129.85 161.8,129.73 162.43,129.73 162.58,129.58 162.58,129.35 162.46,129.22 162.15,129.22 v2(162.06,129.31)
  IN3 w0.14: 160.49,129.82 160.02,129.82 155.94,133.9 129.46,133.9 127.99,135.37 123.62,135.37 122.57,136.42 102.42,136.42 102.05,136.79 62.65,136.79 61.26,138.19 61.26,138.64 59.41,140.5 59.41,143.21 59.21,143.42 59.21,143.62 53.95,148.88 53.94,148.88 53.11,149.71 53,149.71 v2(52.81,149.52)
PEG_CTX_GRX_C_N15: length 126.2
  TOP w0.109: JCPU1.A24 161.53,127.84 v2(161.06,128.31) ; CC50.2 51.46,148.73 51.56,148.83 51.56,149.6 51.39,149.77 51.18,149.77 51.03,149.62 v2(51.03,149.52)
  IN3 w0.089: v2(161.06,128.31) 161.14,128.23 161.44,128.23 161.57,128.36 161.57,128.52 161.37,128.72 160.48,128.72 160.45,128.68 160.43,128.68
  IN3 w0.14: v2(51.03,149.52) 51.23,149.72 51.35,149.72 57.99,143.09 57.99,142.46 57.48,141.95 57.48,138.62 60.1,135.99 101.31,135.99 102.56,134.73 121.69,134.73 123.34,133.08 155.62,133.08 160.02,128.68 160.43,128.68
PEG_CTX_GRX_C_P0: length 107.8
  TOP w0.109: v2(77.7,150.15) 77.87,149.98 78.05,149.98 78.44,149.59 78.44,149 CC67.2 ; JCPU1.J35 v2(169.06,138.31)
  IN3 w0.089: 169.7,140.62 169.7,140.59 169.67,140.56 169.67,138.92 169.38,138.63 169.14,138.63 169.06,138.55 v2(169.06,138.31)
  IN3 w0.14: v2(77.7,150.15) 77.77,150.08 78.26,150.08 78.44,149.9 78.79,149.9 80.7,151.81 86.31,151.81 87.43,152.94 93.36,152.94 94.53,154.12 106.01,154.12 106.27,154.37 110.15,154.37 111.53,155.74 137.87,155.74 138.35,156.22 156.19,156.22 169.7,142.71 169.7,140.62
PEG_CTX_GRX_C_P1: length 110.6
  TOP w0.109: CC68.2 76.66,149 76.66,149.69 76.37,149.98 76.09,149.98 v2(75.92,150.15) ; v2(167.06,138.31) 167.53,137.84 JCPU1.G34
  IN3 w0.089: v2(167.06,138.31) 167.21,138.31 167.37,138.15 167.81,137.71 168.35,137.71 168.66,138.02 168.66,138.7 168.34,139.03 168.34,140.55 168.37,140.58 168.37,140.6
  IN3 w0.14: v2(75.92,150.15) 76.57,150.15 76.88,149.84 76.88,149.55 77.46,148.97 81.28,148.97 82.19,149.88 84.36,149.88 84.55,150.07 88.91,150.07 90.05,151.2 94.7,151.2 95.79,152.29 97.86,152.29 98.81,153.24 106.6,153.24 106.92,153.56 115.51,153.56 116.05,154.09 119.83,154.09 120.66,154.92 138.5,154.92 138.97,155.39 155.74,155.39 168.37,142.76 168.37,140.6
PEG_CTX_GRX_C_P2: length 114
  TOP w0.109: v2(74.14,150.15) 74.31,149.98 74.59,149.98 74.89,149.69 74.89,149 CC51.2 ; v2(168.03,137.28) 168.48,136.84 JCPU1.H33
  IN3 w0.089: v2(168.03,137.28) 168.2,137.45 168.49,137.45 168.61,137.33 168.61,137.13 168.36,136.88 167.78,136.88 167.64,137.02 167.64,137.55 167.28,137.91 166.9,137.91 166.65,138.16 166.65,139.68 166.38,139.95 166.38,140.59 166.41,140.62 166.41,140.65
  IN3 w0.14: v2(74.14,150.15) 74.8,150.15 75.1,149.86 75.1,149.57 76.87,147.8 81.73,147.8 82.27,148.35 84.82,148.35 85.73,149.26 89.26,149.26 89.8,149.8 99.49,149.8 101.93,152.24 106.78,152.24 107.28,152.74 117.85,152.74 117.95,152.85 123.39,152.85 124.58,154.04 127.66,154.04 128.25,153.45 129.11,153.45 130.1,152.46 138.81,152.46 140.74,154.4 140.81,154.47 155.45,154.47 166.41,143.5 166.41,140.65
PEG_CTX_GRX_C_P3: length 114.8
  TOP w0.109: v2(72.36,150.15) 72.53,149.98 72.81,149.98 73.11,149.69 73.11,149 CC52.2 ; v2(168.06,136.31) JCPU1.G32
  IN3 w0.089: v2(168.06,136.31) 168.2,136.45 168.52,136.45 168.65,136.32 168.65,136.17 168.38,135.9 167.84,135.9 166.64,137.11 166.64,137.57 166.32,137.88 165.98,137.88 165.64,138.22 165.64,138.75 165.49,138.9 165.49,140.54 165.52,140.57 165.52,140.6
  IN3 w0.14: v2(72.36,150.15) 73.1,150.15 73.56,149.69 73.56,149.06 75.62,147 84.9,147 86.35,148.45 89.81,148.45 89.93,148.33 99.16,148.33 102.18,151.35 107.11,151.35 107.67,151.91 121.11,151.91 121.47,151.55 139.57,151.55 141.19,153.18 155.55,153.18 165.52,143.2 165.52,140.6
PEG_CTX_GRX_C_P4: length 115.9
  TOP w0.109: v2(168.06,135.31) 168.53,134.84 JCPU1.H31 ; v2(70.59,150.15) 70.76,149.98 71.03,149.98 71.33,149.69 71.33,149 CC69.2
  IN3 w0.089: 164.7,140.59 164.7,140.57 164.67,140.54 164.67,138.15 164.92,137.9 165.29,137.9 165.63,137.55 165.63,137.12 165.86,136.89 166.29,136.89 167.64,135.55 167.64,135.12 167.87,134.89 168.37,134.89 168.62,135.14 168.62,135.35 168.49,135.48 168.23,135.48 v2(168.06,135.31)
  IN3 w0.14: v2(70.59,150.15) 71.33,150.15 71.71,149.77 71.71,149.31 74.81,146.2 85.38,146.2 86.73,147.55 89.4,147.55 89.55,147.39 99.42,147.39 102.51,150.48 107.44,150.48 108.05,151.09 120.75,151.09 121.14,150.71 156.87,150.71 164.7,142.89 164.7,140.59
PEG_CTX_GRX_C_P5: length 117.8
  TOP w0.109: CC54.2 69.55,149 69.55,149.69 69.26,149.98 68.98,149.98 v2(68.81,150.15) ; v2(168.06,134.31) 168.53,133.84 JCPU1.H30
  IN3 w0.089: v2(168.06,134.31) 167.71,134.31 167.61,134.4 167.61,134.6 167.52,134.69 167.3,134.91 164.86,134.91 164.65,135.12 164.65,137.54 164.27,137.92 163.87,137.92 163.66,138.14 163.66,140.54 163.69,140.57 163.69,140.59
  IN3 w0.14: 163.69,140.59 163.69,142.7 156.59,149.8 120.91,149.8 120.42,150.28 108.45,150.28 107.79,149.62 102.81,149.62 99.32,146.13 88.48,146.13 87.76,145.4 72.65,145.4 69.92,148.13 69.92,149.71 69.48,150.15 v2(68.81,150.15)
PEG_CTX_GRX_C_P6: length 109.4
  TOP w0.109: JCPU1.B33 v2(163.06,137.31) ; CC55.2 67.77,149 67.77,149.69 67.48,149.98 67.2,149.98 v2(67.03,150.15)
  IN3 w0.14: v2(67.03,150.15) 67.27,149.91 67.52,149.91 67.92,149.52 67.92,148.58 71.89,144.6 88.34,144.6 89.02,145.29 99.73,145.29 102.92,148.48 129.99,148.48 130.4,148.88 132.92,148.88 140.59,141.21 160.26,141.21 162.51,138.96 162.51,137.22 162.7,137.02 162.87,137.02 163.06,137.21 v2(163.06,137.31)
PEG_CTX_GRX_C_P7: length 110.9
  TOP w0.109: CC70.2 66,149 66,149.69 65.7,149.98 65.42,149.98 v2(65.25,150.15) ; v2(162.15,136.31) 161.68,135.84 JCPU1.A32
  IN3 w0.089: 161.26,138.07 161.27,138.07 161.27,138.02 161.34,137.95 161.69,137.6 161.69,136.16 161.82,136.03 162.07,136.03 162.15,136.11 v2(162.15,136.31)
  IN3 w0.14: v2(65.25,150.15) 65.42,149.98 65.8,149.98 66.15,149.63 66.15,148.6 70.95,143.8 87.91,143.8 88.52,143.2 94.89,143.2 96.19,144.49 100.07,144.49 103.25,147.66 121.84,147.66 121.97,147.54 131.6,147.54 138.74,140.4 158.94,140.4 161.26,138.07
PEG_CTX_GRX_C_P8: length 113.4
  TOP w0.109: CC57.2 64.22,149 64.22,149.69 63.92,149.98 63.64,149.98 v2(63.47,150.15) ; v2(163.06,135.31) 163.53,134.84 JCPU1.C31
  IN3 w0.089: 160.31,137 160.33,136.98 160.33,136.94 161.68,135.58 161.68,135.15 161.92,134.91 162.25,134.91 162.29,134.94 162.7,134.94 163.06,135.3 v2(163.06,135.31)
  IN3 w0.14: 160.31,137 160.18,137.13 157.82,139.48 136.86,139.48 130.15,146.19 121.87,146.19 121.28,146.77 103.68,146.77 99.26,142.35 87.84,142.35 87.55,142.65 70.22,142.65 69.72,143.14 69.72,143.32 64.39,148.66 64.39,149.6 63.99,149.99 63.63,149.99 v2(63.47,150.15)
PEG_CTX_GRX_C_P9: length 115.2
  TOP w0.109: JCPU1.B30 162.53,133.84 v2(162.06,134.31) ; v2(61.7,150.15) 61.87,149.98 62.14,149.98 62.44,149.69 62.44,149 CC58.2
  IN3 w0.089: v2(162.06,134.31) 161.88,134.31 161.78,134.41 161.78,134.51 161.37,134.92 160.9,134.92 160.48,135.35 160.48,135.39 160.46,135.41
  IN3 w0.14: 160.46,135.41 157.47,138.4 136.31,138.4 130.56,144.15 122.33,144.15 120.8,145.68 104.47,145.68 102.56,143.78 102.56,142.35 102.11,141.9 100.08,141.9 99.73,141.55 87.48,141.55 87.18,141.84 69.42,141.84 68.2,143.07 67.28,143.07 66.8,143.55 66.8,144.67 62.76,148.71 62.76,149.55 62.37,149.95 61.9,149.95 v2(61.7,150.15)
PEG_CTX_GRX_C_P10: length 116.4
  TOP w0.109: CC71.2 60.66,149 60.66,149.69 60.37,149.98 60.09,149.98 v2(59.92,150.15) ; v2(163.06,133.31) 163.53,132.84 JCPU1.C29
  IN3 w0.089: 160.86,133.94 160.87,133.94 160.9,133.91 162.47,133.91 162.72,133.66 162.72,133.48 162.89,133.31 v2(163.06,133.31)
  IN3 w0.14: v2(59.92,150.15) 60.12,149.95 60.38,149.95 65.35,144.97 65.35,143.7 66.93,142.13 67.87,142.13 69.39,140.61 108.06,140.61 111.35,143.9 118.36,143.9 119.81,142.46 131.06,142.46 136.01,137.51 157.23,137.51 160.79,133.94 160.86,133.94
PEG_CTX_GRX_C_P11: length 115.2
  TOP w0.109: CC60.2 58.88,149 58.88,149.69 58.59,149.98 58.31,149.98 v2(58.14,150.15) ; JCPU1.B28 162.53,131.84 v2(162.06,132.31)
  IN3 w0.089: v2(162.06,132.31) 161.91,132.31 161.76,132.46 161.76,132.68 161.53,132.91 160.89,132.91 160.86,132.94 160.84,132.94
  IN3 w0.14: v2(58.14,150.15) 58.34,149.95 58.6,149.95 63.88,144.67 63.88,143.65 65.88,141.65 65.88,140.97 67.04,139.81 124.92,139.81 126.55,138.19 131.08,138.19 132.68,136.59 157.01,136.59 160.66,132.94 160.84,132.94
PEG_CTX_GRX_C_P12: length 118
  TOP w0.109: JCPU1.C27 163.53,130.84 v2(163.06,131.31) ; CC61.2 57.11,149 57.11,149.69 56.81,149.98 56.53,149.98 v2(56.36,150.15)
  IN3 w0.089: v2(163.06,131.31) 162.86,131.31 162.75,131.42 162.75,131.62 162.45,131.92 160.76,131.92 160.73,131.95 160.71,131.95
  IN3 w0.14: v2(56.36,150.15) 56.54,149.97 56.82,149.97 62.38,144.42 62.38,143.55 64.92,141.01 64.92,140.78 66.69,139.01 124.33,139.01 125.96,137.38 130.73,137.38 132.33,135.78 156.69,135.78 160.51,131.95 160.71,131.95
PEG_CTX_GRX_C_P13: length 121.2
  TOP w0.109: v2(163.06,130.31) JCPU1.B26 ; CC72.2 55.33,149 55.33,149.69 55.03,149.98 54.75,149.98 v2(54.58,150.15)
  IN3 w0.089: v2(163.06,130.31) 162.88,130.31 162.75,130.44 162.75,130.67 162.49,130.93 161.83,130.93 161.74,130.85 160.55,130.85 160.51,130.88 160.49,130.88
  IN3 w0.14: 160.49,130.88 160.45,130.88 156.37,134.96 131.96,134.96 130.86,136.07 130.45,136.07 130.06,136.46 124.34,136.46 123.22,137.57 102.87,137.57 102.59,137.85 64.38,137.85 64.01,138.22 64.01,138.79 62.53,140.27 62.53,141.95 60.93,143.55 60.93,144.09 55.04,149.97 54.76,149.97 v2(54.58,150.15)
PEG_CTX_GRX_C_P14: length 123.7
  TOP w0.109: CC63.2 53.55,149 53.55,149.69 53.25,149.98 52.98,149.98 v2(52.81,150.15) ; JCPU1.C25 163.53,128.84 v2(163.06,129.31)
  IN3 w0.089: 160.49,130.07 160.5,130.07 160.53,130.04 161.76,130.04 161.88,129.92 162.51,129.92 162.77,129.66 162.77,129.41 162.88,129.31 v2(163.06,129.31)
  IN3 w0.14: 160.49,130.07 160.12,130.07 156.04,134.15 129.56,134.15 128.09,135.62 123.73,135.62 122.67,136.68 102.53,136.68 102.16,137.05 62.76,137.05 61.52,138.29 61.52,138.75 59.66,140.6 59.66,143.32 59.46,143.52 59.46,143.73 54.05,149.14 54.05,149.14 53.22,149.97 52.99,149.97 v2(52.81,150.15)
PEG_CTX_GRX_C_P15: length 126.3
  TOP w0.109: JCPU1.B24 162.53,127.84 v2(162.06,128.31) ; v2(51.03,150.15) 51.2,149.98 51.48,149.98 51.77,149.69 51.77,149 CC64.2
  IN3 w0.089: v2(162.06,128.31) 161.85,128.31 161.76,128.41 161.76,128.6 161.45,128.91 160.48,128.91 160.45,128.94 160.43,128.94
  IN3 w0.14: v2(51.03,150.15) 51.2,149.97 51.46,149.97 58.24,143.19 58.24,142.35 57.73,141.85 57.73,138.72 60.21,136.25 101.41,136.25 102.67,134.99 121.8,134.99 123.45,133.34 155.73,133.34 160.13,128.94 160.43,128.94
PEG_CTX_GRX_N0: length 3.1
  TOP w0.109: CC44.1 78.16,147.48 v3(78.16,146.79) 78.16,146.48 78.08,146.4 78.08,145.82 77.94,145.67 JMXM1.176
PEG_CTX_GRX_N1: length 3.2
  TOP w0.109: JMXM1.170 76.44,145.67 76.58,145.82 76.58,146.11 76.36,146.34 76.36,147.04 76.39,147.06 76.39,147.48 CC45.1
PEG_CTX_GRX_N2: length 3.3
  TOP w0.109: CC53.1 74.61,147.48 v3(74.61,146.85) 74.61,146.47 75.08,146 75.08,145.82 74.94,145.67 JMXM1.164
PEG_CTX_GRX_N3: length 4.1
  TOP w0.109: CC73.1 72.82,147.49 72.82,147.37 72.63,147.18 72.6,147.18 72.17,146.75 71.82,146.75 71.08,146.01 71.08,145.82 70.94,145.67 JMXM1.156
PEG_CTX_GRX_N4: length 3.9
  TOP w0.109: JMXM1.150 69.44,145.67 69.58,145.82 69.58,146.12 v3(70.13,146.67) 70.37,146.91 70.65,146.91 71.05,147.31 71.05,147.48 CC46.1
PEG_CTX_GRX_N5: length 3.6
  TOP w0.109: CC74.1 69.27,147.48 69.27,147.28 v3(68.75,146.76) 68.08,146.1 68.08,145.79 67.94,145.65 JMXM1.144
PEG_CTX_GRX_N6: length 3.5
  TOP w0.109: CC47.1 67.5,147.48 67.5,147.16 v3(67.13,146.79) 66.58,146.25 66.58,145.79 66.44,145.65 JMXM1.138
PEG_CTX_GRX_N7: length 3.4
  TOP w0.109: JMXM1.132 64.94,145.67 65.08,145.82 65.08,146.4 v3(65.5,146.81) 65.72,147.03 65.72,147.48 CC56.1
PEG_CTX_GRX_N8: length 3.3
  TOP w0.109: JMXM1.126 63.44,145.67 63.58,145.82 63.58,146.21 63.94,146.56 v3(63.94,146.83) 63.94,147.48 CC75.1
PEG_CTX_GRX_N9: length 3.1
  TOP w0.109: JMXM1.120 61.94,145.67 62.08,145.82 62.08,146.47 62.16,146.54 v3(62.16,146.79) 62.16,147.48 CC48.1
PEG_CTX_GRX_N10: length 3.2
  TOP w0.109: JMXM1.114 60.44,145.7 60.58,145.84 60.58,146.33 60.38,146.53 v3(60.38,146.81) 60.38,147.48 CC59.1
PEG_CTX_GRX_N11: length 3.3
  TOP w0.109: CC76.1 58.62,147.47 58.62,146.91 v3(58.8,146.73) 59.08,146.44 59.08,145.86 58.94,145.72 JMXM1.108
PEG_CTX_GRX_N12: length 3.4
  TOP w0.109: CC49.1 56.81,147.49 56.81,146.94 v3(57.01,146.75) 57.58,146.17 57.58,145.82 57.44,145.67 JMXM1.102
PEG_CTX_GRX_N13: length 3.5
  TOP w0.109: CC62.1 55.05,147.48 55.05,147.08 v3(55.36,146.77) 56.09,146.04 56.09,145.81 55.94,145.67 JMXM1.96
PEG_CTX_GRX_N14: length 3.9
  TOP w0.109: CC77.1 53.27,147.48 53.27,147.16 v3(53.62,146.8) 53.79,146.63 54.13,146.63 54.59,146.17 54.59,145.82 54.44,145.67 JMXM1.90
PEG_CTX_GRX_N15: length 4.2
  TOP w0.109: CC50.1 51.49,147.48 51.49,146.91 51.95,146.45 52.75,146.45 53.09,146.11 53.09,145.8 52.94,145.65 JMXM1.84
PEG_CTX_GRX_P0: length 3.2
  TOP w0.109: JMXM1.178 78.44,145.67 78.3,145.82 78.3,146.31 78.4,146.41 78.4,147.07 78.37,147.09 78.37,147.48 CC67.1
PEG_CTX_GRX_P1: length 3.2
  TOP w0.109: JMXM1.172 76.94,145.67 76.8,145.82 76.8,146.2 76.6,146.4 v3(76.6,146.76) 76.6,147.48 CC68.1
PEG_CTX_GRX_P2: length 3.3
  TOP w0.109: CC51.1 74.82,147.48 74.82,147.15 74.84,147.13 74.84,146.54 75.3,146.08 75.3,145.82 75.44,145.67 JMXM1.166
PEG_CTX_GRX_P3: length 4.1
  TOP w0.109: CC52.1 73.03,147.47 73.03,147.28 v3(72.57,146.82) 72.29,146.54 71.91,146.54 71.3,145.93 71.3,145.82 71.44,145.67 JMXM1.158
PEG_CTX_GRX_P4: length 3.9
  TOP w0.109: CC69.1 71.26,147.48 71.26,147.22 70.74,146.7 70.49,146.7 70.1,146.31 70.07,146.31 69.8,146.04 69.8,145.82 69.94,145.67 JMXM1.152
PEG_CTX_GRX_P5: length 3.6
  TOP w0.109: JMXM1.146 68.44,145.65 68.3,145.79 68.3,146.01 68.68,146.4 68.71,146.4 69.11,146.79 69.11,146.82 69.48,147.2 69.48,147.48 CC54.1
PEG_CTX_GRX_P6: length 3.5
  TOP w0.109: JMXM1.140 66.94,145.65 66.8,145.79 66.8,146.16 67.06,146.43 67.09,146.43 67.49,146.82 67.49,146.85 67.71,147.07 67.71,147.48 CC55.1
PEG_CTX_GRX_P7: length 3.4
  TOP w0.109: JMXM1.134 65.44,145.67 65.3,145.82 65.3,146.31 65.43,146.45 65.46,146.45 65.86,146.84 65.86,146.87 65.93,146.94 65.93,147.48 CC70.1
PEG_CTX_GRX_P8: length 3.3
  TOP w0.109: CC57.1 64.15,147.48 64.15,147.13 64.17,147.1 64.17,146.5 63.8,146.12 63.8,145.82 63.94,145.67 JMXM1.128
PEG_CTX_GRX_P9: length 3.2
  TOP w0.109: CC58.1 62.37,147.48 62.37,147.09 62.39,147.07 62.39,146.48 62.3,146.38 62.3,145.82 62.44,145.67 JMXM1.122
PEG_CTX_GRX_P10: length 3.2
  TOP w0.109: CC71.1 60.59,147.48 60.59,147.12 60.62,147.1 60.62,146.6 60.8,146.42 60.8,145.84 60.94,145.7 JMXM1.116
PEG_CTX_GRX_P11: length 3.3
  TOP w0.109: CC60.1 58.83,147.49 58.83,147.03 59.3,146.56 59.3,145.86 59.44,145.72 JMXM1.110
PEG_CTX_GRX_P12: length 3.4
  TOP w0.109: JMXM1.104 57.94,145.67 57.8,145.82 57.8,146.26 57.37,146.68 57.37,146.71 57.02,147.06 57.02,147.46 CC61.1
PEG_CTX_GRX_P13: length 3.6
  TOP w0.109: JMXM1.98 56.44,145.67 56.3,145.81 56.3,146.13 55.72,146.7 55.72,146.73 55.33,147.13 55.3,147.13 55.26,147.16 55.26,147.48 CC72.1
PEG_CTX_GRX_P14: length 3.8
  TOP w0.109: CC63.1 53.48,147.47 53.48,147.28 53.91,146.84 54.21,146.84 54.8,146.25 54.8,145.82 54.94,145.68 JMXM1.92
PEG_CTX_GRX_P15: length 4.2
  TOP w0.109: JMXM1.86 53.44,145.66 53.3,145.8 53.3,146.19 52.81,146.69 v3(52.26,146.69) 52.01,146.69 51.71,146.99 51.71,147.48 CC64.1
PEQ: length 11.5
  TOP w0.102: v2(35.28,161.58) R69.2 R70.2 ; U9.8 v2(31.34,154.44)
  BOTTOM w0.102: v2(35.28,161.58) v1(34.75,161.05) 33.93,160.24 33.93,158.53 34.19,158.28 34.19,157.47 34.01,157.29 34.01,157.11 v2(31.34,154.44)
PHASE1: length 17.4
  TOP w0.102: PC540.2 v1(157.57,164.21)
  IN3 w1.016: 165.96,165.55 165.58,165.16 163.88,165.16 162.53,163.82 156.51,163.82 156.11,164.22 ; 167.99,163.89 170.36,163.89 170.86,164.4 172.31,164.4 172.95,165.04
  vias: v3(155.85,165.8) v3(155.85,165.16) v3(167.8,165.61) v3(167.8,164.97) v3(173.9,165.61) v3(173.9,164.97)
PHASE2: length 24.7
  IN3 w1.016: 179.42,166.69 179.32,166.79 160.53,166.79 ; 180.69,166.69 180.95,166.94 186.03,166.94 186.28,166.69
  vias: v1(159.65,166.09) v3(158.93,167.02) v3(159.38,166.56) v3(180.25,165.61) v3(180.25,164.97) v3(186.35,165.61) v3(186.35,164.97)
PHASE3: length 11.2
  TOP w0.102: v1(193.76,165.05) 193.52,164.81 v3(193.52,164.15)
  IN3 w1.016: 200.33,170.42 199.82,169.91 199.82,166.56 200.13,166.26 ; 194.92,163.64 195.05,163.51 200.18,163.51 200.48,163.82
  vias: v3(193.52,163.51) v3(200.13,171.98) v3(200.15,171.35) v3(200.32,165.35) v3(200.32,164.72)
PLTRST_GPU#: length 228.2
  TOP w0.102: v2(82.9,96.03) 82.88,96 65.06,96 57.57,88.5 v1(57.57,87.41) RH114.1 ; v2(111.43,123.05) 110.79,123.69 110.79,126.02 110.21,126.61 U16.2
  IN3 w0.127: v2(103.53,103.7) 102.94,103.7 102.67,103.98 102.67,106.77 101.62,107.81 101.01,107.81 100.79,107.58 100.79,107.28 100.56,107.05 99.03,107.05 98.91,106.92 98.91,106.49 99.03,106.36 101.62,106.36 101.83,106.16 101.83,105.7 101.73,105.6 100.23,105.6 100.1,105.47 100.1,105.05 100.23,104.93 101.67,104.93 101.8,104.8 101.8,104.55 101.67,104.42 100.2,104.42 100.07,104.29 100.07,104.04 100.2,103.91 101.67,103.91 101.8,103.78 101.8,103.53 101.67,103.4 99.47,103.4 99.34,103.28 99.34,103.02 99.47,102.89 103.81,102.89 103.94,102.77 103.94,102.51 103.81,102.39 101.75,102.39 101.62,102.26 101.62,97.32 101.5,97.19 101.24,97.19 101.12,97.32 101.12,102.26 100.99,102.39 100.73,102.39 100.61,102.26 100.61,97.07 100.48,96.94 100.23,96.94 100.1,97.07 100.1,102.26 99.97,102.39 99.72,102.39 99.59,102.26 99.59,97.04 99.46,96.91 99.21,96.91 99.08,97.04 99.08,102.26 98.96,102.39 98.7,102.39 98.58,102.26 98.58,97.04 98.45,96.91 98.19,96.91 98.07,97.04 98.07,102.26 97.94,102.39 97.69,102.39 97.56,102.26 97.56,99.84 97.43,99.71 97.06,99.71 96.93,99.58 96.93,98.57 96.8,98.44 96.55,98.44 96.42,98.57 96.42,99.58 96.3,99.71 96.04,99.71 95.92,99.58 95.92,97.04 95.79,96.91 95.53,96.91 95.41,97.04 95.41,99.58 95.28,99.71 95.03,99.71 94.9,99.58 94.9,97.04 94.77,96.91 94.52,96.91 94.39,97.04 94.39,99.58 94.26,99.71 94.01,99.71 93.88,99.58 93.88,97.04 93.76,96.91 93.5,96.91 93.38,97.04 93.38,99.58 93.25,99.71 92.99,99.71 92.87,99.58 92.87,97.04 92.74,96.91 92.49,96.91 92.36,97.04 92.36,99.58 92.23,99.71 91.98,99.71 91.85,99.58 91.85,97.04 91.72,96.91 91.47,96.91 91.34,97.04 91.34,99.58 91.22,99.71 90.96,99.71 90.84,99.58 90.84,97.04 90.71,96.91 90.45,96.91 90.33,97.04 90.33,99.58 90.2,99.71 89.95,99.71 89.82,99.58 89.82,97.04 89.69,96.91 89.44,96.91 89.31,97.04 89.31,99.58 89.18,99.71 88.93,99.71 88.8,99.58 88.8,97.04 88.68,96.91 88.42,96.91 88.3,97.04 88.3,99.58 88.17,99.71 87.91,99.71 87.79,99.58 87.79,97.04 87.66,96.91 87.41,96.91 87.28,97.04 87.28,99.58 87.15,99.71 86.9,99.71 86.77,99.58 86.77,97.04 86.64,96.91 86.39,96.91 86.26,97.04 86.26,99.58 86.14,99.71 85.88,99.71 85.76,99.58 85.76,97.04 85.63,96.91 85.37,96.91 85.25,97.04 85.25,99.58 85.12,99.71 84.87,99.71 84.74,99.58 84.74,97.04 84.61,96.91 84.36,96.91 84.23,97.04 84.23,99.58 84.1,99.71 83.34,99.71 82.93,99.3 82.93,96.05 v2(82.9,96.03)
  IN4 w0.109: v2(103.53,103.7) 103.61,103.7 103.99,104.08 105.05,104.08 107.43,106.46 107.43,111.81 108.03,112.41 108.03,114.07 110.85,116.9 110.85,122.48 v2(111.43,123.05)
PLTRST_LAN#: length 225
  TOP w0.102: RH111.1 58.46,80.49 57.97,80.98 57.97,88.33 65.23,95.59 69.84,95.59 69.94,95.49 69.94,91.05 70.07,90.92 70.33,90.92 70.45,91.05 70.45,95.49 70.55,95.59 70.86,95.59 70.96,95.49 70.96,91.94 71.09,91.81 71.34,91.81 71.47,91.94 71.47,95.49 71.57,95.59 71.87,95.59 71.98,95.49 71.98,92.01 72.1,91.89 72.36,91.89 72.48,92.01 72.48,95.49 72.59,95.59 72.89,95.59 72.99,95.49 72.99,92.01 73.12,91.89 73.37,91.89 73.5,92.01 73.5,95.49 73.6,95.59 73.91,95.59 74.01,95.49 74.01,92.7 74.14,92.57 74.39,92.57 74.52,92.7 74.52,95.49 74.62,95.59 74.92,95.59 75.02,95.49 75.02,92.77 75.13,92.67 75.43,92.67 75.53,92.77 75.53,95.49 75.63,95.59 75.94,95.59 76.04,95.49 76.04,92.88 76.17,92.75 76.42,92.75 76.55,92.88 76.55,95.49 76.65,95.59 76.95,95.59 77.06,95.49 77.06,92.9 77.18,92.77 77.44,92.77 77.56,92.9 77.56,95.49 77.67,95.59 77.95,95.59 80.86,92.69 84.54,92.69 87.93,89.29 93.41,89.29 93.51,89.4 93.51,91.5 93.61,91.61 93.92,91.61 94.02,91.5 94.02,89.4 94.12,89.29 94.42,89.29 94.53,89.4 v1(94.53,90.87) 94.53,91.5 94.63,91.61 94.93,91.61 95.03,91.5 95.03,89.4 95.13,89.29 95.44,89.29 95.54,89.4 95.54,91.5 95.64,91.61 95.95,91.61 96.05,91.5 96.05,89.4 96.15,89.29 96.46,89.29 96.56,89.4 96.56,91.5 96.66,91.61 96.96,91.61 97.07,91.5 97.07,89.4 97.17,89.29 98.64,89.29 103.44,84.49 103.6,84.49 103.71,84.6 103.71,85.56 103.6,85.66 102.87,85.66 102.74,85.79 102.74,86.04 102.87,86.17 103.58,86.17 103.71,86.3 103.71,86.56 103.6,86.66 102.34,86.66 102.21,86.79 102.21,87.05 102.34,87.17 103.6,87.17 103.71,87.27 103.71,87.58 103.6,87.68 101.01,87.68 100.89,87.81 100.89,88.06 101.01,88.19 103.6,88.19 103.71,88.29 103.71,88.59 103.6,88.7 99.92,88.7 99.8,88.82 99.8,89.08 99.92,89.2 103.6,89.2 103.71,89.31 103.71,89.61 103.6,89.71 99.01,89.71 98.88,89.84 98.88,90.09 99.01,90.22 103.6,90.22 103.71,90.32 103.71,90.63 103.6,90.73 98.02,90.73 97.89,90.86 97.89,91.11 98.02,91.24 98.31,91.24 98.41,91.34 98.41,91.61 98.51,91.71 98.82,91.71 98.92,91.61 98.92,91.34 99.02,91.24 99.32,91.24 99.43,91.34 99.43,91.61 99.53,91.71 99.83,91.71 99.93,91.61 99.93,91.34 100.04,91.24 100.34,91.24 100.44,91.34 100.44,91.61 100.54,91.71 100.85,91.71 100.95,91.61 100.95,91.34 101.05,91.24 101.36,91.24 101.46,91.34 101.46,91.61 101.56,91.71 101.86,91.71 101.97,91.61 101.97,91.34 102.07,91.24 102.37,91.24 102.47,91.34 102.47,91.61 102.58,91.71 102.88,91.71 102.98,91.61 102.98,91.34 103.08,91.24 103.6,91.24 103.71,91.34 103.71,91.58 103.83,91.71 104.09,91.71 104.32,91.48 104.52,91.48 104.62,91.38 104.62,91.07 104.52,90.97 104.32,90.97 104.21,90.87 104.21,90.56 104.32,90.46 104.52,90.46 104.62,90.36 104.62,90.06 104.52,89.95 104.32,89.95 104.21,89.85 104.21,89.55 104.32,89.45 104.52,89.45 104.62,89.35 104.62,89.04 104.52,88.94 104.32,88.94 104.21,88.84 104.21,84.6 104.32,84.49 104.62,84.49 104.72,84.6 104.72,88.1 104.85,88.23 105.1,88.23 105.23,88.1 105.23,88.05 105.36,87.92 105.82,87.92 105.94,87.8 105.94,87.57 105.82,87.44 105.36,87.44 105.23,87.31 105.23,86.78 105.33,86.68 105.48,86.68 105.59,86.58 105.59,86.28 105.48,86.17 105.33,86.17 105.23,86.07 105.23,84.6 105.33,84.49 105.64,84.49 105.74,84.6 105.74,85.1 105.86,85.23 106.12,85.23 106.25,85.1 106.25,84.6 106.35,84.49 107.69,84.49 108.36,85.15 108.63,85.15 108.91,85.43 108.91,86.81 108.81,86.91 107.52,86.91 107.42,86.81 107.42,86.55 107.52,86.45 107.77,86.45 107.87,86.35 107.87,86.04 107.77,85.94 107.52,85.94 107.42,85.84 107.42,85.08 107.31,84.98 107.01,84.98 106.91,85.08 106.91,86.81 106.81,86.91 106.5,86.91 106.37,87.03 106.37,87.37 106.5,87.49 108.94,87.49 109.04,87.6 109.04,87.9 108.94,88 106.53,88 106.4,88.13 106.4,88.38 106.53,88.51 108.94,88.51 109.04,88.61 109.04,88.92 108.94,89.02 108.19,89.02 108.09,89.12 108.09,89.38 108.39,89.69 U31.36
PLTRST_MMI#: length 222.8
  TOP w0.102: v2(55.12,80.3) 55.64,80.3 RH110.1 ; JIO1.10 22.63,100.5 26.74,96.38 26.74,93.46 27.43,92.77 28.98,92.77 31.22,90.54 v1(37.81,90.54) 41.98,90.54 v2(42.54,89.98)
  IN3 w0.127: v2(55.12,80.3) 55.04,80.23 54.63,80.23 53.93,80.92 53.84,80.92 53.42,80.5 53.42,80.4 53.65,80.17 53.65,80.03 53.48,79.86 53.34,79.86 53.14,80.05 52.96,80.05 52.69,79.78 52.69,79.07 52.22,78.6 52,78.6 51.57,79.03 50.52,79.03 50.42,78.93 50.42,78.36 50.32,78.26 49.74,78.26 49.53,78.47 49.53,78.65 49.91,79.03 49.91,79.16 50.32,79.57 50.32,80.04 50.32,81.5 50.19,81.62 48.96,81.62 48.65,81.93 48.44,81.93 48.3,81.79 48.3,81.24 48.42,81.12 49.68,81.12 49.81,80.99 49.81,80.73 49.68,80.61 48.58,80.61 48.45,80.48 48.45,80.32 48.67,80.1 49.68,80.1 49.81,79.97 49.81,79.79 49.4,79.39 49.4,79.26 49.27,79.13 48.87,79.13 47.08,80.93 47.08,81.11 47.37,81.4 47.37,81.58 47.19,81.76 47.01,81.76 46.72,81.47 46.54,81.47 46.36,81.65 46.36,81.83 46.91,82.38 46.91,82.56 46.73,82.74 46.55,82.74 46,82.19 45.82,82.19 43.66,84.34 43.66,85.99 43.79,86.12 43.95,86.12 44.17,85.9 44.17,85.71 44.3,85.59 44.48,85.59 44.59,85.48 44.59,85.17 44.17,84.75 44.17,84.57 44.65,84.09 44.86,84.09 44.98,84.21 44.98,84.57 45.11,84.7 45.36,84.7 45.49,84.57 45.49,83.93 45.62,83.81 45.88,83.81 46.01,83.93 46.01,84.83 46.1,84.92 46.1,85.66 46.23,85.79 48.08,85.79 48.23,85.64 48.23,83.91 48.39,83.76 50.39,83.76 50.52,83.88 50.52,84.74 50.65,84.86 50.79,84.86 50.93,85 50.93,85.24 50.8,85.37 50.65,85.37 50.52,85.5 50.52,86.15 50.65,86.28 51.99,86.28 52.12,86.15 52.12,85.81 52.24,85.69 52.5,85.69 52.62,85.81 52.62,86.15 52.75,86.28 53.01,86.28 53.13,86.15 53.13,85.3 53.01,85.18 52.58,85.18 52.45,85.05 52.45,84.79 52.58,84.67 53.21,84.67 53.4,84.47 53.72,84.47 53.85,84.6 53.85,84.64 53.97,84.77 54.15,84.77 54.28,84.9 54.28,85.15 54.15,85.28 53.77,85.28 53.64,85.4 53.64,86.15 53.77,86.28 54.05,86.28 54.18,86.4 54.18,86.66 54.05,86.78 50.65,86.78 50.52,86.91 50.52,87.17 50.65,87.29 54.02,87.29 54.15,87.42 54.15,87.67 54.02,87.8 53.47,87.8 53.35,87.93 53.35,88.46 53.22,88.58 52.97,88.58 52.84,88.46 52.84,87.93 52.71,87.8 52.46,87.8 52.33,87.93 52.33,89.4 52.2,89.52 51.95,89.52 51.82,89.4 51.82,87.93 51.7,87.8 50.65,87.8 50.52,87.93 50.52,88.18 50.65,88.31 50.98,88.31 51.1,88.44 51.1,88.69 50.98,88.82 50.65,88.82 50.52,88.94 50.52,89.72 50.65,89.84 51.51,89.84 51.64,89.97 51.64,90.22 51.51,90.35 50.65,90.35 50.52,90.48 50.52,91.3 50.39,91.43 50.12,91.43 49.99,91.3 49.99,84.39 49.87,84.27 48.87,84.27 48.74,84.39 48.74,84.65 48.87,84.77 49.36,84.77 49.49,84.9 49.49,85.15 49.36,85.28 48.87,85.28 48.74,85.41 48.74,85.66 48.87,85.79 49.33,85.79 49.49,85.95 49.49,91.25 49.36,91.38 49.11,91.38 48.98,91.25 48.98,86.45 48.85,86.32 48.6,86.32 48.47,86.45 48.47,91.63 48.34,91.76 48.09,91.76 47.96,91.63 47.96,91.38 47.84,91.26 47.32,91.26 47.19,91.13 47.19,90.87 47.32,90.75 47.84,90.75 47.96,90.62 47.96,86.45 47.84,86.32 47.58,86.32 47.45,86.45 47.45,88.94 47.33,89.07 47.07,89.07 46.95,88.94 46.95,86.45 46.82,86.32 46.57,86.32 46.44,86.45 46.44,88.94 46.31,89.07 46.06,89.07 45.93,88.94 45.93,86.53 45.8,86.4 45.55,86.4 45.42,86.53 45.42,86.97 45.3,87.09 44.86,87.09 44.73,87.22 44.73,87.48 44.86,87.6 45.3,87.6 45.42,87.73 45.42,87.98 45.3,88.11 43.84,88.11 43.71,88.24 43.71,88.49 43.84,88.62 45.3,88.62 45.42,88.75 45.42,89.01 45.3,89.14 43.25,89.14 43.13,89.27 43.13,90.36 43.25,90.49 43.51,90.49 43.64,90.36 43.64,89.78 43.76,89.65 44.02,89.65 44.14,89.78 44.14,90.34 44.27,90.46 44.45,90.46 44.65,90.26 44.65,89.78 44.78,89.65 45.01,89.65 45.36,90.01 45.61,90.01 45.73,90.13 45.73,90.39 45.61,90.51 45.13,90.51 44.83,90.82 44.83,91.3 44.7,91.43 43.84,91.43 43.71,91.55 43.71,91.81 43.84,91.94 44.93,91.94 45.44,91.43 45.67,91.43 45.82,91.58 45.82,92.37 45.69,92.49 43.56,92.49 43.43,92.62 43.43,92.89 43.56,93.02 44.8,93.02 44.93,93.15 44.93,93.33 44.73,93.53 43.56,93.53 43.43,93.65 43.43,94.82 43.27,94.98 43.05,94.98 42.92,94.86 42.92,92.98 42.8,92.85 42.62,92.85 42.42,93.05 42.42,95.8 42.29,95.92 42.02,95.92 41.89,95.8 41.89,93.16 41.77,93.03 41.51,93.03 41.39,93.16 41.39,95.31 41.26,95.44 41.01,95.44 40.88,95.31 40.88,93.16 40.75,93.03 40.5,93.03 40.37,93.16 40.37,95.74 40.5,95.87 40.66,95.87 40.79,96 40.79,96.25 40.66,96.38 40.5,96.38 40.37,96.51 40.37,96.76 40.5,96.89 40.97,96.89 41.1,97.01 41.1,97.16 40.86,97.4 40.5,97.4 40.37,97.52 40.37,97.78 40.24,97.9 39.97,97.9 39.84,97.78 39.84,92.6 39.97,92.47 42.11,92.47 42.24,92.34 42.24,91.76 42.16,91.68 42.16,90.36 v2(42.54,89.98)
PLTRST_USH#: length 257.8
  TOP w0.102: JUSH1.15 114.33,29.82 113.79,29.27 C56.1 113.31,28.68 112.75,28.12 112.16,28.12 111.73,28.55 111.73,29.74 110.09,31.38 v1(110.09,33.91) 110.09,34.93 111.37,36.2 111.37,48.72 v2(110.46,49.62) ; v2(54.3,78.27) 54.66,78.63 54.66,80.43 55.07,80.84 55.07,80.91 55.42,81.27 56.03,81.27 56.28,81.02 56.28,80.55 RH109.1
  IN3 w0.127: v2(110.46,49.62) 116.28,49.62 116.38,49.52 116.38,49.06 116.28,48.96 114.8,48.96 114.67,48.83 114.67,48.5 114.8,48.37 115.6,48.37 115.73,48.25 115.73,47.88 115.6,47.75 114.8,47.75 114.67,47.63 114.67,46.3 114.83,46.14 116.81,46.14 116.94,46.27 116.94,48.37 117.07,48.5 117.41,48.5 117.54,48.37 117.54,46.27 117.66,46.14 118.04,46.14 118.17,46.27 118.17,47.16 118.3,47.29 118.63,47.29 118.76,47.16 118.76,46.27 118.88,46.14 119.25,46.14 119.38,46.27 119.38,47.05 119.51,47.18 119.87,47.18 120,47.05 120,46.27 120.13,46.14 120.5,46.14 120.62,46.27 120.62,47.05 120.75,47.18 121.14,47.18 121.27,47.05 121.27,45.71 121.14,45.58 114.27,45.58 114.16,45.68 114.16,48.83 114.04,48.96 113.78,48.96 113.66,48.83 113.66,45.64 113.53,45.52 113.27,45.52 113.15,45.64 113.15,48.83 113.02,48.96 112.77,48.96 112.64,48.83 112.64,46.19 112.54,46.09 112.23,46.09 112.13,46.19 112.13,48.83 112,48.96 111.75,48.96 111.62,48.83 111.62,47.12 111.5,46.99 111.24,46.99 111.12,47.12 111.12,48.83 110.99,48.96 110.59,48.96 110.46,48.83 110.46,47.16 110.34,47.03 109.27,47.03 109.14,47.16 109.14,47.61 109.27,47.74 109.73,47.74 109.85,47.87 109.85,48.21 109.73,48.34 109.27,48.34 109.14,48.46 109.14,48.88 109.27,49.01 109.75,49.01 109.88,49.14 109.88,49.49 109.75,49.62 108.63,49.62 108.51,49.49 108.51,47.16 108.38,47.03 108,47.03 107.87,47.16 107.87,49.15 107.75,49.28 107.36,49.28 107.24,49.15 107.24,47.16 107.11,47.03 106.73,47.03 106.6,47.16 106.6,49.49 106.48,49.62 106.09,49.62 105.97,49.49 105.97,47.16 105.84,47.03 105.46,47.03 105.33,47.16 105.33,49.49 105.21,49.62 104.82,49.62 104.7,49.49 104.7,47.18 104.57,47.05 104.19,47.05 104.06,47.18 104.06,49.49 103.94,49.62 103.55,49.62 103.43,49.49 103.43,47.18 103.3,47.05 102.87,47.05 102.74,47.18 102.74,48.5 102.62,48.63 102.24,48.63 102.11,48.5 102.11,47.66 101.98,47.54 101.6,47.54 101.47,47.66 101.47,48.5 101.35,48.63 100.97,48.63 100.84,48.5 100.84,48.39 100.71,48.26 100.33,48.26 100.2,48.39 100.2,49.52 100.08,49.64 99.7,49.64 99.57,49.52 99.57,48.57 99.44,48.45 99.03,48.45 98.9,48.57 98.9,49.75 98.78,49.87 98.32,49.87 98.2,49.75 98.2,49.19 97.97,48.96 97.7,48.96 97.57,49.09 97.57,49.75 97.44,49.87 97.19,49.87 97.06,49.75 97.06,49.09 96.94,48.96 96.68,48.96 96.56,49.09 96.56,49.75 96.43,49.87 96.17,49.87 96.05,49.75 96.05,49.09 95.92,48.96 95.67,48.96 95.54,49.09 95.54,49.75 95.41,49.87 95.16,49.87 95.03,49.75 95.03,49.09 94.9,48.96 94.65,48.96 94.52,49.09 94.52,49.75 94.4,49.87 94.14,49.87 94.02,49.75 94.02,49.09 93.89,48.96 93.63,48.96 93.51,49.09 93.51,49.75 93.38,49.87 93.13,49.87 93,49.75 93,49.09 92.87,48.96 92.62,48.96 92.49,49.09 92.49,49.95 92.26,50.18 79.68,50.18 79.4,49.9 78.38,49.9 78.26,50.03 78.26,50.66 78.13,50.79 77.54,50.79 76.91,51.42 74.91,51.42 74.78,51.3 74.78,51.02 74.65,50.89 74.4,50.89 74.27,51.02 74.27,51.3 74.14,51.42 73.89,51.42 73.76,51.3 73.76,51.02 73.64,50.89 73.19,50.89 73.06,51.02 73.06,51.52 72.94,51.65 72.68,51.65 72.55,51.52 72.55,51.02 72.43,50.89 71.88,50.89 71.7,51.07 71.7,51.35 72.69,52.34 72.87,52.34 73.04,52.18 73.22,52.18 73.4,52.36 73.4,52.54 73.23,52.7 73.23,52.88 73.39,53.04 73.39,53.22 73.12,53.49 72.94,53.49 72.78,53.32 72.6,53.32 72.49,53.43 72.31,53.43 72.13,53.25 72.13,53.07 72.24,52.96 72.24,52.78 72.13,52.68 71.43,52.68 71.3,52.81 71.3,53.05 71.18,53.18 70.8,53.18 70.67,53.05 70.67,52.41 70.81,52.26 71.45,52.26 71.58,52.13 71.58,51.88 71.45,51.75 70.8,51.75 70.67,51.63 70.67,51.04 70.54,50.91 70.15,50.91 70.03,51.04 70.03,52.87 69.9,53 69.62,53 69.49,52.87 69.49,52.31 69.37,52.18 69.16,52.18 69.05,52.3 68.87,52.3 68.74,52.18 68.56,52.18 68.38,52.36 68.38,52.54 68.51,52.66 68.51,52.84 68.33,53.02 68.15,53.02 68.02,52.89 67.84,52.89 67.66,53.07 67.66,53.25 67.79,53.38 67.79,53.56 67.33,54.02 67.33,54.27 65.73,55.87 65.73,56.68 65.16,57.25 65.16,58.55 64.07,59.64 62.38,59.64 61.3,58.56 56.54,58.56 56.44,58.46 54.34,58.46 53.22,59.58 52.83,59.58 50.96,61.44 50.96,69.85 51.48,70.38 51.48,71.26 50.99,71.75 50.99,71.93 51.29,72.24 51.47,72.24 52.12,71.59 52.5,71.59 53.31,72.41 53.31,74.67 54.01,75.36 54.77,75.36 54.91,75.5 54.91,75.91 55.03,76.04 56.44,76.04 56.56,76.16 56.56,76.44 56.44,76.57 53.29,76.57 53.16,76.7 53.16,77.08 53.29,77.2 56.64,77.2 57.1,76.75 57.38,76.75 57.89,77.26 57.89,78.5 57.76,78.63 57.47,78.63 57.34,78.5 57.34,77.81 57.21,77.69 56.96,77.69 56.83,77.81 56.83,78.5 56.71,78.63 56.45,78.63 56.33,78.5 56.33,78.22 56.2,78.09 55.94,78.09 55.82,78.22 55.82,78.5 55.69,78.63 55.37,78.63 54.37,77.62 54.19,77.62 54.01,77.8 54.01,77.98 v2(54.3,78.27)
PM_APWROK: length 190.4
  TOP w0.102: v2(65.61,49.19) 64.95,49.85 RH87.1 64.34,49.85 63.01,51.18 UH2.2 62.97,51.72 v1(62.62,52.06)
  IN1 w0.109: v2(65.61,49.19) 65.61,48.46 68.61,45.45 68.99,45.45 70.47,43.97 75.55,43.97 77.05,42.47 80.23,42.47 80.96,41.74 94.41,41.74 95.15,42.47 98.49,42.47 99.17,41.79 103.38,41.79 103.65,41.52 113.13,41.52 113.97,40.68 119.91,40.68 122.58,38.02 174.45,38.02 176.13,39.7 176.7,39.7 177.54,38.86 181.57,38.86 183.64,36.79 184.2,36.79 184.43,37.02 185.42,37.02 185.62,36.82 187.2,36.82 189.38,39 193.4,39 200.58,46.18 215.64,46.18 218.5,49.04 232.97,49.04 235.1,46.9 236.75,46.9 v2(236.8,46.95)
  BOTTOM w0.102: U51.A9 237.34,46.42 v2(236.8,46.95)
PM_APWROK_R: length 64.3
  TOP w0.102: UH2.4 62.47,49.28 63.04,49.85 63.83,49.85 RH87.2 64.62,48.81 64.62,46.01 64.26,45.66 64.26,44.31 65.76,42.81 73.7,42.81 74.2,43.31 81.55,43.31 82.73,44.49 v1(82.73,44.73) 82.73,45.88 v2(82.58,46.02)
  IN1 w0.109: v2(82.58,46.02) 82.3,46.02 81.43,46.9 78.2,46.9 77.07,48.03 74.89,48.03 74.44,48.47 70.91,48.47 70.62,48.77 70.62,49.35 68.09,51.88 68.09,54.59 67.37,55.31 67.37,57.3 68,57.94 68,58.52 67.44,59.09 67.44,60.87 68.07,61.51 68.07,64.48 69.51,65.91 69.51,66.19 69.72,66.4 69.93,66.4 v2(70.48,66.96)
  BOTTOM w0.102: v2(70.48,66.96) 70.48,67.31 UH1.AB7
PM_DRAM_PWRGD: length 207.7
  TOP w0.102: RC89.2 208.85,105.22 v2(208.9,105.27)
  IN3 w0.127: v2(66.6,61.48) 66.6,61.43 67.89,60.14 67.89,59.7 69.39,58.2 76.76,58.2 77.91,57.05 77.91,55.25 78.79,54.37 79.2,54.37 79.64,53.94 83.49,53.94 86.18,56.63 87.65,56.63 88.42,57.39 90.3,57.39 90.73,56.96 92.28,56.96 96.29,52.95 101.09,52.95 102.06,51.97 117.27,51.97 119.7,49.53 122.29,49.53 124.62,47.19 147.33,47.19 147.75,46.77 148.89,46.77 150.52,45.15 163.88,45.15 167.91,49.17 189.07,49.17 190.67,50.78 191.58,50.78 197.32,56.51 197.32,57.58 201.13,61.39 201.13,66.19 207.26,72.32 207.26,77.03 210.36,80.12 210.36,88.58 209.18,89.76 209.18,95.25 207.02,97.41 207.02,101.88 207.48,102.33 207.48,102.86 209.08,104.46 209.08,105.09 v2(208.9,105.27)
  BOTTOM w0.102: RH104.1 63.47,59.73 63.91,60.16 64.84,60.16 66.17,61.48 v2(66.6,61.48)
PM_DRAM_PWRGD_A: length 14.1
  TOP w0.102: RC18.2 202.08,103.02 203.49,101.61 v1(204.52,101.61) 206.2,101.61 209.3,104.72 209.3,105.44 209.07,105.68 207.62,105.68 RC89.1 UC2.2
PM_DRAM_PWRGD_CPU: length 31.1
  TOP w0.102: v2(184.06,113.31) 183.59,113.78 JCPU1.AC10 ; RC28.1 202.59,109.67 RC101.1 204.19,109.08 206.4,109.08 v2(206.48,109.16)
  IN4 w0.089: 197.84,112.87 184.53,112.87 184.09,113.31 v2(184.06,113.31)
  IN4 w0.109: 197.84,112.87 199.69,112.87 203.4,109.16 v2(206.48,109.16)
  BOTTOM w0.102: v4(206.97,108.88) 206.69,109.16 v2(206.48,109.16)
PM_DRAM_PWRGD_R: length 6.3
  BOTTOM w0.089: UH1.H3 68.31,61.66
  BOTTOM w0.102: 68.31,61.66 67.89,61.24 67.64,61.24 67.3,60.9 66.17,60.9 64.9,59.63 RH104.2 64.39,59.12 v1(64.8,58.71)
PM_LANPHY_ENABLE: length 86.5
  TOP w0.076: 71.63,59.83 71.63,60.19 71.83,60.39 71.83,61.1 v2(72.44,61.71)
  TOP w0.102: R555.1 123.09,89.73 v1(124.41,88.4) 125.07,87.74 v2(125.3,87.74) ; 71.63,59.83 71.63,59.38 71.98,59.03 71.98,55.83 72.36,55.45 72.36,52.3 71.73,51.66 RH217.1
  IN3 w0.089: v2(72.44,61.71) 72.57,61.58 73.61,61.58 73.89,61.87 73.89,62.58
  IN3 w0.127: 73.89,62.58 73.89,62.97 74.5,63.58 74.5,66.05 75.21,66.76 75.88,66.76 76.36,66.28 81.35,66.28 81.58,66.51 85.56,66.51 86.66,67.61 86.84,67.61 88.21,68.97 91.28,68.97 92.83,70.52 97.34,70.52 100.79,73.98 101.73,73.98 107.03,79.29 113.49,79.29 118.29,84.09 123.8,84.09 125.73,86.02 125.73,87.31 v2(125.3,87.74)
  BOTTOM w0.102: UH1.K13 72.9,62.17 v2(72.44,61.71)
POWER_SW#: length 18.4
  IN1 w0.254: v2(32.24,101.57) 42.04,101.57 v2(42.47,101.99)
  BOTTOM w0.254: U29.20 v1(34.65,96.76) 34.65,99.81 32.89,101.57 v2(32.24,101.57) ; v2(42.47,101.99) 42.48,101.98 U10.4
POWER_SW#_MB: length 514.4
  TOP w0.102: v2(279.88,94.29) 279.88,95 279.82,95.06 278.87,95.06 278.28,94.48 C759.1 278.28,92.8 PWRSW1.1 277.52,92.77 276.49,91.74 JPB1.1 ; SW1.4 SW1.2 v2(302.24,155.76)
  IN1 w0.109: v3(226.68,36.72) 226.01,37.39 221.02,37.39 219.15,39.26 205.89,39.26 204.48,37.85 199.69,37.85 192.41,30.57 178.58,30.57 176.92,28.91 156.94,28.91 154.34,31.51 116.94,31.51 116.63,31.82 110.75,31.82 108.88,33.7 93.64,33.7 92.58,32.64 67.43,32.64 64.95,35.13 63.98,35.13 50.88,48.23 50.88,63.04 50.47,63.45 50.47,64.92 48.12,67.27 48.12,68.08 44.05,72.14 41.91,72.14 39.74,74.31 39.74,74.47 37.95,76.26 37.95,77.25 33.19,82.01 31.91,82.01 26.07,87.85 v2(25.98,87.85)
  IN2 w0.127: v2(302.24,155.76) 302.18,155.76 300.58,154.17 293.37,154.17 291.01,151.8 291.01,128.46 288.16,125.62 288.16,113.35 286.56,111.75 286.56,97.47 284.3,95.21 280.53,95.21 279.88,94.56 v2(279.88,94.29)
  IN3 w0.127: v2(279.88,94.29) 279.88,94.37 279.47,94.78 275.12,90.42 275.12,79.25 275.82,78.55 275.82,77.66 275.59,77.43 275.59,71.3 276.4,70.49 276.4,67.95 277.65,66.71 277.65,41.85 276.58,40.79 276.58,33.72 275.59,32.73 275.59,30.23 272.5,27.14 271.12,27.14 270.48,27.78 257.41,27.78 254.22,30.96 248.64,30.96 246.23,33.38 236.92,33.38 234.94,35.36 234.94,35.93 233.58,37.29 228.61,37.29 227.84,36.51 226.88,36.51 v3(226.68,36.72)
  BOTTOM w0.102: JAPS1.11 14.75,125.44 15.27,124.93 17.21,124.93 17.68,125.4 19.04,125.4 24.61,119.83 24.61,107.91 22.78,106.08 22.78,97.74 23.32,97.2 23.32,90.79 25.98,88.13 v2(25.98,87.85) ; R811.2 235.3,34.91 C1354.1 231.59,34.91 230.36,36.14 227.25,36.14 v3(226.68,36.72) ; v2(302.24,155.76) v4(302.24,156.36)
POWER_SW_IN#: length 289.9
  TOP w0.102: v2(239.12,42.22) 238.67,41.77 235.66,41.77 234.36,40.48 233.4,40.48 231.8,38.88 230.4,38.88 v2(229.72,39.56)
  IN1 w0.109: v2(229.72,39.56) 229.52,39.76 220.15,39.76 219.54,40.37 205.37,40.37 203.95,38.94 199.17,38.94 191.88,31.65 178.16,31.65 176.48,29.97 157.38,29.97 154.78,32.57 117.38,32.57 117.07,32.88 111.31,32.88 109.44,34.75 84.27,34.75 83.39,33.87 67.69,33.87 65.38,36.18 64.42,36.18 53.69,46.91 53.69,65.29 53.88,65.48 53.88,71.68 52.65,72.91 51.99,72.91 50.22,74.68 50.22,76.23 50.67,76.67 55.62,76.67 56.89,77.94 56.89,78.91 58.42,80.43 v2(58.42,82.97)
  BOTTOM w0.102: v2(239.12,42.22) 239.12,42.22 239.55,41.79 U51.B67 ; v2(58.42,82.97) 59.59,84.14 59.59,87.14 47.5,99.23 v1(43.9,99.23) 41.96,99.23 41.1,100.09 41.1,102.15 42.39,103.44 U10.2 ; C1352.1 R810.2 R811.1 235.63,35.5 234.49,35.5 234.11,35.12 231.67,35.12 229.72,37.07 v2(229.72,39.56)
PROCHOT#_EC: length 55.5
  BOTTOM w0.102: R1180.1 253.59,43.27 254.99,41.87 254.99,41.55 Q47.2 256.08,41.28 256.18,41.38 256.18,41.52 256.08,41.62 255.8,41.62 255.7,41.73 255.7,41.93 255.8,42.03 256.08,42.03 256.18,42.13 256.18,42.33 256.08,42.44 255.17,42.44 255.07,42.54 255.07,42.74 255.17,42.84 256.08,42.84 256.18,42.94 256.18,44.04 256.61,44.46 257.05,44.46 257.12,44.54 257.12,45.44 257.02,45.54 256.39,45.54 256.28,45.64 256.28,45.85 256.39,45.95 257.02,45.95 257.12,46.05 257.12,46.33 257.5,46.71 257.5,47.99 257.71,48.2 v1(258.11,48.2) 259.82,48.2 259.92,48.1 259.92,45.91 259.82,45.81 259.61,45.81 259.51,45.91 259.51,47.69 259.41,47.79 259.21,47.79 259.1,47.69 259.1,46.85 259,46.75 258.8,46.75 258.7,46.85 258.7,47.69 258.6,47.79 258.39,47.79 258.29,47.69 258.29,46.9 257.53,46.14 257.53,44.34 257.4,44.21 257.4,43.85 257.49,43.76 257.76,43.76 257.86,43.66 257.86,43.46 257.76,43.36 257.1,43.36 257,43.46 257,43.88 256.89,43.98 256.72,43.98 256.59,43.85 256.59,43.05 256.69,42.95 257,42.95 257.1,42.85 257.1,42.65 257,42.55 256.69,42.55 256.59,42.44 256.59,42.24 256.69,42.14 257,42.14 257.1,42.04 257.1,41.83 257,41.73 256.69,41.73 256.59,41.63 256.59,41.19 255.83,40.42 254.68,40.42 254.49,40.62 254.49,41.66 252.86,43.29 252.37,43.29 252.15,43.52 251.64,43.52 251.31,43.19 250.9,43.19 250.8,43.29 250.8,43.65 250.9,43.75 251,43.75 251.1,43.85 R1179.2 251.41,44.13 251.51,44.23 251.51,44.92 251.41,45.02 R812.2 250.44,44.36 249.93,44.36 249.83,44.26 249.83,44.06 249.93,43.96 250.45,43.96 250.55,43.85 250.55,43.04 250.45,42.94 250.34,42.94 250.06,43.22 250.06,43.47 249.99,43.55 249.76,43.55 249.66,43.45 249.66,43.09 249.99,42.76 249.99,42.61 249.83,42.45 249.69,42.45 249.25,42.89 249.25,43.36 249.1,43.51 248.93,43.51 248.84,43.42 U51.A46
PROCHOT_GATE: length 85.7
  TOP w0.102: v2(221.9,44.31) 221.9,43.71 235.46,30.15 v2(235.46,28.46)
  BOTTOM w0.102: PU704.2 246.63,24.84 244.97,26.51 237.41,26.51 v2(235.46,28.46) ; U46.A50 234.98,75.93 234.68,76.22 233.51,76.22 232.98,75.69 231.68,75.69 231.24,75.24 RP1.6 230.69,75.24 230.4,75.53 230.4,76.47 230.1,76.77 228.79,76.77 224.86,72.84 224.86,70.95 223.06,69.15 223.06,67.89 218.69,63.52 v1(218.69,62.21) 218.69,56.44 217.45,55.2 217.45,48.77 v2(221.9,44.31)
