# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_DPC_HPD: length 104.1
  TOP w0.102: v2(117.02,128.38) 117.7,129.07 117.7,130.04 118.31,130.65 118.31,131.64 D7.2 117.7,132.31 U25.2 ; v2(39.27,123.1) v1(39.91,123.1)
  IN1 w0.109: v2(39.27,123.1) 39.27,122.81 40.03,122.05 40.03,114.06 42.75,111.34 59.92,111.34 65.99,117.41 79.2,117.41 83.44,121.65 85.44,121.65 86.89,123.1 86.89,124.83 89.79,127.72 107.72,127.72 107.97,127.47 109.52,127.47 110.71,128.66 113.05,128.66 114.27,127.45 116.08,127.45 v2(117.02,128.38)
  BOTTOM w0.102: v2(39.27,123.1) 39.25,123.08 U629.3
MXM_DPC_HPD_GATE: length 28.8
  TOP w0.102: v2(109.7,143.55) 116.84,143.55 117.78,142.61 117.78,137.2 R519.2 118.35,136.62 U25.4 ; JMXM1.262 99.44,144.13 99.57,144 v2(99.57,143.78)
  IN4 w0.109: v2(99.57,143.78) 100.41,144.62 108.51,144.62 109.58,143.55 v2(109.7,143.55)
  BOTTOM w0.102: v2(109.7,143.55) v1(109.7,142.99)
MXM_DPC_N0: length 57.6
  TOP w0.102: v2(42.7,125.72) 42.89,125.91 42.89,126.21 43.25,126.58 43.69,126.58 45.15,128.04 45.15,131.62 47.76,134.24 89.51,134.24 90.83,135.56 90.83,135.79 90.69,135.93 JMXM1.229
  BOTTOM w0.102: C525.1 42.09,126.25 42.19,126.35 42.7,126.35 42.94,126.11 42.94,125.96 42.87,125.9 42.87,125.82 42.77,125.72 v2(42.7,125.72)
MXM_DPC_N0_C: length 4.9
  BOTTOM w0.102: C525.2 40.84,126.25 40.45,126.25 v3(39.74,125.55) 39.55,125.35 39.55,123.84 39.28,123.57 39.01,123.57 38.91,123.48 U629.2
MXM_DPC_N1: length 60.4
  TOP w0.102: v2(42.7,123.81) 42.89,124 42.89,124.35 43.29,124.75 43.58,124.75 45.86,127.03 45.86,131.34 48.05,133.54 90.42,133.54 92.33,135.45 92.33,135.81 92.19,135.96 JMXM1.235
  BOTTOM w0.102: v2(42.7,123.81) 42.77,123.81 42.87,123.91 42.87,123.99 42.94,124.05 42.94,124.21 42.7,124.45 42.19,124.45 42.09,124.35 C527.1
MXM_DPC_N1_C: length 4.4
  BOTTOM w0.102: C527.2 40.82,124.36 40.51,124.36 40.27,124.12 v3(40.27,123.7) 40.27,123.1 39.53,122.36 39.03,122.36 38.94,122.28 U629.5
MXM_DPC_N2: length 63.2
  TOP w0.102: JMXM1.241 93.69,135.93 93.83,135.79 93.83,135.33 91.34,132.83 48.33,132.83 46.57,131.07 46.57,126.72 44.46,124.61 44.46,123.75 43.7,122.99 43.47,122.99 42.89,122.4 42.89,122.1 v2(42.7,121.91)
  BOTTOM w0.102: C529.1 42.09,122.44 42.19,122.54 42.7,122.54 42.94,122.3 42.94,122.15 42.87,122.09 42.87,122.01 42.77,121.91 v2(42.7,121.91)
MXM_DPC_N2_C: length 3.3
  BOTTOM w0.102: C529.2 40.83,122.45 40.64,122.45 40.38,122.19 40.38,122.17 39.99,121.79 39.97,121.79 39.75,121.57 39.01,121.57 38.91,121.48 U629.7
MXM_DPC_N3: length 66.1
  TOP w0.102: JMXM1.247 95.19,135.93 95.33,135.79 95.33,135.2 94.07,133.93 92.25,132.12 48.61,132.12 47.28,130.79 47.28,126.39 45.2,124.31 45.2,122.63 44.81,122.25 43.65,121.08 43.42,121.08 42.89,120.55 42.89,120.19 v2(42.7,120)
  BOTTOM w0.102: C528.1 42.09,120.54 42.19,120.64 42.7,120.64 42.94,120.4 42.94,120.24 42.87,120.18 42.87,120.1 42.77,120 v2(42.7,120)
MXM_DPC_N3_C: length 3
  BOTTOM w0.102: C528.2 40.83,120.54 40.37,120.54 40.36,120.53 39.83,120.53 39.81,120.54 39.76,120.54 39.58,120.37 38.98,120.37 38.89,120.28 U629.10
MXM_DPC_P0: length 57.5
  TOP w0.102: JMXM1.231 91.19,135.93 91.05,135.79 91.05,135.47 89.6,134.02 47.85,134.02 45.36,131.53 45.36,127.95 43.78,126.37 43.34,126.37 43.1,126.12 43.1,125.9 v2(43.28,125.72)
  BOTTOM w0.102: v2(43.28,125.72) 43.15,125.84 43.15,126.2 42.79,126.57 42.33,126.57 C523.1
MXM_DPC_P0_C: length 5
  BOTTOM w0.102: C523.2 40.83,126.47 40.36,126.47 39.79,125.9 39.77,125.9 39.33,125.46 39.33,123.93 39.19,123.79 39.01,123.79 38.91,123.88 U629.1
MXM_DPC_P1: length 60.3
  TOP w0.102: v2(43.28,123.81) 43.1,123.99 43.1,124.26 43.38,124.54 43.67,124.54 46.07,126.94 46.07,131.26 48.14,133.33 90.51,133.33 92.55,135.36 92.55,135.81 92.69,135.96 JMXM1.237
  BOTTOM w0.102: v2(43.28,123.81) 43.15,123.94 43.15,124.3 42.79,124.66 42.33,124.66 C524.1
MXM_DPC_P1_C: length 4.4
  BOTTOM w0.102: C524.2 40.85,124.58 40.43,124.58 40.05,124.21 40.05,123.99 40.04,123.98 40.04,123.37 40.05,123.36 40.05,123.19 39.44,122.58 39,122.58 38.9,122.68 U629.4
MXM_DPC_P2: length 63.2
  TOP w0.102: v2(43.28,121.91) 43.1,122.09 43.1,122.31 43.56,122.77 43.79,122.77 44.68,123.66 44.68,124.52 46.79,126.63 46.79,130.98 48.42,132.61 91.43,132.61 94.05,135.24 94.05,135.79 94.19,135.93 JMXM1.243
  BOTTOM w0.102: v2(43.28,121.91) 43.15,122.03 43.15,122.39 42.79,122.76 42.33,122.76 C526.1
MXM_DPC_P2_C: length 3.3
  BOTTOM w0.102: C526.2 40.84,122.67 40.55,122.67 v3(40.03,122.15) 39.83,121.95 39.66,121.79 38.98,121.79 38.89,121.88 U629.6
MXM_DPC_P3: length 66.1
  TOP w0.102: JMXM1.249 95.69,135.93 95.55,135.79 95.55,135.11 92.34,131.9 48.7,131.9 47.5,130.7 47.5,126.3 45.41,124.22 45.41,122.54 44.97,122.1 43.74,120.87 43.51,120.87 43.1,120.46 43.1,120.18 v2(43.28,120)
  BOTTOM w0.102: v2(43.28,120) 43.15,120.13 43.15,120.49 42.79,120.85 42.33,120.85 C530.1
MXM_DPC_P3_C: length 3
  BOTTOM w0.102: C530.2 40.84,120.76 v3(40.09,120.76) 39.67,120.76 39.49,120.58 39.01,120.58 38.92,120.68 U629.9
MXM_EDP_AUX+: length 17.2
  TOP w0.102: C371.1 109.99,150.34 109.99,149.71 v2(110.16,149.54) ; v2(98.98,143.78) 98.8,143.96 98.8,144.07 98.94,144.21 JMXM1.260
  IN4 w0.117: v2(98.98,143.78) 98.81,143.95 98.81,144.32 100.5,146 107.29,146 109.96,148.67 109.96,149.35 v2(110.16,149.54)
MXM_EDP_AUX+_C: length 6.9
  TOP w0.102: R336.2 C371.2 110.02,151.97 110.02,152.18 110.4,152.57 v3(110.65,152.57) 111.03,152.57 111.85,153.38 111.85,153.89 111.86,153.9 111.86,154.43 111.85,154.44 111.85,154.69 111.99,154.83 JEDP1.38
MXM_EDP_AUX-: length 17.1
  TOP w0.102: C373.1 109.78,150.41 109.78,149.75 v2(109.57,149.54) ; v2(98.4,143.78) 98.58,143.96 98.58,144.08 98.44,144.22 JMXM1.258
  IN4 w0.117: v2(109.57,149.54) 109.73,149.39 109.73,148.77 107.2,146.24 100.4,146.24 98.57,144.42 98.57,143.95 v2(98.4,143.78)
MXM_EDP_AUX-_C: length 6.9
  TOP w0.102: R339.2 C373.2 109.8,151.96 109.8,152.27 110.32,152.79 110.96,152.79 111.63,153.47 v3(111.63,154.17) 111.63,154.69 111.49,154.83 JEDP1.39
MXM_EDP_HPD: length 30
  TOP w0.102: JEDP1.22 119.99,154.61 119,153.62 119,152.82 120.12,151.7 R222.2 120.06,151.65 119.43,151.02 119.43,150.23 119.05,149.85 119.05,148.83 v1(117.9,147.68) 116.8,146.58 113.42,146.58 113.15,146.32 100.61,146.32 99.94,145.65 JMXM1.264
MXM_EDP_TX0+: length 23.7
  TOP w0.102: JMXM1.236 92.94,145.58 92.8,145.72 92.8,145.8 92.86,145.86 93.42,145.86 95.53,147.97 98.53,147.97 99.48,148.92 v3(100.46,148.92) 107.01,148.92 107.02,148.91 107.58,148.91 107.59,148.92 111.31,148.92 111.86,149.47 112.48,149.47 112.83,149.81 112.83,150.38 C379.1
MXM_EDP_TX0+_C: length 5.1
  TOP w0.102: JEDP1.35 113.49,154.83 113.35,154.69 113.35,154.53 113.36,154.52 113.36,153.99 113.35,153.98 113.35,153.52 112.8,152.97 v3(112.8,152.69) 112.8,151.98 C379.2
MXM_EDP_TX0-: length 23.7
  TOP w0.102: JMXM1.234 92.44,145.57 92.58,145.71 92.58,145.89 92.77,146.08 93.33,146.08 95.44,148.18 98.44,148.18 99.39,149.14 100.18,149.14 100.19,149.15 100.72,149.15 100.74,149.14 v3(107.3,149.14) 111.23,149.14 111.77,149.68 112.39,149.68 112.61,149.9 112.61,150.37 C380.1
MXM_EDP_TX0-_C: length 5.1
  TOP w0.102: C380.2 112.58,151.94 112.58,152.41 112.57,152.43 112.57,152.96 112.58,152.97 112.58,153.06 113.13,153.61 v3(113.13,154.25) 113.13,154.69 112.99,154.83 JEDP1.36
MXM_EDP_TX1+: length 24
  TOP w0.102: C377.1 114.7,150.36 114.7,149.85 113.5,148.64 112.13,148.64 111.7,148.21 102.79,148.21 102.78,148.2 102.22,148.2 102.21,148.21 99.76,148.21 98.81,147.26 v3(97.98,147.26) 95.81,147.26 94.31,145.76 94.31,145.71 94.44,145.58 JMXM1.242
MXM_EDP_TX1+_C: length 4.9
  TOP w0.102: JEDP1.32 114.99,154.83 114.85,154.69 114.85,154.55 114.86,154.53 114.86,154 114.85,153.99 114.85,153.24 114.7,153.1 v3(114.7,152.65) 114.7,151.98 C377.2
MXM_EDP_TX1-: length 24
  TOP w0.102: C378.1 114.49,150.39 114.49,149.94 113.41,148.86 112.04,148.86 111.61,148.43 v3(102.5,148.43) 99.67,148.43 98.72,147.47 98.26,147.47 98.25,147.49 97.71,147.49 97.7,147.47 95.72,147.47 94.09,145.85 94.09,145.72 93.94,145.57 JMXM1.240
MXM_EDP_TX1-_C: length 4.9
  TOP w0.102: JEDP1.33 114.49,154.83 114.63,154.69 v3(114.63,154.27) 114.63,153.33 114.49,153.19 114.49,152.93 114.48,152.92 114.48,152.39 114.49,152.38 114.49,151.94 C378.2
MXM_EDP_TX2+: length 24.7
  TOP w0.102: C375.1 116.61,150.36 116.61,149.49 116.3,149.19 116.3,149.17 115.93,148.79 115.91,148.79 115.2,148.08 114.92,147.8 112.61,147.8 112.31,147.5 v3(105.29,147.5) 100.04,147.5 99.1,146.56 96.48,146.56 95.8,145.88 95.8,145.79 95.94,145.65 JMXM1.248
MXM_EDP_TX2+_C: length 5
  TOP w0.102: C375.2 116.6,151.99 v3(116.6,152.59) 116.6,153.02 116.35,153.27 116.35,153.93 116.36,153.94 116.36,154.47 116.35,154.48 116.35,154.69 116.49,154.83 JEDP1.29
MXM_EDP_TX2-: length 24.7
  TOP w0.102: C376.1 116.39,150.39 116.39,149.58 v3(115.96,149.14) 115.46,148.65 114.83,148.02 112.52,148.02 112.22,147.71 105.65,147.71 105.64,147.73 104.99,147.73 104.98,147.71 99.95,147.71 99.01,146.77 96.39,146.77 95.58,145.97 95.58,145.79 95.44,145.65 JMXM1.246
MXM_EDP_TX2-_C: length 5
  TOP w0.102: JEDP1.30 115.99,154.83 116.13,154.69 v3(116.13,154.2) 116.13,153.18 116.39,152.93 116.39,152.87 116.37,152.86 116.37,152.33 116.39,152.31 116.39,151.94 C376.2
MXM_EDP_TX3+: length 25.4
  TOP w0.102: C372.1 118.53,150.37 118.53,149.9 118.54,149.88 118.54,149.35 118.53,149.34 118.53,149 116.6,147.07 v3(116.04,147.07) 113.22,147.07 112.95,146.8 100.41,146.8 99.47,145.86 97.36,145.86 97.3,145.8 97.3,145.66 97.44,145.52 JMXM1.254
MXM_EDP_TX3+_C: length 5.1
  TOP w0.102: C372.2 118.54,151.96 118.54,152.46 v3(118.15,152.86) 117.85,153.16 117.85,153.81 117.86,153.82 117.86,154.36 117.85,154.37 117.85,154.69 117.99,154.83 JEDP1.26
MXM_EDP_TX3-: length 25.4
  TOP w0.102: C374.1 118.31,150.38 v3(118.31,149.62) 118.31,149.09 116.51,147.28 116.32,147.28 116.3,147.3 115.77,147.3 115.76,147.28 113.13,147.28 112.86,147.02 100.32,147.02 99.38,146.08 97.27,146.08 97.08,145.89 97.08,145.69 96.94,145.54 JMXM1.252
MXM_EDP_TX3-_C: length 5.1
  TOP w0.102: C374.2 118.32,151.97 118.32,152.37 118.19,152.51 118.17,152.51 117.8,152.88 117.8,152.9 117.63,153.07 v3(117.63,154.09) 117.63,154.69 117.49,154.83 JEDP1.27
MXM_ENVDD: length 68.2
  TOP w0.102: v2(43.43,143.32) 43.05,143.32 42.72,142.99 42.72,141.67 46.69,137.7 JMXM1.59 ; v2(91.31,164.2) v1(91.31,163.56)
  IN1 w0.109: v2(43.43,143.32) 43.8,143.69 43.8,144 44.69,144.89 48.14,144.89 49.58,146.33 55.09,146.33 55.85,147.1 65.02,147.1 65.7,147.78 66.31,147.78 67.53,149 69.17,149 69.73,149.57 69.73,151.11 70.44,151.82 72.91,151.82 74.73,153.63 78.24,153.63 86.71,162.1 86.78,162.1 89.28,164.61 90.91,164.61 v2(91.31,164.2)
  BOTTOM w0.102: D6.3 91.22,164.29 v2(91.31,164.2)
MXM_LVDS_A0+: length 15.7
  TOP w0.102: v2(96.24,152.77) 96.24,152.79 95.9,153.14 95.61,153.14 95.27,152.8 95.27,152.2 95.35,152.12 95.35,151.77 95.27,151.69 95.27,151.39 95.35,151.31 95.35,150.95 95.27,150.88 95.27,148.83 93.75,147.31 92.78,147.31 91.24,145.76 91.24,145.66 91.44,145.45 JMXM1.230
  BOTTOM w0.102: U11.18 94.18,153.87 94.11,153.94 94.02,153.94 93.94,154.01 93.94,154.18 94,154.24 94.44,154.24 94.7,153.98 94.7,153.82 94.92,153.61 95.07,153.61 95.54,153.14 95.92,153.14 96.24,152.82 v2(96.24,152.77)
MXM_LVDS_A0-: length 15.8
  TOP w0.102: JMXM1.228 90.94,145.84 91.15,146.05 92.67,147.57 93.64,147.57 95.01,148.94 v3(95.01,149.84) 95.01,152.91 95.5,153.4 v2(96.24,153.4)
  BOTTOM w0.102: U11.17 93.67,154.29 93.9,154.52 94.53,154.52 95.65,153.4 v2(96.24,153.4)
MXM_LVDS_A1+: length 20.2
  TOP w0.102: JMXM1.224 89.94,145.65 89.82,145.76 89.82,145.9 90.41,146.48 90.87,146.48 91.08,146.7 91.08,146.7 93.27,148.88 93.27,148.96 94.46,150.15 94.46,153.28 95.07,153.89 96.65,153.89 97.38,153.15 97.38,152.58 97.31,152.51 97.31,152.15 97.38,152.07 97.38,151.8 96.85,151.27 96.85,150.66 96.72,150.53 96.62,150.53 96.44,150.71 v2(96.44,150.84)
  BOTTOM w0.102: v2(96.44,150.84) 96.77,150.84 96.84,150.9 96.84,151.21 96.75,151.3 96.29,151.3 96.15,151.16 95.74,151.16 95.52,150.93 U11.22
MXM_LVDS_A1-: length 20.3
  TOP w0.102: JMXM1.222 89.44,145.65 89.56,145.76 89.56,146.01 90.22,146.67 90.22,146.67 90.3,146.75 90.76,146.75 93,148.99 93,149.07 94.19,150.26 94.19,153.39 94.96,154.15 96.76,154.15 97.64,153.27 97.64,151.68 97.12,151.16 97.12,150.98 v2(97.26,150.84)
  BOTTOM w0.102: v2(97.26,150.84) 97.1,150.99 97.1,151.32 96.86,151.56 96.17,151.56 96.03,151.42 95.63,151.42 95.62,151.43 U11.21
MXM_LVDS_A2+: length 27.1
  TOP w0.102: JMXM1.218 88.44,145.55 88.2,145.79 88.2,145.96 88.29,146.05 88.29,146.4 88.2,146.49 88.2,146.79 88.29,146.88 88.29,147.24 88.2,147.33 88.2,147.57 89.41,148.78 89.76,148.78 90.52,149.54 92.4,149.54 93.06,150.2 93.06,153.23 94.52,154.69 96.92,154.69 98.4,153.21 98.4,150.61 97.62,149.83 97.62,149.19 97.48,149.05 97.48,148.73 97.43,148.68 97.2,148.68 v2(97.08,148.81)
  BOTTOM w0.102: v2(97.08,148.81) 97.31,148.81 97.52,149.02 97.52,149.15 97.38,149.29 96.29,149.29 96.17,149.17 95.91,149.17 95.67,148.93 U11.26
MXM_LVDS_A2-: length 27.2
  TOP w0.102: JMXM1.216 87.94,145.65 87.93,145.65 87.93,147.69 89.3,149.05 89.65,149.05 90.41,149.81 92.29,149.81 92.8,150.31 92.8,153.34 94.41,154.95 97.04,154.95 98.67,153.32 98.67,150.5 97.89,149.72 v2(97.89,148.81)
  BOTTOM w0.102: U11.25 96.05,149.43 96.18,149.56 97.49,149.56 97.79,149.26 97.79,148.91 v2(97.89,148.81)
MXM_LVDS_ACLK+: length 11.8
  TOP w0.102: v2(87.04,146.16) 87.04,146.27 86.73,146.58 86.25,146.58 86.16,146.5 85.81,146.5 85.72,146.58 85.48,146.58 85.21,146.31 85.21,145.72 85.44,145.48 JMXM1.206
  IN4 w0.117: v2(92.63,146.57) 92.85,146.79 92.85,146.94 92.66,147.13 92.24,147.13 92.14,147.03 91.74,147.03 91.64,147.13 91.29,147.13 91.19,147.03 90.79,147.03 90.69,147.13 88.28,147.13 87.67,146.52 87.32,146.52 87.04,146.24 v2(87.04,146.16)
  BOTTOM w0.102: v2(92.63,146.57) 92.79,146.73 92.79,146.82 92.67,146.94 U11.31
MXM_LVDS_ACLK-: length 11.9
  TOP w0.102: JMXM1.204 84.94,146.42 85.37,146.85 v2(87.04,146.85)
  IN4 w0.117: v2(87.04,146.85) 87.1,146.8 87.55,146.8 88.17,147.41 92.78,147.41 93.13,147.06 93.14,147.06 93.22,146.98 v2(93.22,146.57)
  BOTTOM w0.102: U11.30 93.18,146.94 93.06,146.82 93.06,146.73 v2(93.22,146.57)
MXM_LVDS_B0+: length 15.4
  TOP w0.102: JMXM1.225 89.69,137.6 89.57,137.71 89.57,142.17 89.99,142.58 89.99,143.6 v2(90.14,143.75)
  BOTTOM w0.102: v2(90.14,143.75) 90.14,143.75 90.14,143.25 89.9,143 88.66,143 88.25,143.41 88.25,143.77 v3(87.9,144.12) 86.36,145.66 86.36,147.08 86.28,147.16 U13.18
MXM_LVDS_B0-: length 15.3
  TOP w0.102: JMXM1.223 89.19,137.6 89.31,137.71 89.31,142.28 89.72,142.69 89.72,143.59 v2(89.56,143.75)
  BOTTOM w0.102: v2(89.56,143.75) 89.56,143.75 89.88,143.43 89.88,143.36 89.79,143.27 88.77,143.27 88.52,143.52 88.52,143.88 87.77,144.63 87.77,144.75 87.5,145.02 87.4,145.02 87.19,145.24 87.19,145.34 86.92,145.6 86.79,145.6 86.63,145.77 86.63,147.19 86.39,147.43 86.16,147.43 85.93,147.66 U13.17
MXM_LVDS_B1+: length 14.1
  TOP w0.102: v2(87.02,143.08) 87.02,143.06 86.84,142.89 86.84,142.51 88.07,141.27 88.07,137.57 88.19,137.45 JMXM1.219
  BOTTOM w0.102: U13.22 83.02,144.53 v3(83.51,144.04) 85.18,142.37 86.57,142.37 87.02,142.81 v2(87.02,143.08)
MXM_LVDS_B1-: length 14
  TOP w0.102: v2(86.41,143.08) 86.41,143.07 86.57,142.9 86.57,142.4 87.81,141.16 87.81,137.58 87.69,137.46 JMXM1.217
  BOTTOM w0.102: U13.21 83.52,145.77 83.29,145.53 83.29,145.37 83.39,145.28 83.59,145.28 83.67,145.2 83.67,145.05 83.56,144.95 83.37,144.95 83.29,144.87 83.29,144.64 84.11,143.82 84.21,143.82 84.48,143.55 84.48,143.45 84.69,143.23 84.8,143.23 85.06,142.97 85.06,142.86 85.29,142.63 86.46,142.63 86.64,142.81 86.64,142.91 86.47,143.08 v2(86.41,143.08)
MXM_LVDS_B2+: length 15.6
  TOP w0.102: v2(86.74,141.09) 86.73,141.09 86.73,141.05 86.57,140.89 86.57,137.59 86.69,137.48 JMXM1.213
  BOTTOM w0.102: v2(86.74,141.09) 86.71,141.06 86.71,140.45 86.42,140.16 83.48,140.16 82.51,141.13 82.51,141.91 81.34,143.08 81.34,144.37 81.02,144.69 U13.26
MXM_LVDS_B2-: length 15.7
  TOP w0.102: JMXM1.211 86.19,137.44 86.31,137.55 86.31,140.93 86.13,141.11 v2(86.13,141.11)
  BOTTOM w0.102: U13.25 81.52,145.8 81.29,145.57 81.29,145.48 81.37,145.4 81.56,145.4 81.63,145.33 81.63,145.12 81.56,145.05 81.35,145.05 81.29,144.98 81.29,144.8 81.61,144.48 v3(81.61,143.88) 81.61,143.19 82.78,142.02 82.78,141.24 83.59,140.42 84.64,140.42 84.72,140.5 85.07,140.5 85.15,140.42 85.45,140.42 85.53,140.5 85.89,140.5 85.96,140.42 86.31,140.42 86.45,140.56 86.45,140.79 86.13,141.11 v2(86.13,141.11)
MXM_LVDS_BCLK+: length 21.5
  TOP w0.102: JMXM1.201 83.69,137.35 83.59,137.45 83.59,137.53 83.69,137.63 83.99,137.63 84.26,137.9 84.26,138.13 84.45,138.32 v2(84.48,138.32)
  BOTTOM w0.102: v2(84.48,138.32) 84.48,137.94 84,137.45 80.88,137.45 79.7,138.62 79.7,141.88 79.34,142.24 79.34,143.45 76.96,145.82 76.96,148.02 77.6,148.66 U13.31
MXM_LVDS_BCLK-: length 21.5
  TOP w0.102: JMXM1.199 83.19,137.38 83.32,137.51 83.32,137.64 83.58,137.9 83.88,137.9 84,138.01 84,138.12 83.95,138.17 83.93,138.17 v2(83.79,138.32)
  BOTTOM w0.102: U13.30 79.18,148.16 78.95,148.4 78.73,148.4 78.69,148.35 78.69,147.99 78.59,147.89 78.28,147.89 78.21,147.97 78.21,148.35 78.16,148.4 77.71,148.4 77.23,147.91 77.23,145.93 79.6,143.56 v3(79.6,142.89) 79.6,142.35 79.97,141.99 79.97,138.74 80.99,137.72 82.05,137.72 82.14,137.81 82.49,137.81 82.58,137.72 82.89,137.72 82.98,137.81 83.33,137.81 83.42,137.72 83.89,137.72 84.12,137.96 84.12,138.11 83.92,138.32 v2(83.79,138.32)
MXM_LVDS_DDC_CLK: length 55
  TOP w0.102: JMXM1.71 49.69,137.49 51.15,138.95 51.15,139.46 53.95,142.25 57.71,142.25 58.29,142.84 58.82,142.84 59.08,143.09 60.76,143.09 61.01,142.84 67.46,142.84 68.33,141.97 74.46,141.97 75.46,142.97 v2(75.46,143.07) ; v2(88.34,150.76) 87.4,149.82 R1122.2
  IN1 w0.109: v2(75.94,151.35) 79.75,151.35 80.31,151.91 86.01,151.91 87.56,150.35 88.24,150.35 88.34,150.45 v2(88.34,150.76)
  BOTTOM w0.102: v2(75.46,143.07) 75.46,150.94 75.87,151.35 v2(75.94,151.35) ; v2(88.34,150.76) 88.67,150.43 U11.5
MXM_LVDS_DDC_DAT: length 59
  TOP w0.102: v2(74.88,143.07) 74.26,142.46 68.53,142.46 67.66,143.32 61.21,143.32 60.96,143.57 58.88,143.57 58.62,143.32 56.06,143.32 55.5,142.76 52.5,142.76 50.05,140.31 50.05,138.53 49.19,137.67 JMXM1.69
  IN1 w0.109: v2(75.94,151.96) 76.06,151.84 79.41,151.84 79.97,152.4 89.55,152.4 91.47,154.32 v2(91.72,154.32)
  BOTTOM w0.102: v2(74.88,143.07) 74.9,143.1 74.9,151.3 75.56,151.96 v2(75.94,151.96) ; U11.13 91.67,154.28 v2(91.72,154.32) 91.41,154.62 R1121.2
MXM_MB_DP_AUX: length 300.7
  TOP w0.102: v2(99.87,121.2) 101.27,121.2 101.41,121.06 103.62,121.06 104.41,121.84 104.41,123.57 105.19,124.36 105.19,127.05 105.7,127.56 105.75,127.56 106.22,128.03 106.22,131.24 110.55,135.57 110.55,135.8 110.69,135.94 JMXM1.309
  IN1 w0.117: v2(287.5,62.52) 287.37,62.52 287.2,62.7 287.2,62.95 286.93,63.22 286.55,63.22 286.46,63.31 286.06,63.31 285.96,63.22 285.61,63.22 285.52,63.31 285.12,63.31 285.02,63.22 262.23,63.22 260.27,61.25 247.97,61.25 247.7,60.97 245.03,60.97 244.33,60.27 230.03,60.27 229.73,60.58 226.27,60.58 225.78,60.09 211.81,60.09 209.32,57.6 198.19,57.6 190.9,50.31 159.76,50.31 159.26,50.81 154.33,50.81 153.82,50.31 125.5,50.31 116.61,59.2 114.79,59.2 111.4,62.58 108.7,62.58 100.74,70.54 100.74,77.83 100.13,78.45 100.13,80.15 100.76,80.79 100.76,85.15 99.69,86.22 99.69,89.93 98.51,91.12 98.51,109.25 97.64,110.11 97.64,114.45 98.65,115.46 98.65,118.8 99.13,119.29 99.13,121.22 99.46,121.54 99.68,121.54 99.87,121.35 v2(99.87,121.2)
  IN4 w0.117: v2(291.46,72.43) 291.59,72.43 291.96,72.06 291.96,71.66 291.64,71.34 291.64,63.85 289.66,61.86 289.43,61.86 289.32,61.96 288.92,61.96 288.82,61.86 288.47,61.86 288.37,61.96 287.97,61.96 287.87,61.86 287.28,61.86 287.07,62.07 287.07,62.27 287.32,62.52 v2(287.5,62.52)
  BOTTOM w0.102: C397.1 291.39,73.14 291.68,72.85 291.68,72.64 v2(291.46,72.43) 291.62,72.43 291.95,72.1 291.95,71.95 291.71,71.72 290.94,71.72 290.27,72.38 290.27,72.4 289.85,72.82 289.83,72.82 289.79,72.86 289.28,72.86 289.1,73.04 U22.33 ; Q340.1 287.44,61.52 287.44,62.46 v2(287.5,62.52)
MXM_MB_DP_AUX#: length 300.7
  TOP w0.102: v2(99.87,121.93) 99.87,121.78 100.24,121.41 101.36,121.41 101.5,121.27 103.53,121.27 104.19,121.93 104.19,123.66 104.98,124.45 104.98,127.14 105.61,127.78 105.66,127.78 106.01,128.12 106.01,131.33 110.33,135.66 110.33,135.8 110.19,135.94 JMXM1.307
  IN1 w0.117: v2(286.74,62.52) 286.96,62.74 286.96,62.86 286.84,62.98 262.33,62.98 260.37,61.02 248.07,61.02 247.79,60.74 245.13,60.74 244.43,60.04 229.94,60.04 229.63,60.34 226.36,60.34 225.88,59.86 211.91,59.86 209.41,57.36 198.29,57.36 191,50.07 159.67,50.07 159.16,50.58 154.43,50.58 153.92,50.07 125.4,50.07 116.51,58.96 114.69,58.96 111.3,62.34 108.61,62.34 100.51,70.44 100.51,77.73 99.89,78.35 99.89,80.25 100.52,80.88 100.52,85.05 99.46,86.12 99.46,89.84 98.27,91.02 98.27,109.15 97.41,110.02 97.41,114.55 98.42,115.56 98.42,118.9 98.9,119.39 98.9,121.32 99.36,121.78 99.72,121.78 99.75,121.81 99.75,121.81 v2(99.87,121.93)
  IN4 w0.117: v2(292.2,72.43) 292.2,71.57 291.88,71.24 291.88,63.75 289.75,61.63 287.18,61.63 286.83,61.97 286.83,62.43 v2(286.74,62.52)
  BOTTOM w0.102: C398.1 291.9,72.84 291.9,72.68 292.15,72.43 v2(292.2,72.43) 292.17,72.4 292.17,71.9 291.78,71.5 290.85,71.5 v3(289.88,72.46) 289.7,72.64 289.27,72.64 289.16,72.54 U22.34 ; v2(286.74,62.52) 286.38,62.52 285.96,62.94 Q340.4
MXM_MB_DP_AUX#_C: length 4.1
  BOTTOM w0.102: U22.29 289.14,75.04 289.23,74.96 289.76,74.96 289.77,74.97 290.31,74.97 290.32,74.96 v3(291.37,74.96) 291.58,74.96 291.95,74.59 291.95,74.31 C398.2
MXM_MB_DP_AUX_C: length 4.1
  BOTTOM w0.102: C397.2 291.67,74.05 291.73,74.12 291.73,74.5 291.5,74.73 291.11,74.73 291.1,74.74 v3(290.04,74.74) 289.25,74.74 289.06,74.54 U22.30
MXM_MB_DP_HPD: length 227.9
  TOP w0.102: U27.2 123.04,132.91 122.78,132.65 122.78,131.92 D8.2 123.04,131.66 124.08,131.66 v2(124.51,132.09)
  IN4 w0.109: v2(259.88,78.08) 259.07,77.27 245.86,77.27 242.85,74.27 234.05,74.27 232.87,73.08 232.87,70.14 231.89,69.17 229.36,69.17 227.18,66.99 218.96,66.99 216.66,69.28 210.27,69.28 185.81,93.74 145.14,93.74 134.86,104.03 133.08,104.03 133.01,104.1 122.48,104.1 119.85,106.73 119.85,113.06 121.32,114.52 124.07,114.52 127.24,117.7 127.24,127.15 126.6,127.78 126.6,130 v2(124.51,132.09)
  BOTTOM w0.102: v2(259.88,78.08) 259.97,78.17 259.97,80.4 261.89,82.33 265.75,82.33 266.39,81.7 273.71,81.7 274.57,80.84 274.57,78.37 275.84,77.1 276.68,77.1 277.01,76.77 v1(277.01,76.14) 277.01,75.58 277.57,75.02 280.24,75.02 280.76,75.54 U22.9
MXM_MB_DP_HPD_GATE: length 22.1
  TOP w0.102: U27.4 123.69,136.62 R60.1 123.11,137.2 123.11,138.21 119.39,141.94 v1(119.39,143.42) 119.39,144.5 117.79,146.1 113.62,146.1 113.35,145.83 110.15,145.83 109.94,145.63 JMXM1.304
MXM_MB_DP_N0: length 275.9
  TOP w0.102: JMXM1.283 104.19,136 104.41,135.79 104.41,134.68 101.23,131.51 v3(101.23,128.49) 101.23,127.8 100.93,127.5 100.93,124.1 100.71,123.89 100.53,123.89 100.15,124.27 v2(100.15,124.35)
  IN1 w0.117: v2(100.15,124.35) 100.15,124.22 100.28,124.09 100.68,124.09 100.96,123.81 100.96,119.67 100.1,118.8 100.1,114.85 101.14,113.81 101.14,109.43 100.43,108.72 100.43,103.95 99.62,103.14 99.62,91.33 100.48,90.46 100.48,86.83 101.85,85.46 101.85,80.46 101.22,79.82 101.22,78.4 101.61,78.01 101.61,76.26 102.49,75.38 102.49,74.49 102.39,74.38 102.39,72.38 111.43,63.34 111.99,63.34 114.9,60.42 116.42,60.42 125.78,51.07 153.44,51.07 154,51.63 159.69,51.63 160.25,51.07 190.6,51.07 197.86,58.33 205.63,58.33 206.17,58.87 208.91,58.87 211.36,61.31 230.14,61.31 230.43,61.02 242.44,61.02 242.8,61.39 244.25,61.39 245.04,62.17 246.87,62.17 248.67,63.98 252.7,63.98 252.94,64.21 287.67,64.21 288.13,64.68 288.13,64.83 288.4,65.1 288.56,65.1 288.8,65.35 288.8,65.5 289.08,65.78 289.23,65.78 289.63,66.17 289.63,66.58 v2(289.37,66.84)
  BOTTOM w0.102: v2(289.37,66.84) 289.55,67.03 289.55,67.15 C284.1
MXM_MB_DP_N0_C: length 4.7
  BOTTOM w0.102: C284.2 289.56,68.87 289.56,69.18 289.25,69.49 v3(288.07,69.49) 287.39,69.49 287.07,69.82 287.07,70.16 286.92,70.3 U22.39
MXM_MB_DP_N1: length 266.2
  TOP w0.102: JMXM1.289 105.69,136.05 105.97,135.77 105.97,135.17 102.28,131.48 v3(102.28,130.24) 102.28,127.7 101.65,127.06 101.65,123.91 102.08,123.48 102.08,122.75 102.02,122.68 101.89,122.68 101.52,123.05 v2(101.52,123.13)
  IN1 w0.117: v2(101.52,123.13) 101.52,123.08 101.9,122.7 102.02,122.7 102.23,122.49 102.23,119.59 100.97,118.33 100.97,115.25 102.06,114.16 102.06,109.31 101.4,108.65 101.4,103.87 100.4,102.88 100.4,91.68 101.22,90.87 101.22,87.27 102.65,85.84 102.65,77.07 103.78,75.93 103.78,73.02 112.45,64.35 114.28,64.35 121.08,57.54 147.04,57.54 147.7,56.88 184.48,56.88 185.04,57.44 193.29,57.44 195.25,59.41 200.18,59.41 201.04,60.27 201.6,60.27 202.33,61.01 209.71,61.01 210.75,62.05 227.57,62.05 228.4,62.88 230.05,62.88 231.16,61.77 242.04,61.77 243.36,63.09 245.6,63.09 247.37,64.86 251.94,64.86 254.13,67.05 277.03,67.05 277.94,66.14 283.27,66.14 283.36,66.23 283.76,66.23 283.85,66.14 284.2,66.14 284.3,66.23 284.7,66.23 284.79,66.14 285.4,66.14 285.73,66.47 285.73,66.67 v2(285.56,66.84)
  BOTTOM w0.102: C283.1 285.74,67.15 285.74,67.03 v2(285.56,66.84)
MXM_MB_DP_N1_C: length 2.6
  BOTTOM w0.102: U22.42 285.42,70.33 285.57,70.18 285.57,69.36 285.74,69.19 285.74,68.86 C283.2
MXM_MB_DP_N2: length 261.8
  TOP w0.102: v2(103.48,122.37) 103.29,122.56 102.96,122.56 102.77,122.75 102.77,126.99 103.52,127.74 103.52,131.5 v3(103.89,131.87) 106.69,134.68 107.3,135.29 107.3,135.89 107.19,136 JMXM1.295
  IN1 w0.117: v2(103.48,122.37) 103.48,122.52 103.65,122.69 103.86,122.69 104.01,122.54 104.01,111.44 103.61,111.04 103.61,109.06 102.67,108.12 102.67,103.19 101.65,102.17 101.65,92.7 103.5,90.84 103.5,86.88 104.26,86.12 104.26,78 105.21,77.05 105.21,73.9 111.79,67.32 115.98,67.32 124.51,58.79 147.85,58.79 148.41,58.22 167.94,58.22 168.47,58.76 190.44,58.76 194.12,62.44 201.11,62.44 201.44,62.77 207.77,62.77 209.21,64.22 216.05,64.22 216.62,64.78 221.13,64.78 222.83,66.49 230.94,66.49 232.71,64.71 242.34,64.71 243.23,65.59 246.29,65.59 247.21,66.5 251.4,66.5 253.41,68.52 280.35,68.52 280.46,68.42 280.86,68.42 280.96,68.52 281.31,68.52 281.41,68.42 281.81,68.42 281.91,68.52 282.67,68.52 283.91,67.28 283.91,67.1 v2(283.65,66.84)
  BOTTOM w0.102: C286.1 283.84,67.15 283.84,67.03 v2(283.65,66.84)
MXM_MB_DP_N2_C: length 2.7
  BOTTOM w0.102: C286.2 283.83,68.86 283.83,69.24 284.05,69.46 284.05,69.9 284.07,69.91 284.07,70.19 283.92,70.33 U22.45
MXM_MB_DP_N3: length 260.7
  TOP w0.102: JMXM1.301 108.69,136.08 108.97,135.79 108.97,135.48 108.95,135.46 104.72,131.23 104.72,130.06 104.71,130.05 104.71,129.52 104.72,129.5 104.72,127.95 104.27,127.5 104.27,124.73 104.05,124.51 103.85,124.51 v2(103.48,124.88)
  IN1 w0.117: v2(281.61,66.84) 281.79,67.02 281.79,67.3 281.48,67.6 253.74,67.6 251.91,65.77 247.54,65.77 245.41,63.63 241.56,63.63 241.28,63.91 234.64,63.91 234.23,63.51 232.11,63.51 230.37,65.24 223.42,65.24 222.22,64.04 217.04,64.04 216.18,63.18 209.35,63.18 208.2,62.03 201.85,62.03 201.42,61.61 195.81,61.61 192.17,57.97 169.48,57.97 168.92,57.41 148.01,57.41 147.38,58.04 122.72,58.04 116.6,64.17 115.25,64.17 113.05,66.36 111.55,66.36 104.39,73.52 104.39,76.54 103.37,77.57 103.37,85.95 102.68,86.64 102.68,90.34 100.91,92.12 100.91,102.67 101.9,103.66 101.9,108.39 102.73,109.23 102.73,124.36 103.08,124.71 103.31,124.71 v2(103.48,124.88)
  BOTTOM w0.102: C282.1 281.9,67.18 281.9,67.07 281.67,66.84 v2(281.61,66.84)
MXM_MB_DP_N3_C: length 2.8
  BOTTOM w0.102: U22.48 282.42,70.33 282.57,70.18 282.57,69.86 v3(282.32,69.61) 281.93,69.22 281.93,68.86 C282.2
MXM_MB_DP_P0: length 276
  TOP w0.102: v2(100.15,123.69) 100.79,123.69 101.14,124.03 101.14,127.41 101.45,127.71 101.45,128.21 101.46,128.22 101.46,128.75 101.45,128.76 101.45,131.42 104.62,134.59 104.62,135.9 104.69,135.97 JMXM1.285
  IN1 w0.117: v2(100.15,123.69) 100.32,123.86 100.59,123.86 100.73,123.71 100.73,119.77 99.86,118.9 99.86,114.75 100.91,113.71 100.91,109.53 100.19,108.82 100.19,104.05 99.38,103.24 99.38,91.23 100.24,90.36 100.24,86.73 101.62,85.36 101.62,80.55 100.98,79.92 100.98,78.3 101.37,77.91 101.37,76.16 102.25,75.28 102.25,74.58 102.15,74.48 102.15,72.28 111.33,63.1 111.89,63.1 114.81,60.19 116.33,60.19 125.68,50.83 153.54,50.83 154.1,51.39 159.59,51.39 160.15,50.83 190.69,50.83 197.96,58.1 205.73,58.1 206.26,58.63 209.01,58.63 211.46,61.07 230.04,61.07 230.33,60.79 242.54,60.79 242.9,61.15 244.35,61.15 245.13,61.94 246.97,61.94 248.77,63.74 252.8,63.74 253.04,63.98 287.76,63.98 289.86,66.07 289.86,66.75 v2(289.95,66.84)
  BOTTOM w0.102: C285.1 289.77,67.15 289.77,67.03 v2(289.95,66.84)
MXM_MB_DP_P0_C: length 4.7
  BOTTOM w0.102: C285.2 289.76,68.87 289.76,69.3 v3(289.56,69.5) 289.36,69.71 288.35,69.71 288.34,69.72 287.81,69.72 287.79,69.71 287.48,69.71 287.28,69.91 287.28,70.16 287.42,70.3 U22.38
MXM_MB_DP_P1: length 266.3
  TOP w0.102: v2(101.52,122.47) 102.11,122.47 102.28,122.64 102.28,123.58 101.87,124 101.87,126.97 102.5,127.61 102.5,129.96 102.51,129.97 102.51,130.5 102.5,130.52 102.5,131.39 106.19,135.08 JMXM1.291
  IN1 w0.117: v2(286.14,66.84) 285.97,66.67 285.97,66.37 285.5,65.9 277.85,65.9 276.93,66.82 254.23,66.82 252.04,64.62 247.47,64.62 245.7,62.85 243.46,62.85 242.14,61.53 231.06,61.53 229.95,62.64 228.5,62.64 227.67,61.81 210.85,61.81 209.81,60.77 202.43,60.77 201.7,60.03 201.14,60.03 200.28,59.17 195.35,59.17 193.39,57.21 185.14,57.21 184.58,56.65 147.6,56.65 146.94,57.31 120.99,57.31 114.18,64.12 112.35,64.12 103.55,72.92 103.55,75.84 102.41,76.97 102.41,85.74 100.98,87.17 100.98,90.77 100.17,91.58 100.17,102.98 101.16,103.97 101.16,108.75 101.82,109.41 101.82,114.06 100.74,115.15 100.74,118.43 102,119.69 102,122.39 101.92,122.47 v2(101.52,122.47)
  BOTTOM w0.102: C280.1 285.96,67.15 285.96,67.02 v2(286.14,66.84)
MXM_MB_DP_P1_C: length 2.6
  BOTTOM w0.102: U22.41 285.92,70.33 285.78,70.18 285.78,69.45 285.95,69.28 285.95,68.87 C280.2
MXM_MB_DP_P2: length 261.7
  TOP w0.102: JMXM1.297 107.69,136.05 107.52,135.88 107.52,135.2 104.29,131.97 104.29,131.95 103.86,131.52 103.84,131.52 103.73,131.42 103.73,127.65 102.98,126.9 102.98,122.83 103.05,122.77 103.43,122.77 103.48,122.82 v2(103.48,123.13)
  IN1 w0.117: v2(284.24,66.84) 284.15,66.93 284.15,67.37 282.77,68.75 253.32,68.75 251.3,66.74 247.11,66.74 246.2,65.82 243.13,65.82 242.25,64.94 232.81,64.94 231.03,66.72 222.73,66.72 221.03,65.02 216.52,65.02 215.95,64.45 209.12,64.45 207.67,63.01 201.34,63.01 201.01,62.68 194.03,62.68 190.34,58.99 168.38,58.99 167.84,58.46 148.51,58.46 147.95,59.03 124.61,59.03 116.08,67.55 111.89,67.55 105.44,74 105.44,77.15 104.49,78.1 104.49,86.22 103.74,86.98 103.74,90.94 101.89,92.8 101.89,102.07 102.9,103.09 102.9,108.02 103.84,108.96 103.84,110.94 104.25,111.34 104.25,122.64 103.96,122.92 103.68,122.92 v2(103.48,123.13)
  BOTTOM w0.102: v2(284.24,66.84) 284.05,67.02 284.05,67.15 C281.1
MXM_MB_DP_P2_C: length 2.7
  BOTTOM w0.102: U22.44 284.42,70.33 284.28,70.19 v3(284.28,69.63) 284.28,69.39 284.05,69.15 284.05,68.87 C281.2
MXM_MB_DP_P3: length 260.7
  TOP w0.102: JMXM1.303 109.19,136.7 109.19,135.39 109.1,135.31 104.94,131.15 v3(104.94,129.78) 104.94,127.86 104.48,127.41 104.48,124.64 104.14,124.3 v2(103.48,124.3)
  IN1 w0.117: v2(103.48,124.3) 103.3,124.47 103.18,124.47 102.97,124.27 102.97,109.13 102.13,108.29 102.13,103.56 101.14,102.57 101.14,92.22 102.92,90.44 102.92,86.74 103.61,86.05 103.61,77.67 104.63,76.64 104.63,73.61 111.65,66.59 113.15,66.59 115.34,64.4 116.69,64.4 122.82,58.28 147.48,58.28 148.11,57.65 168.82,57.65 169.38,58.2 192.07,58.2 195.71,61.84 201.33,61.84 201.75,62.27 208.1,62.27 209.25,63.42 216.08,63.42 216.94,64.28 222.12,64.28 223.32,65.48 230.47,65.48 232.21,63.74 234.13,63.74 234.54,64.15 241.37,64.15 241.65,63.87 245.31,63.87 247.44,66 251.81,66 253.65,67.84 278.65,67.84 278.75,67.93 279.15,67.93 279.24,67.84 279.59,67.84 279.69,67.93 280.09,67.93 280.18,67.84 281.58,67.84 282.02,67.4 282.02,66.91 282.09,66.84 v2(282.33,66.84)
  BOTTOM w0.102: C279.1 282.52,67.55 282.12,67.15 282.12,67.06 v2(282.33,66.84)
MXM_MB_DP_P3_C: length 2.9
  BOTTOM w0.102: U22.47 282.92,70.33 282.78,70.18 282.78,69.77 282.67,69.65 282.67,69.64 282.29,69.26 282.28,69.26 282.14,69.13 282.14,68.87 C279.2
MXM_OVERT#: length 10.8
  TOP w0.102: v2(43.23,146.11) 45.44,146.11 45.94,145.61 JMXM1.56
  BOTTOM w0.102: v2(43.23,146.11) 43.18,146.11 42.65,145.58 v1(42.65,144.5) R10.2 41.64,140.62 Q4.3
MXM_PANEL_BKEN: length 78.1
  TOP w0.102: v2(98.47,163.03) 98.47,162.93 v1(99.16,162.24) ; v2(43.13,142.21) 43.92,141.42 43.92,141.25 47.19,137.97 JMXM1.61
  IN1 w0.109: v2(43.13,142.21) 43.36,142.21 44.22,143.07 44.22,143.83 44.86,144.47 48.31,144.47 49.75,145.91 55.26,145.91 56.02,146.67 65.19,146.67 65.88,147.36 66.49,147.36 67.71,148.58 69.34,148.58 70.15,149.39 70.15,150.94 70.61,151.4 73.2,151.4 75.01,153.21 86.7,153.21 88.87,155.39 94.66,155.39 95.63,156.35 95.63,160.36 97.91,162.64 98.09,162.64 v2(98.47,163.03)
  BOTTOM w0.102: v2(98.47,163.03) 99.03,163.59 99.58,163.59 D64.2
MXM_PRESENTL#: length 143.5
  TOP w0.076: v2(73.38,60.59) 73.18,60.39 73.18,59.45
  TOP w0.102: v2(86.18,54.22) 86.18,53.79 v1(85.79,53.39) 85.37,52.97 85.37,51.54 83.89,50.07 83.89,48.68 81.71,46.49 81.71,45.77 80.81,44.87 80.49,44.87 79.75,44.13 76.69,44.13 75.91,44.91 73.41,44.91 72.52,45.81 72.16,45.81 71.98,45.99 RPH8.6 71.98,46.52 72.34,46.88 72.46,46.88 73.28,47.69 73.51,47.69 74.62,48.81 74.62,53.31 73.81,54.13 73.81,58.81 73.18,59.45 ; v2(98.22,120.61) 99.03,119.8 103.44,119.8 104.89,121.25 104.89,123.34 106.04,124.5 106.88,124.5 107.69,125.31 107.69,127.06 106.7,128.05 106.7,131.04 111.19,135.53 JMXM1.310
  IN1 w0.109: v2(86.18,54.22) 86.18,55.43 88.37,57.62 93.34,57.62 98.5,62.78 98.5,70.02 99.49,71.01 99.49,76.11 98.84,76.76 98.84,79.67 97.81,80.7 97.81,83.6 98.93,84.73 98.93,89.66 97.78,90.82 97.78,107.21 96.37,108.62 96.37,114.31 96.75,114.69 96.75,119.14 v2(98.22,120.61)
  BOTTOM w0.102: UH1.G15 73.76,60.97 v2(73.38,60.59)
MXM_PRESENTR#: length 182.9
  TOP w0.076: 71.83,59.68 71.83,60.16 72,60.32 72,60.68 v2(72.41,61.1)
  TOP w0.102: v2(42.54,138.34) 41.44,139.45 JMXM1.38 ; 71.83,59.68 71.83,59.47 72.19,59.11 72.19,55.91 72.57,55.53 72.57,52.21 72.36,52.01 v1(72.36,51.74) 72.36,49.41 72.52,49.26 72.52,48.71 71.72,47.92 71.32,47.92 70.71,47.31 68.99,47.31 68.56,46.87 RPH9.7 68.56,46.09 68.3,45.83 67.49,45.83 67.03,45.38 v2(67.03,44.82)
  IN1 w0.109: v2(42.54,138.34) 42.29,138.09 42.29,130.85 37.64,126.2 37.64,123.56 38.56,122.64 38.56,115.13 36.65,113.22 34.39,113.22 31.95,110.78 19.25,110.78 10.62,102.16 9.43,102.16 8.65,101.37 8.65,97.36 v2(8.89,97.12)
  IN4 w0.109: v2(8.89,97.12) 8.89,96.34 13.8,91.43 13.8,87.47 15.71,85.56 17.37,85.56 21.37,81.56 27.84,81.56 29.11,80.29 35.02,80.29 37.68,77.64 37.68,76.22 40.31,73.58 41.06,73.58 44.91,69.74 45.97,69.74 50.35,65.36 50.35,57.6 54.12,53.83 54.12,52.8 56.56,50.36 57.31,50.36 62.34,45.33 63.13,45.33 63.94,44.51 66.72,44.51 v2(67.03,44.82)
  BOTTOM w0.102: v2(72.41,61.1) 72.54,60.97 UH1.G13
MXM_PWR_LEVEL: length 87.4
  TOP w0.102: v2(116.43,129.09) 116.08,129.44 D19.2 114.32,130.42 R37.2 113.78,130.4 U17.4 ; JMXM1.54 45.44,144.16 46,143.6 46,143.4 46.28,143.12 46.28,141.67 49.1,138.85 49.1,138.46 48.82,138.18 v2(48.82,138.06)
  IN1 w0.109: v2(48.82,138.06) 48.82,138.04 49.47,137.38 49.47,134.85 53.44,130.88 64.94,130.88 66.39,129.43 83.24,129.43 83.92,130.11 108.86,130.11 109.89,129.09 114.37,129.09 114.61,129.32 116.2,129.32 v2(116.43,129.09)
  BOTTOM w0.102: v2(48.82,138.06) v1(49.5,138.06)
MXM_RSVD1: length 3.5
  TOP w0.102: v2(101.93,142.53) 100.94,143.52 JMXM1.268
  BOTTOM w0.102: v2(101.93,142.53) 101.8,142.66 R6.2
MXM_RSVD2: length 5.5
  TOP w0.102: v2(101.93,143.14) 101.88,143.14 101.44,143.58 JMXM1.270
  BOTTOM w0.102: v2(101.93,143.14) 101.78,143.29 100.96,143.29 R1979.2 100.09,142.66 99.26,141.83 v1(99.26,141.68)
NB_LAN_TX0+: length 2.8
  TOP w0.279: R575.1 57.45,156.15 57.45,155.74 v2(57.55,155.64)
  BOTTOM w0.279: T156.24 57.89,156.53 57.45,156.1 57.45,155.74 v2(57.55,155.64)
NB_LAN_TX0+_R: length 14
  TOP w0.279: R575.2 57.45,157.93 57.45,158.21 v2(57.75,158.5)
  IN4 w0.203: JLOM1.1 52.22,162.07 50.9,160.75 50.9,158.18 51.76,157.32 57.12,157.32 57.61,157.81 57.61,158.36 v2(57.75,158.5)
NB_LAN_TX0-: length 2.8
  TOP w0.279: R576.1 57.05,156.15 57.05,155.74 v2(56.95,155.64)
  BOTTOM w0.279: T156.23 56.62,156.53 57.05,156.1 57.05,155.74 v2(56.95,155.64)
NB_LAN_TX0-_R: length 14
  TOP w0.279: R576.2 57.05,157.93 57.05,158.21 v2(56.74,158.52)
  IN4 w0.203: JLOM1.2 53.02,161.39 52.03,161.39 51.24,160.61 51.24,158.32 51.9,157.67 55.39,157.67 55.6,157.87 56.21,157.87 56.41,157.67 56.98,157.67 57.26,157.95 57.26,158.58 57.08,158.77 56.91,158.77 56.74,158.61 v2(56.74,158.52)
NB_LAN_TX1+: length 2.8
  TOP w0.279: v2(52.47,155.64) 52.37,155.74 52.37,156.15 R577.1
  BOTTOM w0.279: v2(52.47,155.64) 52.37,155.74 52.37,155.94 52.81,156.38 T156.20
NB_LAN_TX1+_R: length 10.6
  TOP w0.279: v2(52.47,158.51) 52.37,158.41 52.37,157.93 R577.2
  IN3 w0.191: JLOM1.3 54.26,160.79 55.47,159.58 55.47,159.13 55.88,158.73 55.88,157.98 55.55,157.65 52.84,157.65 52.28,158.21 52.28,158.31 v2(52.47,158.51)
NB_LAN_TX1-: length 2.8
  TOP w0.279: v2(51.87,155.64) 51.97,155.74 51.97,156.15 R578.1
  BOTTOM w0.279: T156.19 51.54,156.4 51.97,155.97 51.97,155.74 v2(51.87,155.64)
NB_LAN_TX1-_R: length 10.6
  TOP w0.279: R578.2 51.97,157.93 51.97,158.41 v2(51.87,158.51)
  IN3 w0.191: v2(51.87,158.51) 51.95,158.43 51.95,158.07 52.7,157.32 55.69,157.32 56.21,157.84 56.21,158.86 55.8,159.27 55.8,159.65 JLOM1.6
NB_LAN_TX2+: length 14.2
  IN1 w0.203: v2(50.13,158.62) 50.13,158.74 49.94,158.93 49.78,158.93 49.59,158.75 49.59,158.27 50.06,157.8 50.6,157.8 50.8,158 51.41,158 51.62,157.8 52.23,157.8 52.43,158 53.04,158 53.25,157.8 55.37,157.8 55.82,158.25 55.82,159.81 56.06,160.05 56.06,161.14 55.73,161.46 55.41,161.46 55.28,161.33 JLOM1.4
  BOTTOM w0.279: v2(50.13,158.62) 49.83,158.33 49.83,158.15 50.27,157.72 T156.18
NB_LAN_TX2-: length 14.2
  IN1 w0.203: JLOM1.5 56.3,161.4 56.4,161.3 56.4,159.91 56.16,159.67 56.16,158.1 55.51,157.46 49.92,157.46 49.25,158.13 49.25,158.51 v2(49.13,158.63)
  BOTTOM w0.279: T156.17 49,157.72 49.43,158.15 49.43,158.33 v2(49.13,158.63)
NB_LAN_TX3+: length 22.2
  IN1 w0.203: JLOM1.7 58.48,162.13 58.48,158.12 57.02,156.66 45.8,156.66 44.66,157.79 44.66,158.6 v2(44.85,158.79)
  BOTTOM w0.279: T156.14 45.19,157.8 44.73,158.26 44.73,158.67 44.85,158.79 v2(44.85,158.79)
NB_LAN_TX3-: length 22.3
  IN1 w0.203: JLOM1.8 58.83,160.64 58.83,157.98 57.16,156.31 45.65,156.31 44.32,157.65 44.32,158.72 v2(44.25,158.79)
  BOTTOM w0.279: T156.13 43.92,157.82 44.32,158.23 44.32,158.72 44.25,158.79 v2(44.25,158.79)
NB_PSID: length 45.7
  TOP w0.254: v2(6.35,90.72) 6.86,91.23 PL3.2
  IN4 w0.254: v2(8.74,64.48) 8.74,67.03 10.22,68.52 10.22,69.53 6.32,73.43 6.32,80.45 8.4,82.53 8.4,88.66 v2(6.35,90.72)
  BOTTOM w0.102: v4(20.41,61.74) 18.86,63.28 PJPDC1.2
  BOTTOM w0.254: PJPDC1.2 12.19,63.28 12.06,63.16 9.4,63.16 8.74,63.82 v2(8.74,64.48)
NB_PSID_TS5A63157: length 3.6
  TOP w0.102: PU1.3 6.52,99.11 v1(6.34,98.92)
  TOP w0.254: PU1.3 7.74,98.5 7.67,98.43 PR9.2 PR8.1
NTC: length 25
  TOP w0.203: PU500.6 155.35,172
  TOP w0.254: PH500.1 164.62,161.53 163.84,161.53 v1(162.67,160.36) 162.1,160.36 v2(162.05,160.31) ; v2(154.76,172.91) 154.71,172.96 154.71,173.57 PR528.1 155.14,173.3 155.14,173.26 155.24,173.16 155.24,172.1 155.35,172
  IN4 w0.254: v2(162.05,160.31) 161.92,160.44 161.62,160.44 161.16,160.9 161.16,167.96 158.27,170.85 158.27,171.97 156.51,173.72 155.57,173.72 v2(154.76,172.91)
NUM_LED: length 2.4
  TOP w0.102: JIO1.90 21.72,76.5 R942.2
NUM_LED#: length 277.2
  TOP w0.102: v2(22.26,71.6) Q93.3 24.6,73.33 v1(24.92,73.01)
  IN3 w0.127: v2(205.97,42.13) 206.63,42.13 211.06,46.55 211.06,47.6 214.48,51.02 220.58,51.02 221.25,51.69 223.38,51.69 226.19,54.49 226.19,57.52 228.57,59.91 234.92,59.91 235.3,60.29 244.83,60.29 246.56,62.01 246.71,62.01 247.09,62.4 247.09,69.05 244.47,71.67 v2(244.47,72.94)
  IN4 w0.109: v2(22.26,71.6) 22.82,71.6 23.22,71.2 26.96,71.2 27.14,71.02 28.48,71.02 29.28,71.83 40.19,71.83 41.69,70.32 41.69,69.61 42.62,68.68 42.84,68.68 44.17,67.35 44.88,67.35 45.89,66.35 46.92,66.35 48.25,65.01 48.62,64.65 48.62,56.95 52.44,53.13 52.44,51.89 55.9,48.43 56.77,48.43 60.73,44.46 60.73,43.93 62.27,42.39 73.52,42.39 74.13,41.78 77.46,41.78 77.83,41.41 83.41,41.41 83.55,41.55 93.62,41.55 94.46,40.7 99.09,40.7 99.31,40.92 102.05,40.92 103.33,39.64 119.4,39.64 121.63,37.4 167.13,37.4 167.81,36.72 173.96,36.72 175.7,38.46 177.11,38.46 177.37,38.72 188.74,38.72 190.19,40.17 197.89,40.17 200.58,42.86 203.94,42.86 205.08,41.72 205.56,41.72 v2(205.97,42.13)
  BOTTOM w0.102: v2(244.47,72.94) 244.19,72.66 U46.A2
NVRAM_PWR_EN: length 267.2
  TOP w0.102: v2(235,65.42) 234.95,65.42 234.56,65.04 233.98,65.04 233.3,65.72 229.51,65.72 229.11,65.32 224.6,65.32 223.87,66.05 220.78,66.05 216.13,70.7 v2(216.13,70.75)
  BOTTOM w0.102: U46.B32 235.23,65.2 v2(235,65.42) ; U49.3 13.06,141.11 R739.1 17.55,141.11 19.15,139.51 v1(27.09,139.51) 37.36,139.51 40.64,136.23 45.34,136.23 50.95,130.62 64.57,130.62 64.95,130.24 64.95,125.46 75.79,114.62 75.79,108.32 87.48,96.63 101.76,96.63 102.67,97.55 105.19,97.55 106.58,98.95 116.43,98.95 116.83,98.54 122.48,98.54 123.6,97.42 123.67,97.42 125.83,95.26 126.22,95.26 137.39,84.09 147.28,84.09 148.45,85.26 166.49,85.26 169.38,82.36 178.91,82.36 181.35,79.92 184.39,79.92 187.49,76.82 203.69,76.82 206.89,73.62 207.76,73.62 210.54,70.85 210.54,69.96 211.22,69.28 214.65,69.28 v2(216.13,70.75)
P1_SW: length 29.6
  TOP w0.254: PL502.2 v3(173.71,152.97)
  IN2 w0.254: v3(173.71,152.97) 173.52,152.78 168.09,152.78 162.23,158.64 160.4,158.64 158.93,160.11 154.61,160.11 154.22,159.72 154.22,159.26 v3(154.02,159.07)
  BOTTOM w0.102: v3(173.71,152.97) v1(173.04,152.97)
  BOTTOM w0.254: PR553.1 PR552.2 154.28,159.89 154.28,159.32 v3(154.02,159.07)
P2_SW: length 38.6
  TOP w0.254: PL501.2 184,155.06 v3(184,152.85)
  IN2 w0.254: v2(157.81,158.18) 157.91,158.08 158.98,158.08 160.2,156.86 161.85,156.86 167.26,151.45 170.15,151.45 173.84,147.77 178.92,147.77 181.1,149.94 181.1,151.6 182.2,152.69 183.84,152.69 v3(184,152.85)
  BOTTOM w0.254: PR539.1 PR535.2 v2(157.81,158.18)
  vias: v1(188.58,156.55) v3(186.28,157.04)
P3_SW: length 49.3
  TOP w0.254: v3(193.27,152.97) 193.27,155.11 PL500.2 ; PR511.2 PR510.2 156.08,158.43 157.58,156.93 v2(157.78,156.93)
  IN2 w0.254: v2(157.78,156.93) 157.96,156.76 158.53,156.76 165.23,150.05 169.9,150.05 173.61,146.34 182.32,146.34 182.47,146.5 185.39,146.5 191.67,152.78 193.08,152.78 v3(193.27,152.97)
  vias: v1(202.89,155.25) v3(197.55,154.78)
P33ALW: length 3.8
  BOTTOM w0.102: PR1025.1 256.91,34.93 v1(257.39,34.93)
  BOTTOM w0.254: PU1001.18 258.12,33.18 257.15,34.15 256.79,34.15 PR1025.1
P33ALW2: length 3.9
  BOTTOM w0.102: PR1022.2 v1(257.49,25.92)
  BOTTOM w0.254: PU1001.9 259.47,27.49 258.67,26.7 PR1022.2
P50ALW: length 4.1
  BOTTOM w0.102: PR1012.1 v1(266.27,36.31)
  BOTTOM w0.254: PU1001.27 263.47,34.69 264.48,35.7 264.64,35.7 265.15,36.21 PR1012.1
PANEL_BKEN_EC: length 238.5
  IN4 w0.109: v2(226.67,65.98) 225.96,65.27 218.69,65.27 215.31,68.65 210.01,68.65 185.55,93.11 144.88,93.11 134.59,103.4 132.82,103.4 132.75,103.47 122.21,103.47 119.22,106.46 119.22,114.4 121.9,117.08 125.13,117.08 126.57,118.52 126.57,126.88 124.52,128.93 124.52,129.91 122.93,131.5 122.93,133.8 122.29,134.45 122.29,138.17 120.67,139.78 120.67,151.58 121.88,152.78 122.49,152.78 125.74,156.03 125.74,158.45 126.67,159.38 128.01,159.38 129.24,160.62 129.24,161.72 127.46,163.5 125.08,163.5 v2(124.69,163.11)
  BOTTOM w0.102: v2(226.67,65.98) 226.67,66.33 227.61,67.27 230.77,67.27 v1(231.3,66.74) 231.66,66.38 232.15,66.38 232.43,66.66 U46.A35 ; D69.2 97.98,163.64 97.98,162.84 97.1,161.96 97.1,161.38 97.28,161.2 97.28,160.69 97.89,160.08 99.17,160.08 99.41,160.33 99.41,160.9 100.02,161.51 102.68,161.51 102.91,161.28 108.14,161.28 109.1,162.24 115.72,162.24 115.77,162.29 123.87,162.29 v2(124.69,163.11)
PANEL_BKEN_PCH: length 175.4
  TOP w0.102: v2(91.49,83.38) v1(92.33,84.22) 92.71,84.6 99.61,84.6 101.08,83.12 113.42,83.12 115.22,84.93 125.19,84.93 126.15,85.89 127.79,85.89 131.16,89.27 135.06,93.17 135.06,115.77 133.81,117.03 133.81,145.72 133.45,146.07 133.45,151.33 131.4,153.38 131.4,157.86 129.93,159.33 128.06,159.33 124.76,162.64 124.47,162.64 v2(124,163.11)
  IN4 w0.109: v2(82.9,62.14) 82.57,62.47 82.57,64.1 82.9,64.43 84.45,64.43 85.04,65.01 87.43,65.01 88.97,66.56 89.71,66.56 90.65,67.5 90.65,68.3 90.92,68.57 90.92,76.47 92.21,77.75 92.21,78.89 90.92,80.18 90.92,82.81 v2(91.49,83.38)
  BOTTOM w0.102: v2(82.9,62.14) 82.88,62.17 UH1.K36 ; v2(124,163.11) 123.42,162.52 115.54,162.52 115.47,162.45 108.93,162.45 107.99,161.51 104.93,161.51 103.99,162.45 U54.2
PANEL_BKEN_SW: length 47.3
  TOP w0.102: v2(124.66,149.01) v1(124.66,148.26)
  IN4 w0.109: v2(124.66,149.01) 124.66,149.1 126.74,151.17 128.09,151.17 129.26,152.34 129.26,154.99 129.68,155.41 129.68,159.13 131.27,160.72 131.27,163.56 v2(130.96,163.87)
  BOTTOM w0.102: U23.44 124.53,148.87 v2(124.66,149.01) ; U54.1 105.5,162.69 R1139.1 108.84,162.95 109.07,162.73 121.81,162.73 122.64,163.55 130.65,163.55 v2(130.96,163.87)
PBA_GPU_SEL#: length 398.4
  TOP w0.102: v2(251.51,36.13) 251.51,37.76 248.26,41.01 248.26,42.68 248.83,43.24 249.73,43.24 251.26,44.77 251.26,46.24 250.44,47.05 249.87,47.05 249.51,47.41 249.15,47.41 248.64,47.92 248.64,50.63 248.52,50.74 248.52,54.35 247.34,55.53 247.34,62.67 246.25,63.77 245.11,63.77 v2(244.57,64.3)
  IN1 w0.109: v2(35.43,125.46) 35.43,125.18 38.33,122.29 38.33,117.01 36.88,115.56 35.81,115.56 33.27,113.02 21.18,113.02 10.54,102.37 9.35,102.37 8.42,101.45 8.42,96.39 10.87,93.94 10.87,91.68 12.16,90.39 12.16,83.9 14.11,81.95 14.11,78.78 16.19,76.7 20.93,76.7 22.93,74.69 23.8,74.69 24.18,74.31 25.46,74.31 27.18,72.59 27.18,71.46 27.46,71.18 28.37,71.18 28.9,71.72 35.64,71.72 36.41,72.49 39.5,72.49 41.74,70.25 42.93,70.25 44.47,68.72 44.47,67.88 45.89,66.46 47.46,66.46 49.43,64.49 49.43,62.74 49.7,62.47 49.7,62.46 49.76,62.4 49.76,47.88 67.1,30.54 67.1,29.82 70.26,26.66 92.32,26.66 99.82,19.16 110.2,19.16 119.71,28.67 123.49,28.67 125.3,30.47 153.8,30.47 156.73,27.54 177.39,27.54 178.38,28.54 192.5,28.54 200.78,36.81 204.91,36.81 206.32,38.22 218.36,38.22 223.3,33.28 234.03,33.28 234.62,32.69 244.57,32.69 246.52,34.64 250.02,34.64 v2(251.51,36.13)
  BOTTOM w0.102: v2(244.57,64.3) 244.57,64.89 244.78,65.1 v1(244.78,65.48) 244.78,65.8 244.42,66.16 U46.A15 ; v2(35.43,125.46) 35.31,125.35 U629.54
PBAT_PRES#: length 124.4
  TOP w0.102: v2(208.1,10.22) 208.13,10.2 PD5.1 208.13,8.7 208.58,8.24 210.13,8.24 210.56,8.67 210.56,9.18 PR2.2 ; v2(219.15,53.71) 219.23,53.71 220.88,52.06 222.07,52.06 223.62,50.51 223.62,49.42 225.04,47.99 225.47,47.99 227.25,46.22 228.47,46.22 229.08,45.61 229.08,40.17 228.67,39.76 228.67,37.53 236.09,30.11 236.09,24.96 235.57,24.44 235.57,24.08 v2(234.03,22.54) ; PR3.7 v2(194.41,9.72)
  IN1 w0.109: v2(194.41,9.72) 195.43,10.73 198.09,10.73 198.47,10.35 200.13,10.35 200.89,9.59 207.47,9.59 v2(208.1,10.22)
  IN3 w0.127: v2(219.15,53.71) 219.15,54.29 227.94,63.08 228.32,63.08 229.31,64.08 229.31,66.34 230.57,67.6 232.59,67.6 233.05,68.06 v2(234.32,68.06)
  IN4 w0.109: v2(208.1,10.22) 210.39,12.51 227.94,12.51 232.89,17.46 232.89,21.4 v2(234.03,22.54)
  BOTTOM w0.102: v2(219.15,53.71) 219.05,53.61 v1(219.05,52.93) 219.05,52.41 220.14,51.32 221.77,51.32 222.34,51.89 PU1081.1 ; U46.B40 234.16,67.91 v2(234.32,68.06)
PBAT_SMBCLK: length 84
  TOP w0.102: v2(200.3,12.18) 200.15,12.33 199.31,12.33 198.42,11.44 196.77,11.44 195.28,9.96 195.28,9.63 195.41,9.5 PR3.5 ; v2(247.22,32.98) 247.01,33.19 246.51,33.19 244.97,34.73 244.97,36.59 244.14,37.41 244.14,40.79 243.74,41.19 243.46,41.19 243.13,40.86 v2(243.13,39.94)
  IN1 w0.109: v2(247.22,32.98) 247.06,33.14 246.74,33.14 244.98,31.38 233.46,31.38 231.47,29.39 231.47,23.41 229.26,21.2 220.22,21.2 211.4,12.38 200.51,12.38 v2(200.3,12.18)
  BOTTOM w0.102: U51.A56 243.3,40.5 243.13,40.32 v2(243.13,39.94) ; RP5.7 251.44,33.68 251.3,33.55 251.3,33.35 250.87,32.92 248,32.92 247.71,33.21 247.45,33.21 v2(247.22,32.98)
PBAT_SMBDAT: length 84.7
  TOP w0.102: v2(243,42.81) 243.46,42.36 243.46,41.62 243.66,41.42 243.84,41.42 244.37,40.88 244.37,37.51 245.2,36.68 245.2,34.82 246.61,33.41 247.01,33.41 v2(247.19,33.59) ; v2(200.3,12.81) 200.05,12.56 199.21,12.56 198.32,11.67 196.67,11.67 195.05,10.05 195.05,9.63 194.91,9.5 PR3.6
  IN1 w0.109: v2(200.3,12.81) 200.5,12.62 211.3,12.62 220.12,21.43 229.16,21.43 231.23,23.5 231.23,29.51 233.34,31.62 244.88,31.62 246.64,33.38 246.98,33.38 v2(247.19,33.59)
  BOTTOM w0.102: v2(243,42.81) 243.55,42.26 U51.B59 ; v2(247.19,33.59) 247.34,33.44 247.85,33.44 248.14,33.15 250.78,33.15 251.07,33.44 251.07,33.55 250.94,33.68 RP5.8
PBATT+: length 95.9
  IN1 w0.508: v3(189.2,11.39) 198.09,11.39 198.65,10.83 207.19,10.83 207.31,10.96 212.16,10.96 213.33,12.13 223.52,12.13 232.69,21.3 232.69,24.98 233.27,25.57 266.19,25.57 269.44,28.82 269.44,32.17 268.4,33.21 v3(268.02,33.21)
  BOTTOM w0.508: PR1008.2 v3(268.02,33.21)
  vias: v1(190.56,12.85) v3(187.15,14.03) v3(187.25,13.37) v3(187.25,12.71) v3(187.25,12.08) v3(187.25,11.44) v3(187.91,13.37) v3(187.88,12.69) v3(187.88,12.05) v3(187.88,11.42) v3(188.57,13.37) v3(188.54,12.69) v3(188.54,12.05) v3(188.54,11.42) v3(188.9,10.78) v3(188.92,10.12) v3(189.18,12.66) v3(189.18,12.03)
PBATT+_C:
  vias: v1(191.55,8.6) v3(192.73,9.44) v3(192.89,10.73) v3(192.89,10.1) v3(193.37,9.44) v3(193.52,10.73) v3(193.52,10.1)
PBATT_IN_SS: length 162.7
  TOP w0.508: v2(127.2,86.78) 127.2,86.83 132.21,91.83 132.21,101.44 132.05,101.59 132.05,102.48 133.15,103.57 133.15,113.94 PR1003.1
  IN3 w0.508: v2(127.2,86.78) 127.2,86.75 128.12,85.84 128.12,83.81 124.56,80.25 124.56,72.96 122.27,70.68 121.77,70.68 120.88,69.79 120.88,67.12 122.2,65.8 122.2,52.85 v2(121.87,52.52)
  BOTTOM w0.508: v2(121.87,52.52) 121.87,45.63 121.13,44.9 121.13,38.88 124.23,35.78 163.93,35.78 168.81,40.65 169.85,40.65 170.61,39.89 170.61,29.71 172.19,28.13 184.22,28.13 185.27,27.09
  vias: v1(187.39,26.37)
PCH_ALW_ON: length 273.3
  TOP w0.102: U36.5 71.77,40.36 71.65,40.48 71.65,41.62 72.44,42.41 74.15,42.41 75.29,41.26 79.63,41.26 81.13,39.76 v2(81.13,37.66) ; v2(55.98,67.81) 56.01,67.83 56.01,68.32 55.68,68.64 54.78,68.64 53.73,69.69 53.73,72.09 53.11,72.71 53.11,74.5 52.52,75.1 52.27,75.1 51.84,75.53 51.84,76.06 51.97,76.19 51.97,78.8 51.48,79.28 51.48,79.88 51.79,80.18 51.79,80.98 51.21,81.56 51.21,82.34 51.71,82.85 51.71,84.67 50.29,86.09 v1(48.92,86.09) 45.13,86.09 44.42,85.38 44.42,84.54 PR23.1
  IN1 w0.109: v2(81.13,37.66) 80.19,36.72 69.87,36.72 63.33,43.25 62.65,43.25 61.78,44.12 61.78,45.01 57.53,49.26 57.53,53.76 56.84,54.45 56.84,66.94 v2(55.98,67.81)
  IN3 w0.127: v2(81.13,37.66) 81.13,39 81.28,39.15 94.61,39.15 98.17,35.6 110.95,35.6 111.63,36.28 116.49,36.28 118.1,34.67 122.55,34.67 123.45,35.57 142.39,35.57 145.52,32.45 154.86,32.45 156.93,30.38 174.71,30.38 175.59,31.26 177.3,31.26 179.42,33.37 190.38,33.37 191.98,34.96 194.59,34.96 196.9,37.28 208.59,37.28 218.27,46.95 226.31,46.95 231.06,51.7 240.59,51.7 v2(241.93,53.05)
  BOTTOM w0.102: U51.A23 242.3,52.68 v2(241.93,53.05) 241.93,53.51 242.67,54.25 RP7.7
