# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_MMITX_P8: length 87.4
  TOP w0.102: JIO1.14 20.24,99.3 20.43,99.11 20.58,99.11 v2(20.9,99.43)
  IN1 w0.089: v2(84.3,72.46) 84.22,72.46 84.12,72.56 84.12,72.66 84.33,72.86 84.5,72.86 84.68,73.03 84.78,73.03 84.81,73.01 84.83,73.01
  IN1 w0.117: 84.83,73.01 85.07,73.01 85.16,72.91 85.56,72.91 85.66,73.01 85.94,73.01 86.23,73.29 86.38,73.29 86.65,73.56 86.65,73.71 87.43,74.49 87.43,77 87.26,77.17 87.26,77.94 86.71,78.48 86.71,81.22 79.88,88.06 77.54,88.06 71.25,94.35 62.89,94.35 59.39,97.85 33.12,97.85 31.84,99.13 23.84,99.13 23.72,99.25 21.08,99.25 v2(20.9,99.43)
  BOTTOM w0.089: UH1.AN39 83.91,72.07 v2(84.3,72.46)
PCIE_PRX_WANTX_N5: length 226.8
  IN3 w0.127: v2(94.72,82) 94.51,81.8 93.29,81.8 93.02,82.08 89.2,82.08 87.12,80 87.12,77.51 86.4,76.78 84.39,76.78 83.31,75.7 83.31,74.82 83.13,74.64 83.03,74.64 v2(82.88,74.79)
  IN4 w0.117: v2(94.72,82) 94.86,81.86 95.88,81.86 99.42,78.31 99.42,70.29 103.4,66.31 103.4,64.22 105.46,62.17 108.97,62.17 113.19,57.95 113.19,56.88 114.7,55.37 115.92,55.37 118.61,52.68 119.87,52.68 121.74,50.81 191.74,50.81 196.72,55.79 228.37,55.79 228.6,56.03 233.58,56.03 234.01,56.45 241.22,56.45 241.71,56.94 245.71,56.94 246.73,57.96 246.84,57.96 248.06,59.18 249.1,59.18 249.44,59.52 249.44,59.95 253.05,63.56 263.45,63.56 265.45,61.57 265.82,61.57 v2(266.04,61.79)
  BOTTOM w0.089: v2(82.88,74.79) 82.62,74.54 UH1.AW36
  BOTTOM w0.102: JMINI1.23 268.73,53 268.44,52.71 268.08,52.71 267.61,53.18 267.61,58.87 266.7,59.78 266.7,61.3 266.44,61.56 266.27,61.56 v2(266.04,61.79)
PCIE_PRX_WANTX_P5: length 226.8
  IN3 w0.127: v2(82.85,74.18) 83.06,74.39 83.24,74.39 83.56,74.71 83.56,75.6 84.5,76.54 86.5,76.54 87.37,77.4 87.37,79.89 89.31,81.83 92.91,81.83 93.19,81.55 94.58,81.55 v2(94.72,81.42)
  IN4 w0.117: v2(266.04,61.18) 265.89,61.33 265.35,61.33 263.35,63.33 253.15,63.33 249.68,59.86 249.68,59.42 249.2,58.94 248.16,58.94 246.94,57.72 246.83,57.72 245.81,56.71 241.81,56.71 241.32,56.22 234.11,56.22 233.68,55.79 228.7,55.79 228.46,55.56 196.82,55.56 191.84,50.58 121.64,50.58 119.77,52.45 118.51,52.45 115.83,55.13 114.6,55.13 112.95,56.78 112.95,57.85 108.87,61.93 105.36,61.93 103.17,64.13 103.17,66.21 99.19,70.19 99.19,78.22 95.78,81.62 94.92,81.62 v2(94.72,81.42)
  BOTTOM w0.089: v2(82.85,74.18) 82.85,74.1 82.69,73.94 UH1.AV36
  BOTTOM w0.102: JMINI1.25 268.74,52.2 268.45,52.49 267.99,52.49 267.4,53.09 267.4,58.78 266.48,59.69 266.48,61.21 266.36,61.34 266.2,61.34 v2(266.04,61.18)
PCIE_PRX_WLANTX_N3: length 153.1
  IN4 w0.117: v2(122.81,169.89) 122.93,169.76 122.93,169.64 122.7,169.41 122.6,169.41 120.5,169.41 116.97,172.94 113.16,172.94 112.85,172.63 108.41,172.63 107.22,171.45 106.63,171.45 103.61,168.42 98.44,168.42 97.07,169.79 91.31,169.79 90.73,170.38 85.35,170.38 83.56,168.59 83.56,166.72 80.22,163.37 79.81,163.37 75.96,159.52 75.96,156.78 72.91,153.73 72.91,148.55 72.38,148.02 72.38,139.77 72.91,139.24 72.91,137.98 72.11,137.17 72.11,119.8 80.38,111.52 80.38,105.5 83.87,102.02 83.87,89.91 80.92,86.95 80.92,76.9 81.18,76.64 81.18,75.32 v2(81.84,74.66)
  BOTTOM w0.102: JMINI2.23 122.69,168.97 123.01,169.29 123.01,169.69 v2(122.81,169.89) ; UH1.AW33 81.71,74.54 v2(81.84,74.66)
PCIE_PRX_WLANTX_P3: length 153.1
  IN4 w0.117: v2(123.39,169.89) 123.17,169.67 123.17,169.54 122.8,169.17 122.51,169.17 120.4,169.17 116.87,172.7 113.26,172.7 112.95,172.4 108.5,172.4 107.32,171.21 106.73,171.21 103.71,168.19 98.34,168.19 96.97,169.56 91.21,169.56 90.63,170.14 85.45,170.14 83.8,168.49 83.8,166.62 80.31,163.13 79.91,163.13 76.2,159.42 76.2,156.68 73.15,153.63 73.15,148.45 72.62,147.92 72.62,139.87 73.15,139.34 73.15,137.88 72.35,137.08 72.35,119.89 80.62,111.62 80.62,105.6 84.11,102.11 84.11,89.81 81.15,86.86 81.15,77 81.41,76.74 81.41,75.75 81.51,75.65 81.61,75.65 81.79,75.83 81.91,75.83 82.02,75.73 82.02,75.38 81.91,75.27 v2(81.84,75.27)
  BOTTOM w0.102: v2(123.39,169.89) 123.22,169.72 123.22,169.29 123.49,169.02 JMINI2.25 ; v2(81.84,75.27) 81.79,75.27 81.65,75.13 UH1.AY33
PCIE_PRX_WPANTX_N6: length 71.9
  TOP w0.102: v2(82.35,37.81) 82.54,38 82.66,38 82.89,38.23 83.08,38.42 83.08,39.41 83.23,39.56 90.38,46.71 90.38,50.95 94.91,55.47 94.91,57.02 94.63,57.3 94.63,65.1 92.94,66.79 92.94,72.33 91.22,74.04 84.7,74.04 84.28,74.46 84.28,74.58 84.2,74.65 v2(84.2,74.89)
  BOTTOM w0.089: v2(84.2,74.89) 84.2,74.92 84.1,75.02 83.41,75.02 UH1.AY38
  BOTTOM w0.102: JMINI3.23 78.54,21.17 78.15,21.55 78.15,23.76 81.24,26.85 81.24,36.78 81.76,37.3 81.76,37.94 82.03,38.2 82.16,38.2 82.35,38.01 v2(82.35,37.81)
PCIE_PRX_WPANTX_P6: length 71.8
  TOP w0.102: v2(83.87,74.41) 84.02,74.41 84.61,73.83 91.13,73.83 92.72,72.24 92.72,66.7 94.41,65.01 94.41,57.21 94.69,56.93 94.69,55.56 90.17,51.04 90.17,46.8 84.07,40.7 84.04,40.67 83.91,40.67 83.67,40.43 83.67,40.38 83.67,40.3 83.45,40.08 83.33,40.08 83.08,39.84 83.08,39.79 83.08,39.71 82.87,39.5 82.87,38.51 82.74,38.38 82.57,38.21 82.35,38.21 82.19,38.37 82.19,38.49 82.27,38.57 v2(82.35,38.57)
  BOTTOM w0.089: UH1.AW38 83.58,74.82 83.77,74.82 83.87,74.71 v2(83.87,74.41)
  BOTTOM w0.102: JMINI3.25 77.74,21.34 77.94,21.54 77.94,23.85 81.02,26.94 81.02,36.87 81.55,37.39 81.55,38.03 81.94,38.42 82.19,38.42 v2(82.35,38.57)
PCIE_PTX_EXPRX_N7: length 89.8
  TOP w0.102: v2(23.85,85.84) 24.14,85.54 24.14,85.07 23.82,84.75 23.7,84.75 23.46,84.51 23.46,84.38 23.24,84.17 23.12,84.17 22.87,83.93 22.87,83.8 21.32,82.25 20.33,82.25 20.21,82.37 20.21,82.37 20.09,82.5 19.34,82.5 JIO1.70
  IN1 w0.117: v2(23.85,85.84) 24.02,86.01 24.02,86.53 23.03,87.52 23.03,90.18 23.49,90.64 23.49,94.65 24.91,96.08 29.59,96.08 30.55,95.12 39.9,95.12 40.18,94.84 46.54,94.84 47.77,96.08 58.9,96.08 62.6,92.38 67.13,92.38 71.05,88.46 74.93,88.46 83.46,79.92 83.46,79.21 83.8,78.88 84.53,78.88 v2(84.56,78.91)
  BOTTOM w0.102: UH1.BE40 84.05,77.05 83.98,76.98 83.84,76.98 83.74,77.08 83.74,77.28 83.83,77.37 83.96,77.37 84.02,77.43 84.02,77.53 83.77,77.79 83.77,78.22 84.01,78.46 84.26,78.46 84.56,78.75 v2(84.56,78.91)
PCIE_PTX_EXPRX_P7: length 89.8
  TOP w0.102: JIO1.72 19.34,81.89 20.21,81.89 20.21,81.9 20.34,82.03 21.41,82.03 24,84.62 24.36,84.98 24.36,85.77 v2(24.43,85.84)
  IN1 w0.117: v2(24.43,85.84) 24.26,86.01 24.26,86.63 23.27,87.62 23.27,90.08 23.72,90.54 23.72,94.55 25.01,95.84 29.5,95.84 30.45,94.88 39.8,94.88 40.08,94.6 46.63,94.6 47.87,95.84 58.8,95.84 62.5,92.14 67.03,92.14 70.95,88.22 74.83,88.22 83.23,79.82 83.23,79.12 83.7,78.64 84.21,78.64 84.56,78.3 v2(84.56,78.19)
  BOTTOM w0.102: UH1.BC40 84.03,76.53 84.38,76.87 84.38,77.48 83.98,77.88 83.98,78.13 84.1,78.25 84.5,78.25 v2(84.56,78.19)
PCIE_PTX_GLANRX_N2: length 39
  TOP w0.102: C461.1 112.18,85.4 112.18,84.99 v2(112.47,84.7)
  IN3 w0.127: v2(81.66,78.7) 82.37,78.7 82.9,79.24 82.9,80.15 86.82,84.06 97.99,84.06 98.34,84.41 102.32,84.41 102.7,84.79 106.55,84.79 107.42,85.66 108.51,85.66 108.69,85.83 111.79,85.83 112.37,85.25 112.37,84.8 v2(112.47,84.7)
  BOTTOM w0.089: v2(81.66,78.7) 81.28,78.32 81.28,77.92 81.08,77.71 81.08,76.93 80.9,76.75 80.9,76.62 80.97,76.54 81.1,76.54 UH1.BD33
PCIE_PTX_GLANRX_N2_C: length 2.9
  TOP w0.102: U31.42 111.53,88.39 111.44,88.3 111.44,87.74 112.15,87.03 112.15,86.74 112.27,86.63 C461.2
PCIE_PTX_GLANRX_P2: length 39
  TOP w0.102: v2(111.76,84.7) 111.96,84.9 111.96,85.36 C460.1
  IN3 w0.127: v2(111.76,84.7) 111.96,84.7 112.05,84.79 112.05,84.87 112.12,84.94 112.12,85.15 111.68,85.59 108.79,85.59 108.62,85.41 107.52,85.41 106.65,84.54 102.8,84.54 102.42,84.16 98.45,84.16 98.1,83.81 86.92,83.81 83.15,80.05 83.15,79.13 82.47,78.45 81.97,78.45 81.82,78.31 81.75,78.31 81.66,78.22 v2(81.66,78.12)
  BOTTOM w0.089: v2(81.66,78.12) 81.48,77.94 81.48,77.83 81.28,77.63 81.28,76.95 81.47,76.75 81.47,76.51 81.19,76.23 81.19,75.74 UH1.BB33
PCIE_PTX_GLANRX_P2_C: length 2.9
  TOP w0.102: U31.41 111.13,88.39 111.23,88.3 111.23,87.65 111.94,86.94 111.94,86.7 111.86,86.63 C460.2
PCIE_PTX_MMIRX_N8: length 79.8
  TOP w0.102: JIO1.22 20.15,96.9 20.39,97.14 22.88,97.14 25.18,94.84 25.18,94.54 24.99,94.35 v2(24.71,94.35)
  IN1 w0.117: v2(24.71,94.35) 24.89,94.53 24.89,94.93 25.17,95.21 27.53,95.21 27.91,94.84 29.15,94.84 30.09,93.9 46.79,93.9 47.57,94.68 59.1,94.68 62.38,91.4 66.01,91.4 70.96,86.46 75.84,86.46 81.18,81.12 81.18,77.99 82.42,76.75 83.7,76.75 84.32,76.12 84.5,76.12 84.61,76.01 84.72,76.01 v2(84.8,76.1)
  BOTTOM w0.089: UH1.BD42 85.29,76.33 85.29,76.24 85.15,76.1 84.8,76.1 v2(84.8,76.1)
PCIE_PTX_MMIRX_P8: length 79.8
  TOP w0.102: v2(25.54,94.35) 25.4,94.49 25.4,94.93 22.97,97.36 20.35,97.36 20.21,97.5 JIO1.20
  IN1 w0.117: v2(25.54,94.35) 25.54,94.24 25.42,94.12 25.25,94.12 25.13,94.24 25.13,94.83 25.27,94.98 25.61,94.98 25.7,94.88 26.1,94.88 26.2,94.98 26.55,94.98 26.64,94.88 27.04,94.88 27.14,94.98 27.43,94.98 27.81,94.6 29.06,94.6 30,93.66 46.89,93.66 47.67,94.44 59.01,94.44 62.28,91.17 65.92,91.17 70.86,86.22 75.74,86.22 80.94,81.02 80.94,77.89 82.32,76.51 83.6,76.51 84.33,75.78 v2(84.33,75.71)
  BOTTOM w0.089: UH1.BD41 84.37,76.41 84.37,75.75 v2(84.33,75.71)
PCIE_PTX_WANRX_N5: length 237.3
  IN4 w0.117: v2(271.87,61.28) 272.08,61.07 272.08,60.92 271.91,60.75 268.18,60.75 267.46,60.03 265.79,60.03 264.18,61.64 262.07,61.64 260.89,62.83 253.39,62.83 250.18,59.62 250.18,59.17 249.25,58.24 248.85,58.24 247.8,57.2 247.02,57.2 246.03,56.21 242.7,56.21 241.75,55.26 234.49,55.26 234.39,55.16 229.26,55.16 228.67,54.57 196.95,54.57 192.3,49.92 118.11,49.92 111.13,56.91 111.13,58.25 108.71,60.67 105.38,60.67 98.61,67.44 98.61,77.7 97.35,78.97 97.35,79.09 97.05,79.39 96.92,79.39 96.66,79.65 96.17,79.65 96.08,79.74 95.68,79.74 95.58,79.65 94.86,79.65 94.77,79.74 v2(94.77,80.02)
  BOTTOM w0.102: C597.1 272.97,49.54 273.06,49.45 273.47,49.45 273.7,49.68 273.7,58.22 272.2,59.72 272.2,60.95 v2(271.87,61.28) ; UH1.BD37 82.84,76.57 82.84,76.5 82.69,76.35 82.63,76.35 82.41,76.58 82.41,76.65 82.7,76.95 82.7,77.2 82.7,77.2 82.7,77.41 82.8,77.51 82.8,77.62 82.71,77.71 82.71,77.92 82.8,78 82.8,79.64 83.4,80.24 83.4,80.8 85.79,83.19 90.59,83.19 93.97,79.81 94.55,79.81 v2(94.77,80.02)
PCIE_PTX_WANRX_N5_C: length 2.6
  BOTTOM w0.102: C597.2 271.72,49.51 271.13,49.51 270.84,49.8 JMINI1.31
PCIE_PTX_WANRX_P5: length 237.3
  IN4 w0.117: v2(94.77,79.19) 94.99,79.41 96.57,79.41 98.37,77.61 98.37,67.34 105.29,60.43 108.61,60.43 110.9,58.15 110.9,56.81 118.01,49.69 192.4,49.69 197.05,54.34 228.77,54.34 229.36,54.93 234.49,54.93 234.59,55.02 241.85,55.02 242.8,55.97 246.12,55.97 247.12,56.96 247.9,56.96 248.94,58 249.35,58 250.42,59.07 250.42,59.53 253.48,62.59 260.79,62.59 261.97,61.41 264.08,61.41 265.69,59.8 267.56,59.8 268.28,60.52 272.01,60.52 272.32,60.82 272.32,61.14 v2(272.46,61.28)
  BOTTOM w0.102: C599.1 273.25,49.24 273.56,49.24 273.91,49.59 273.91,58.31 272.41,59.81 272.41,61.23 v2(272.46,61.28) ; UH1.BB37 82.82,76.17 83.1,76.45 83.1,76.76 82.93,76.92 82.93,77.33 83.02,77.42 83.02,79.55 83.62,80.15 83.62,80.71 85.88,82.97 90.5,82.97 93.88,79.59 94.68,79.59 94.77,79.5 v2(94.77,79.19)
PCIE_PTX_WANRX_P5_C: length 2.6
  BOTTOM w0.102: JMINI1.33 270.84,49 271.13,49.29 271.72,49.29 C599.2
PCIE_PTX_WLANRX_N3: length 125.4
  IN4 w0.117: v2(95.88,86.2) 95.99,86.2 96.26,86.47 96.26,86.61 96.18,86.68 96.18,87.48 96.41,87.71 96.41,87.86 96.68,88.13 96.83,88.13 97.08,88.38 97.08,88.54 97.35,88.81 97.51,88.81 103.71,95.01 105.81,95.01 109.59,98.79 109.59,100.33 111.71,102.45 111.71,102.81 112.91,104.01 113.29,104.01 114.98,105.69 114.98,118.69 114.42,119.24 114.42,121.23 113.96,121.68 113.96,123.38 114.15,123.56 114.15,130.7 115.24,131.79 115.24,135.19 115.78,135.74 115.78,138.33 118.13,140.67 118.13,147.26 117.52,147.87 117.52,153.58 118.56,154.62 118.56,157.67 119.18,158.29 119.18,163.17 125.01,169 125.01,170.12 124.82,170.31 124.63,170.31 v2(124.38,170.07)
  BOTTOM w0.102: v2(95.88,86.2) 96.16,85.92 96.16,85.66 96.07,85.57 96.01,85.51 94.54,84.04 85.04,84.04 82.4,81.39 82.4,78.26 82.15,78.02 82.15,77.57 81.89,77.31 81.81,77.31 81.76,77.36 81.76,77.57 81.7,77.64 81.56,77.64 81.47,77.55 81.47,77.14 81.54,77.07 UH1.BE34 ; v2(124.38,170.07) 124.38,170.09 124.59,170.29 124.87,170.29 125.08,170.51 125.08,171.04 125.62,171.58 126.05,171.58 126.26,171.36 126.26,171.06 126.16,170.96 C596.1
PCIE_PTX_WLANRX_N3_C: length 2.3
  BOTTOM w0.102: JMINI2.31 125.89,169.02 126.18,169.32 126.18,169.69 C596.2
PCIE_PTX_WLANRX_P3: length 125.4
  IN4 w0.117: v2(96.57,86.2) 96.49,86.27 96.49,86.7 96.42,86.78 96.42,87.39 103.8,94.77 105.91,94.77 109.83,98.69 109.83,100.23 111.94,102.35 111.94,102.71 113,103.77 113.39,103.77 115.21,105.6 115.21,118.78 114.65,119.34 114.65,121.32 114.2,121.78 114.2,123.28 114.38,123.46 114.38,130.6 115.47,131.69 115.47,135.09 116.02,135.64 116.02,138.23 118.36,140.57 118.36,147.36 117.75,147.97 117.75,153.48 118.79,154.52 118.79,157.57 119.42,158.19 119.42,163.07 125.25,168.9 125.25,170.22 124.92,170.55 124.48,170.55 v2(124.38,170.65)
  BOTTOM w0.102: v2(124.38,170.65) 124.52,170.51 124.78,170.51 124.87,170.6 124.87,171.13 125.53,171.79 126.14,171.79 126.48,171.45 126.48,171.2 C598.1 ; UH1.BC34 81.67,76.24 81.67,76.7 82.12,77.15 82.12,77.23 82.37,77.48 82.37,77.93 82.61,78.17 82.61,81.31 85.13,83.82 94.63,83.82 96.16,85.36 96.23,85.42 96.38,85.57 96.38,86 v2(96.57,86.2)
PCIE_PTX_WLANRX_P3_C: length 2.3
  BOTTOM w0.102: C598.2 126.4,169.72 126.4,169.32 126.69,169.02 JMINI2.33
PCIE_PTX_WPANRX_N6: length 89.5
  TOP w0.102: v2(84.3,79.44) 84.57,79.71 84.75,79.71 84.8,79.65 85.71,79.65 88.09,77.28 90.88,77.28 93.48,74.68 93.48,67.16 95.12,65.52 95.12,57.49 95.39,57.23 95.39,55.25 91.05,50.9 91.05,46.43 85.83,41.22 85.7,41.22 85.46,40.98 85.46,40.85 85.25,40.63 85.12,40.63 84.88,40.39 84.88,40.26 84.64,40.03 84.64,38.66 84.25,38.27 v2(84.2,38.27)
  BOTTOM w0.102: UH1.BC38 83.31,76.25 83.31,76.72 83.55,76.96 83.55,77.4 83.48,77.47 83.48,79.02 83.92,79.46 83.96,79.5 84.24,79.5 v2(84.3,79.44) ; C636.1 75.23,17.18 75.06,17.18 74.98,17.11 74.98,16.57 75.23,16.33 75.35,16.33 75.59,16.09 75.59,15.96 76.03,15.52 81.27,15.52 82.78,17.03 82.78,30.51 83.3,31.03 83.3,35.1 84.43,36.23 84.43,38.04 v2(84.2,38.27)
PCIE_PTX_WPANRX_N6_C: length 2.7
  BOTTOM w0.102: JMINI3.31 75.34,19.35 75.05,19.06 75.05,18.28 C636.2
PCIE_PTX_WPANRX_P6: length 89.5
  TOP w0.102: v2(84.3,80.18) 84.56,79.92 84.83,79.92 84.89,79.87 85.8,79.87 88.18,77.5 90.97,77.5 93.7,74.77 93.7,67.25 95.34,65.61 95.34,57.58 95.6,57.32 95.6,55.16 91.26,50.81 91.26,46.34 84.86,39.94 84.86,38.29 v2(84.83,38.27)
  BOTTOM w0.102: C626.1 74.76,16.76 74.76,16.48 75.94,15.3 81.36,15.3 82.99,16.94 82.99,30.42 83.51,30.94 83.51,35.01 84.64,36.14 84.64,38.08 v2(84.83,38.27) ; UH1.BE38 83.33,77.18 83.33,77.31 83.26,77.38 83.26,79.11 83.44,79.29 83.44,79.41 83.55,79.52 83.68,79.66 83.81,79.66 83.97,79.82 84.3,79.82 84.43,79.95 84.43,80.05 v2(84.3,80.18)
PCIE_PTX_WPANRX_P6_C: length 2.7
  BOTTOM w0.102: C626.2 74.83,18.23 74.83,19.06 74.54,19.35 JMINI3.33
PCIE_WAKE#: length 579.2
  TOP w0.102: v2(39.93,146.09) 40.23,146.39 40.23,146.8 41.4,147.97 R1972.2 ; JIO1.52 v2(17.98,87.9)
  IN3 w0.127: v2(268.04,61.74) 268.04,59.91 262.03,53.89 258.11,53.89 256.59,52.36 v2(255.17,52.36) 254.18,51.37 251.03,51.37 250.29,50.63 249.32,50.63 247.22,48.53 v2(246.98,48.53)
  IN4 w0.109: v2(255.17,52.36) 256.16,52.36 257,51.52 257,49.29 254.45,46.74 254.45,43.2 255.38,42.27 255.38,39.38 254.63,38.63 254.63,36.61 254.13,36.11 254.13,34.39 251.66,31.93 250.29,31.93 250.06,32.16 248.25,32.16 247.81,31.73 245.93,31.73 245.35,31.15 234.1,31.15 233.96,31.29 231.21,31.29 230.64,31.86 224.96,31.86 217.81,39.01 210.43,39.01 209.24,37.81 206.18,37.81 204.77,36.41 201.35,36.41 200.47,35.54 194.42,35.54 191.02,32.13 121.71,32.13 121.5,32.33 109.52,32.33 109.1,32.75 101.88,32.75 101.54,32.41 98.11,32.41 96.01,30.32 v2(93.72,30.32) 93.22,30.32 91.98,31.55 80.14,31.55 79.53,32.16 75.03,32.16 74.64,32.55 67.1,32.55 66.18,33.47 60.61,33.47 56.59,37.49 55.16,37.49 51.3,41.35 51.03,41.35 47.21,45.17 47.21,49.99 45.78,51.42 38.33,51.42 34.56,55.19 34.56,61.56 30.22,65.9 29.18,65.9 29.04,66.04 26.25,66.04 24.4,67.89 22.49,67.89 21.86,67.26 19.24,67.26 14.7,71.81 9.99,71.81 7.52,74.28 7.52,81.25 8.69,82.41 8.69,94.63 7.26,96.05 7.26,99.67 6.31,100.62 6.31,113.87 v2(6.55,114.11) 6.32,114.34 6.32,130.06 8.16,131.89 8.16,137.01 12.65,141.5 12.65,141.94 14.33,143.62 21.99,143.62 22.17,143.8 37.32,143.8 39.61,146.09 v2(39.93,146.09) 41.43,144.59 68.56,144.59 71.29,147.32 71.29,153.1 75.26,157.07 75.26,166.86 79.51,171.12 90.99,171.12 91.6,170.5 97.36,170.5 97.71,170.15 103.21,170.15 v2(104.93,171.87)
  BOTTOM w0.102: JMINI2.1 110.69,168.44 110.21,168.92 109.88,168.92 109.23,169.57 107.22,169.57 v2(104.93,171.87) ; JMINI1.1 268.8,65 268.04,64.25 v2(268.04,61.74) ; U51.B38 247.41,48.67 247.27,48.53 v2(246.98,48.53) ; v2(6.55,114.11) 8.05,114.11 14.45,107.71 14.45,94.43 v1(14.77,94.11) 16.23,92.65 16.23,90.89 17.5,89.62 17.5,88.46 17.98,87.97 v2(17.98,87.9) ; v2(93.72,30.32) 92.85,29.44 92.85,23.89 90.54,21.58 JMINI3.1 ; R759.2 254,52.36 v2(255.17,52.36)
PCLK_80H: length 211.3
  TOP w0.102: v2(81.66,36.53) 81.66,39.42 83.7,41.46 83.7,47.41 84.38,48.1 84.38,49.87 85.85,51.34 85.85,52.77 86.71,53.63 86.71,54.55 RH159.1
  IN4 w0.109: v2(81.66,36.53) 81.25,36.12 77.37,36.12 76.1,37.39 61.94,37.39 51.52,47.8 51.52,52.75 47.71,56.57 47.71,61.32 44.06,64.96 44.06,65.93 41.6,68.39 40,68.39 38.58,69.8 37.79,69.8 36.68,70.92 29.66,70.92 28.85,70.11 26.76,70.11 26.58,70.29 22.84,70.29 22.64,70.49 20.88,70.49 15.64,75.73 15.64,78.39 15.89,78.64 15.89,80.02 17.11,81.23 17.11,82.13 17.87,82.89 17.87,83.96 16.97,84.86 15.35,84.86 13.1,87.11 13.1,91.14 7.75,96.48 7.75,99.87 6.8,100.83 6.8,113.08 7.04,113.32 7.04,114.98 7.52,115.46 7.52,130.57 8.65,131.69 8.65,136.8 13.14,141.29 13.14,141.73 14.54,143.13 16.72,143.13 v2(17.12,142.74)
  BOTTOM w0.102: v2(17.12,142.74) v1(17.12,143.85) 17.12,151.35 17.35,151.59 17.57,151.81 18.02,152.25 18.68,152.91 18.68,153.96 17.65,154.99 17.65,158.78 18.41,159.54 19.63,159.54 20.04,159.13 JMINI4.19
PECI_EC: length 155.3
  TOP w0.102: JCPU1.AR27 v2(196.06,131.31)
  IN3 w0.102: v2(224.23,84.8) 225.23,83.8 241.94,83.8 242.83,82.92 248.87,82.92 252.31,79.48 259.17,79.48 261.29,77.36 262.2,77.36 264.59,74.97 265.45,74.97 266.24,74.18 266.24,69.46 269.7,66 269.7,52.97 261.9,45.17 261.9,40.17 v2(261.42,39.69)
  IN4 w0.102: v2(196.06,131.31) 198.37,128.99 198.55,128.99 200.76,126.78 200.76,118.8 206.72,112.84 206.88,112.84 207.67,112.05 207.67,111.89 208.84,110.72 208.84,106.03 207.36,104.55 207.36,102.5 206.48,101.61 206.48,97.78 210.64,93.62 210.64,90.46 216.29,84.8 v2(224.23,84.8)
  BOTTOM w0.102: v2(261.42,39.69) 260.42,39.69 260.17,39.94 R952.2
PECI_EC_R: length 10.4
  BOTTOM w0.102: R952.1 256.56,39.82 v1(253.8,39.82) 252.65,40.96 252.07,40.96 251.36,41.67 C292.1 250.67,41.16 249.4,41.16 248.92,41.64 248.92,42.3 248.81,42.42 U51.A48
PEG_B_CLKRQ#: length 7.3
  BOTTOM w0.076: 66.55,65.22 66.72,65.22 66.93,65.42 67.94,65.42 68.15,65.62 68.4,65.62 68.65,65.37 69.1,65.37 UH1.U4
  BOTTOM w0.102: 66.55,65.22 65.57,65.22 65.51,65.27 63.63,65.27 63.45,65.09 v1(63.23,65.09) RH130.2
PEG_COMP: length 4.8
  TOP w0.305: JCPU1.E23 165.59,126.83 v2(166.04,126.38)
  BOTTOM w0.508: v2(166.04,126.38) 166.04,126.4 166.06,126.38 v2(166.04,126.38) ; v2(166.04,126.38) 165.94,126.28 165.94,125.46 166.64,124.75 166.64,124.31 v1(166.85,124.1) 167.78,124.1 RC2.2
PEG_CRX_GTX_C_N0: length 6
  TOP w0.109: JMXM1.177 77.69,135.95 77.83,135.81 77.83,135.28 v2(77.65,135.09)
  BOTTOM w0.109: v2(77.65,135.09) 77.82,135.27 77.82,136.34 77.78,136.39 77.78,137.34 77.76,137.36 77.76,137.92 77.78,137.94 77.78,138.71 CC1.1
PEG_CRX_GTX_C_N1: length 3.6
  TOP w0.109: JMXM1.171 76.19,135.94 76.33,135.79 76.33,135.17 v2(76.15,134.98)
  BOTTOM w0.109: v2(76.15,134.98) 76.29,135.12 76.29,135.71 76.39,135.8 76.39,136.17 CC2.1
PEG_CRX_GTX_C_N2: length 6.1
  TOP w0.109: JMXM1.165 74.69,135.8 74.89,135.61 74.89,135.18 v2(74.72,135.02)
  BOTTOM w0.109: CC3.1 74.86,138.71 74.86,137.51 74.84,137.49 74.84,136.93 74.86,136.91 74.86,136.29 74.9,136.25 74.9,135.2 v2(74.72,135.02)
PEG_CRX_GTX_C_N3: length 3.6
  TOP w0.109: v2(71.07,134.99) 71.31,135.23 71.31,135.68 71.19,135.8 JMXM1.157
  BOTTOM w0.109: v2(71.07,134.99) 71.28,135.2 71.28,136.2 CC4.1
PEG_CRX_GTX_C_N4: length 6.1
  TOP w0.109: JMXM1.151 69.69,135.8 69.83,135.66 69.83,135.28 v2(69.65,135.09)
  BOTTOM w0.109: CC5.1 69.91,138.84 69.91,138.13 69.83,138.05 69.83,137.36 69.81,137.34 69.81,136.78 69.83,136.76 69.83,135.28 v2(69.65,135.09)
PEG_CRX_GTX_C_N5: length 3.6
  TOP w0.109: v2(68.15,135) 68.33,135.19 68.33,135.66 68.19,135.8 JMXM1.145
  BOTTOM w0.109: CC6.1 68.38,136.17 68.38,135.62 68.32,135.56 68.32,135.18 v2(68.15,135)
PEG_CRX_GTX_C_N6: length 6.1
  TOP w0.109: v2(66.65,135.09) 66.83,135.28 66.83,135.66 66.69,135.8 JMXM1.139
  BOTTOM w0.109: v2(66.65,135.09) 66.82,135.26 66.82,135.74 66.86,135.79 66.86,136.74 66.84,136.77 66.84,137.33 66.86,137.35 66.86,138.84 CC7.1
PEG_CRX_GTX_C_N7: length 3.6
  TOP w0.109: v2(65.15,135) 65.33,135.19 65.33,135.66 65.19,135.8 JMXM1.133
  BOTTOM w0.109: v2(65.15,135) 65.34,135.19 65.34,136.17 CC8.1
PEG_CRX_GTX_C_N8: length 5
  TOP w0.109: v2(63.61,140.73) 63.83,140.51 63.83,137.59 63.69,137.45 JMXM1.127
  BOTTOM w0.109: v2(63.61,140.73) 63.81,140.53 63.81,140.43 CC9.1
PEG_CRX_GTX_C_N9: length 2.9
  TOP w0.109: v2(62.1,138.32) 62.26,138.16 62.26,137.81 62.33,137.73 62.33,137.54 62.19,137.4 JMXM1.121
  BOTTOM w0.109: CC10.1 62.29,137.77 62.29,138.13 v2(62.1,138.32)
PEG_CRX_GTX_C_N10: length 8.1
  TOP w0.109: JMXM1.115 60.69,139.35 59.43,140.61 59.43,141.15 59.7,141.42 60.1,141.42 v2(60.22,141.54)
  BOTTOM w0.109: CC11.1 61.04,140.37 61.04,141.18 60.76,141.47 60.3,141.47 v2(60.22,141.54)
PEG_CRX_GTX_C_N11: length 5.4
  TOP w0.109: JMXM1.109 59.19,137.49 59.31,137.61 59.52,137.61 59.71,137.8 59.71,138.73 59.63,138.82 59.45,138.82 59.33,138.7 59.26,138.7 59.16,138.6 v2(59.16,138.54)
  BOTTOM w0.109: v2(59.16,138.54) 59.16,138.6 59.26,138.7 59.33,138.7 59.4,138.77 59.5,138.77 59.61,138.65 59.61,138.13 59.43,137.95 59.43,137.5 59.36,137.43 CC12.1
PEG_CRX_GTX_C_N12: length 6.1
  TOP w0.109: JMXM1.103 57.69,135.96 57.83,135.82 57.83,135.28 v2(57.65,135.09)
  BOTTOM w0.109: CC13.1 57.84,138.84 57.84,137.35 57.82,137.33 57.82,136.77 57.84,136.74 57.84,135.83 57.83,135.82 57.83,135.28 v2(57.65,135.09)
PEG_CRX_GTX_C_N13: length 3.4
  TOP w0.109: v2(56.13,135.11) 56.36,135.34 56.36,135.84 56.19,136.01 JMXM1.97
  BOTTOM w0.109: CC14.1 56.32,136.17 56.32,135.28 56.13,135.09 v2(56.13,135.11)
PEG_CRX_GTX_C_N14: length 6.1
  TOP w0.109: JMXM1.91 54.69,135.99 54.82,135.86 54.82,135.27 v2(54.65,135.09)
  BOTTOM w0.109: CC15.1 54.67,138.84 54.67,138.52 54.83,138.35 54.83,137.32 54.81,137.3 54.81,136.74 54.83,136.72 54.83,135.28 v2(54.65,135.09)
PEG_CRX_GTX_C_N15: length 15.8
  TOP w0.109: JMXM1.85 53.19,135.97 53.28,135.88 53.28,135.31 v2(53.11,135.14)
  BOTTOM w0.109: CC16.1 65.76,133.2 65.14,133.2 64.91,133.43 57.12,133.43 57.1,133.41 56.54,133.41 56.52,133.43 54.29,133.43 53.21,134.51 53.21,135.04 v2(53.11,135.14)
PEG_CRX_GTX_C_P0: length 5.9
  TOP w0.109: v2(78.23,135.09) 78.05,135.28 78.05,135.81 78.19,135.95 JMXM1.179
  BOTTOM w0.109: CC17.1 77.99,138.71 v3(77.99,137.64) 77.99,136.47 78.03,136.43 78.03,135.29 v2(78.23,135.09)
PEG_CRX_GTX_C_P1: length 3.7
  TOP w0.109: JMXM1.173 76.69,135.94 76.55,135.79 76.55,135.16 v2(76.73,134.98)
  BOTTOM w0.109: CC18.1 76.6,136.17 76.6,135.71 76.5,135.62 76.5,135.19 76.71,134.98 v2(76.73,134.98)
PEG_CRX_GTX_C_P2: length 6.1
  TOP w0.109: v2(75.31,135.02) 75.1,135.23 75.1,135.71 75.19,135.8 JMXM1.167
  BOTTOM w0.109: v2(75.31,135.02) 75.11,135.21 75.11,136.34 75.07,136.38 v3(75.07,137.21) 75.07,138.71 CC19.1
PEG_CRX_GTX_C_P3: length 3.6
  TOP w0.109: JMXM1.159 71.69,135.8 71.52,135.63 71.52,135.13 v2(71.66,134.99)
  BOTTOM w0.109: CC20.1 71.49,136.15 71.49,135.16 v2(71.66,134.99)
PEG_CRX_GTX_C_P4: length 6.1
  TOP w0.109: JMXM1.153 70.19,135.8 70.05,135.66 70.05,135.28 v2(70.23,135.09)
  BOTTOM w0.109: CC21.1 70.12,138.84 70.12,138.04 70.04,137.96 v3(70.04,137.06) 70.04,135.28 v2(70.23,135.09)
PEG_CRX_GTX_C_P5: length 3.6
  TOP w0.109: JMXM1.147 68.69,135.8 68.55,135.66 68.55,135.19 v2(68.73,135)
  BOTTOM w0.109: CC22.1 68.59,136.17 68.59,135.54 68.54,135.48 68.54,135.2 68.73,135 v2(68.73,135)
PEG_CRX_GTX_C_P6: length 6.1
  TOP w0.109: JMXM1.141 67.19,135.8 67.05,135.66 67.05,135.28 v2(67.23,135.09)
  BOTTOM w0.109: v2(67.23,135.09) 67.03,135.29 67.03,135.66 67.07,135.7 v3(67.07,137.05) 67.07,138.84 CC23.1
PEG_CRX_GTX_C_P7: length 3.6
  TOP w0.109: JMXM1.135 65.69,135.8 65.55,135.66 65.55,135.19 v2(65.73,135)
  BOTTOM w0.109: CC24.1 65.55,136.17 65.55,135.19 v2(65.73,135)
PEG_CRX_GTX_C_P8: length 5
  TOP w0.109: v2(64.22,140.73) 64.05,140.55 64.05,137.59 64.19,137.45 JMXM1.129
  BOTTOM w0.109: v2(64.22,140.73) 64.02,140.53 64.02,140.43 CC25.1
PEG_CRX_GTX_C_P9: length 2.9
  TOP w0.109: v2(62.69,138.32) 62.47,138.1 62.47,138.1 62.47,137.9 62.55,137.82 62.55,137.54 62.69,137.4 JMXM1.123
  BOTTOM w0.109: CC26.1 62.5,137.77 62.5,138.13 v2(62.69,138.32)
PEG_CRX_GTX_C_P10: length 8
  TOP w0.109: v2(60.24,140.96) 60.24,141.02 60.15,141.11 60.04,141.11 59.95,141.2 59.78,141.2 59.64,141.06 59.64,140.7 60.9,139.43 60.9,137.66 61,137.55 61.09,137.55 61.19,137.45 JMXM1.117
  BOTTOM w0.109: CC27.1 60.73,140.09 60.83,140.2 60.83,141.09 60.67,141.25 60.54,141.25 60.4,141.11 60.32,141.11 60.24,141.02 v2(60.24,140.96)
PEG_CRX_GTX_C_P11: length 5.4
  TOP w0.109: v2(59.16,139.13) 59.26,139.03 59.71,139.03 59.92,138.82 59.92,137.71 59.69,137.48 JMXM1.111
  BOTTOM w0.109: v2(59.16,139.13) 59.31,138.98 59.59,138.98 59.82,138.74 59.82,138.04 59.65,137.87 59.65,137.7 CC28.1
PEG_CRX_GTX_C_P12: length 6.1
  TOP w0.109: JMXM1.105 58.19,135.96 58.04,135.81 58.04,135.28 v2(58.23,135.09)
  BOTTOM w0.109: v2(58.23,135.09) 58.05,135.28 58.05,135.73 58.05,135.74 v3(58.05,137.05) 58.05,138.84 CC29.1
PEG_CRX_GTX_C_P13: length 3.4
  TOP w0.109: v2(56.78,135.09) 56.57,135.3 56.57,135.88 56.69,136 JMXM1.99
  BOTTOM w0.109: CC30.1 56.53,136.17 56.53,135.33 56.78,135.08 v2(56.78,135.09)
PEG_CRX_GTX_C_P14: length 6.1
  TOP w0.109: JMXM1.93 55.19,136.05 55.03,135.89 55.03,135.29 v2(55.23,135.09)
  BOTTOM w0.109: CC31.1 54.88,138.84 54.88,138.61 55.05,138.44 v3(55.05,137.02) 55.05,135.28 v2(55.23,135.09)
PEG_CRX_GTX_C_P15: length 15.8
  TOP w0.109: v2(53.69,135.14) 53.56,135.28 53.56,135.87 53.69,136.01 JMXM1.87
  BOTTOM w0.109: v2(53.69,135.14) 53.64,135.14 53.54,135.04 53.54,134.99 53.42,134.87 53.42,134.6 54.38,133.64 v3(56.82,133.64) 65,133.64 65.23,133.41 65.94,133.41 66.04,133.52 CC32.1
PEG_CRX_GTX_N0: length 105.4
  TOP w0.109: JCPU1.M29 172.53,132.84 v2(172.01,132.32)
  IN1 w0.089: v2(172.01,132.32) 172.01,132.59 171.96,132.64 171.72,132.64 171.45,132.92 171.45,134.47 171.22,134.7 170.86,134.7 170.45,135.11 170.45,135.46 170.19,135.71 169.86,135.71 169.44,136.13 169.44,136.46 169.19,136.72 168.84,136.72 168.48,137.08 168.48,138.44 167.89,139.03 167.89,139.71 167.86,139.74 167.86,139.76
  IN1 w0.135: v2(77.58,141.04) 77.77,140.85 77.77,140.65 78.07,140.36 79.89,140.36 79.95,140.42 86.48,140.42 86.55,140.36 97.15,140.36 98.09,139.41 113.49,139.41 114.53,140.45 124.64,140.45 125.88,139.21 132.87,139.21 133.31,139.65 157.86,139.65 159.08,140.87 167.15,140.87 167.86,140.15 167.86,139.76
  BOTTOM w0.109: v2(77.58,141.04) 77.78,140.84 77.78,140.31 CC1.2
PEG_CRX_GTX_N1: length 105.9
  TOP w0.109: JCPU1.K28 v2(171.06,132.31)
  IN1 w0.089: v2(171.06,132.31) 171.06,132.03 170.97,131.94 170.74,131.94 170.65,132.03 170.65,132.61 169.65,133.61 169.65,134.54 169.3,134.89 168.93,134.89 168.64,135.18 168.64,135.55 168.26,135.93 167.88,135.93 166.64,137.18 166.64,139.54 166.3,139.88 162.37,139.88 161.39,138.9 160.42,138.9 160.39,138.93 160.37,138.93
  IN1 w0.135: 160.37,138.93 159.44,138.93 158.8,138.29 134.54,138.29 134.03,137.78 125.14,137.78 123.98,138.94 115.13,138.94 114.22,138.04 110.64,138.04 110.29,137.69 86.97,137.69 85.65,139 77.34,139 77.19,139.15 76.63,139.15 76.3,138.83 76.3,138.47 v2(76.15,138.32)
  BOTTOM w0.109: v2(76.15,138.32) 76.39,138.08 76.39,137.77 CC2.2
PEG_CRX_GTX_N2: length 107.5
  TOP w0.109: v2(172.06,135.31) 172.53,134.84 JCPU1.M31
  IN1 w0.089: v2(172.06,135.31) 171.89,135.31 171.74,135.46 171.74,135.65 171.47,135.92 170.92,135.92 170.64,136.2 170.64,136.56 170.25,136.94 169.9,136.94 169.66,137.19 169.66,138.55 169.28,138.93 168.9,138.93 168.67,139.16 168.67,139.5 168.88,139.71 168.88,140.04 168.91,140.07 168.91,140.09
  IN1 w0.135: 168.91,140.09 168.91,140.68 167.67,141.92 158.34,141.92 157.15,140.72 137.75,140.72 136.47,142 129.01,142 128.88,141.87 120.64,141.87 120.29,141.52 113.98,141.52 112.92,140.46 98.65,140.46 97.56,141.54 87.33,141.54 87.03,141.84 75,141.84 74.71,141.55 74.71,141.22 v2(74.54,141.04)
  BOTTOM w0.109: CC3.2 74.86,140.31 74.86,140.71 v2(74.54,141.04)
PEG_CRX_GTX_N3: length 109.4
  TOP w0.109: v2(171.06,134.31) 171.53,133.84 JCPU1.L30
  IN1 w0.089: 160.31,139.73 160.33,139.73 160.37,139.7 160.87,139.7 161.45,140.28 166.96,140.28 167.64,139.6 167.64,137.15 167.89,136.89 168.35,136.89 168.67,136.58 168.67,136.13 168.91,135.89 169.35,135.89 169.66,135.59 169.66,135.18 169.91,134.93 170.35,134.93 170.75,134.53 170.75,134.42 170.86,134.31 v2(171.06,134.31)
  IN1 w0.135: 160.31,139.73 158.8,139.73 158.17,139.09 134,139.09 133.55,138.65 125.61,138.65 124.51,139.75 114.66,139.75 113.78,138.87 97.57,138.87 96.62,139.82 77.8,139.82 77.52,140.09 72.29,140.09 71.09,138.9 v2(71.09,138.32)
  BOTTOM w0.109: CC4.2 71.31,137.77 71.31,138.1 v2(71.09,138.32)
PEG_CRX_GTX_N4: length 115.5
  TOP w0.109: JCPU1.M33 172.53,136.84 v2(172.06,137.31)
  IN1 w0.089: v2(172.06,137.31) 171.91,137.31 171.74,137.46 171.74,137.61 171.45,137.9 170.88,137.9 170.69,138.09 170.69,138.47 170.74,138.52 170.74,138.96 170.77,138.99 170.77,139
  IN1 w0.135: 170.77,139 170.77,141.07 168.32,143.52 159.61,143.52 154.2,148.93 143.81,148.93 143.56,149.19 140.38,149.19 135.52,144.32 120.39,144.32 120.35,144.29 115.42,144.29 115.38,144.32 110.42,144.32 110.21,144.54 101.24,144.54 100,143.29 87.89,143.29 87.37,143.81 73.3,143.81 71.34,141.85 70.15,141.85 69.77,141.47 69.77,141.23 v2(69.58,141.04)
  BOTTOM w0.109: CC5.2 69.89,140.42 69.89,140.86 69.72,141.04 v2(69.58,141.04)
PEG_CRX_GTX_N5: length 115.5
  TOP w0.109: JCPU1.L32 171.61,135.84 v2(172.08,136.31)
  IN1 w0.089: v2(172.08,136.31) 171.82,136.31 171.64,136.49 171.64,136.68 171.4,136.92 170.93,136.92 170.75,137.1 170.75,137.46 170.19,138.01 170.19,138.61 169.65,139.15 169.65,139.48 169.7,139.53 169.7,140.03 169.73,140.06 169.73,140.07
  IN1 w0.135: v2(68.07,138.32) 68.07,139.16 68.49,139.57 70.45,139.57 73.51,142.64 87.4,142.64 87.58,142.46 100.25,142.46 101.34,141.36 109.22,141.36 111.38,143.53 114.75,143.53 115.04,143.24 121.66,143.24 122.22,142.69 128.34,142.69 128.47,142.81 136.93,142.81 138.23,141.52 155.96,141.52 157.16,142.72 168,142.72 169.73,140.99 169.73,140.07
  BOTTOM w0.109: CC6.2 68.38,137.77 68.38,138 v2(68.07,138.32)
PEG_CRX_GTX_N6: length 119
  TOP w0.109: v2(173.1,139.41) 172.59,138.9 JCPU1.M35
  IN1 w0.135: v2(66.56,141.04) 66.56,141.88 66.66,141.98 66.74,142.06 68.6,143.91 69.32,144.64 71.78,144.64 72.56,145.43 88.04,145.43 88.19,145.27 94.74,145.27 94.97,145.5 99.31,145.5 100.51,146.7 111.99,146.7 112.39,147.1 121.38,147.1 121.81,147.54 136.44,147.54 139.8,150.89 144.14,150.89 144.47,150.56 155.73,150.56 161.14,145.15 168.96,145.15 172.76,141.35 172.76,139.75 v2(173.1,139.41)
  BOTTOM w0.109: CC7.2 66.65,140.09 66.86,140.31 66.86,140.74 v2(66.56,141.04)
PEG_CRX_GTX_N7: length 121.6
  TOP w0.109: JCPU1.L34 171.66,137.84 v2(172.11,138.29)
  IN1 w0.135: v2(65.07,138.32) 65.07,139.31 66.14,140.37 67.94,140.37 68.43,140.86 68.43,141.95 69.53,143.05 69.53,143.29 70.05,143.8 72.13,143.8 72.94,144.62 87.69,144.62 87.84,144.46 95.02,144.46 95.07,144.52 99.62,144.52 100.99,145.89 112.33,145.89 112.74,146.29 136.35,146.29 140.05,150 143.89,150 144.14,149.75 154.71,149.75 160.12,144.34 168.64,144.34 171.58,141.4 171.58,139.2 171.73,139.05 171.73,138.67 v2(172.11,138.29)
  BOTTOM w0.109: v2(65.07,138.32) 65.34,138.05 65.34,137.77 CC8.2
PEG_CRX_GTX_N8: length 109.4
  TOP w0.109: v2(166.06,132.31) 165.59,132.78 JCPU1.E29
  IN1 w0.089: v2(166.06,132.31) 165.65,132.71 164.88,132.71 164.44,133.15 164.44,133.49 164.22,133.71 160.41,133.71 160.38,133.68 160.36,133.68
  IN1 w0.135: v2(63.64,135.09) 63.7,135.04 63.7,134.58 64.12,134.16 125.85,134.16 126.23,133.77 133.63,133.77 134.01,134.16 156.9,134.16 157.38,133.68 160.36,133.68
  BOTTOM w0.109: CC9.2 63.81,138.84 63.81,138.39 63.85,138.36 63.85,135.3 v2(63.64,135.09)
PEG_CRX_GTX_N9: length 107.4
  TOP w0.109: v2(164.06,132.31) 164.53,131.84 JCPU1.D28
  IN1 w0.089: v2(164.06,132.31) 164.22,132.15 164.37,132.15 164.5,132.28 164.5,132.55 164.31,132.73 160.42,132.73 160.39,132.7 160.37,132.7
  IN1 w0.135: v2(62.13,135.09) 62.13,134.4 63.17,133.36 125.5,133.36 125.93,132.93 134.31,132.93 134.74,133.36 156.41,133.36 157.07,132.7 160.37,132.7
  BOTTOM w0.109: CC10.2 62.29,136.17 62.29,135.76 62.34,135.71 62.34,135.3 v2(62.13,135.09)
PEG_CRX_GTX_N10: length 118.2
  TOP w0.109: JCPU1.E31 v2(166.06,135.31)
  IN1 w0.089: v2(166.06,135.31) 166.06,135.15 165.44,134.53 165.44,134.01 165.74,133.71 166.25,133.71 166.46,133.5 166.46,132.1 166.26,131.9 160.35,131.9 160.31,131.93 160.3,131.93
  IN1 w0.135: 160.3,131.93 159.92,131.93 159.92,131.94 159.8,132.05 159.36,132.05 159.24,131.93 158.84,131.93 158.72,132.05 158.27,132.05 158.16,131.93 157.07,131.93 156.2,132.81 135.23,132.81 134.79,132.37 125.25,132.37 124.82,132.81 123.41,132.81 122.55,131.94 118.34,131.94 117.9,132.38 117.19,132.38 116.75,132.82 62.2,132.82 60.88,134.14 60.88,134.73 61.06,134.91 61.06,135.01 61.14,135.09 v2(61.26,135.09)
  BOTTOM w0.109: CC11.2 60.97,138.84 60.97,138.68 61.04,138.61 61.04,135.31 v2(61.26,135.09)
PEG_CRX_GTX_N11: length 122.6
  TOP w0.109: v2(164.05,134.34) 164.55,133.84 JCPU1.D30
  IN1 w0.089: v2(164.05,134.34) 164.25,134.54 164.25,134.61 164.55,134.91 165.24,134.91 165.47,135.14 165.47,135.53 165.83,135.89 166.28,135.89 166.67,135.5 166.67,134.14 166.89,133.92 167.25,133.92 167.66,133.51 167.66,132.07 167.29,131.7 166.91,131.7 166.67,131.46 166.67,131.08 166.31,130.72 161.87,130.72 161.82,130.66 160.41,130.66 160.38,130.63 160.36,130.63
  IN1 w0.135: 160.36,130.63 153.78,130.63 152.77,131.64 135.69,131.64 135.36,131.31 125.01,131.31 124.54,130.84 117.95,130.84 117.46,131.33 109.98,131.33 109.54,131.77 61.44,131.77 59.13,134.09 v2(59.13,135.09)
  BOTTOM w0.109: v2(59.13,135.09) 59.33,135.3 59.33,135.79 59.37,135.82 59.37,136.17 CC12.2
PEG_CRX_GTX_N12: length 114.6
  TOP w0.109: v2(166.06,139.31) 165.94,139.31 165.59,138.96 JCPU1.E35
  IN1 w0.089: 160.35,137.93 160.37,137.93 160.4,137.9 161.34,137.9 162.36,138.93 165.89,138.93 166.06,139.1 v2(166.06,139.31)
  IN1 w0.135: v2(58.47,141.54) 58.65,141.36 59,141.36 61.11,139.26 61.11,138.7 61.98,137.82 85.27,137.82 86.21,136.88 110.93,136.88 111.28,137.22 115.01,137.22 115.27,137.48 123.17,137.48 123.78,136.87 130.36,136.87 130.77,136.46 131.77,136.46 132.28,136.97 135.25,136.97 135.76,137.48 159.14,137.48 159.59,137.93 160.35,137.93
  BOTTOM w0.109: CC13.2 57.78,140.37 57.78,141.2 57.99,141.41 58.34,141.41 v2(58.47,141.54)
PEG_CRX_GTX_N13: length 114.1
  TOP w0.109: v2(164.06,138.31) 164.53,137.84 JCPU1.D34
  IN1 w0.089: v2(164.06,138.31) 164.22,138.47 164.39,138.47 164.51,138.34 164.51,138.11 164.3,137.9 162.25,137.9 161.25,136.9 160.88,136.9 160.63,136.65 160.4,136.65 160.37,136.68 160.35,136.68
  IN1 w0.135: v2(56.82,138.82) 57,138.65 57.78,138.65 59.4,137.03 84.78,137.03 85.73,136.08 115,136.08 115.61,136.68 122.26,136.68 122.88,136.06 129.82,136.06 130.22,135.65 132.28,135.65 132.68,136.06 135.86,136.06 136.49,136.68 160.35,136.68
  BOTTOM w0.109: v2(56.82,138.82) 56.67,138.67 56.34,138.67 56.1,138.43 56.1,137.92 56.23,137.79 56.23,137.68 CC14.2
PEG_CRX_GTX_N14: length 119.4
  TOP w0.109: JCPU1.E33 165.53,136.84 v2(165.06,137.31)
  IN1 w0.089: v2(165.06,137.31) 165.19,137.44 165.42,137.44 165.53,137.32 165.53,137.2 165.23,136.89 163.75,136.89 163.45,136.59 163.45,136.08 163.25,135.89 160.84,135.89 160.71,135.76 160.48,135.76 160.45,135.79 160.42,135.79
  IN1 w0.135: 160.42,135.79 138.14,135.79 137.56,135.21 133.24,135.21 132.86,134.84 129.79,134.84 129.41,135.22 85.13,135.22 84.12,136.23 58.07,136.23 56.34,137.96 56.34,139.59 56.67,139.92 56.67,140.78 56.34,141.11 56.01,141.11 v2(55.83,141.29)
  BOTTOM w0.109: CC15.2 54.6,140.37 54.6,140.62 55.17,141.19 55.73,141.19 v2(55.83,141.29)
PEG_CRX_GTX_N15: length 116.1
  TOP w0.109: JCPU1.E32 v2(165.06,135.31)
  IN1 w0.089: 160.38,130.02 160.41,130.02 160.44,129.99 161.81,129.99 161.88,129.91 166.25,129.91 167.45,131.11 167.45,131.51 167.82,131.89 168.23,131.89 168.47,132.12 168.47,134.44 168.21,134.7 167.86,134.7 167.45,135.11 167.45,135.55 166.28,136.72 165.91,136.72 165.68,136.49 165.68,136.39 165.06,135.76 v2(165.06,135.31)
  IN1 w0.135: 160.38,130.02 153.6,130.02 152.72,130.91 136.09,130.91 135.91,130.72 125.21,130.72 124.77,130.28 117.69,130.28 117.19,130.78 109.75,130.78 109.31,131.22 68.28,131.22 68.02,130.95 68.02,130.42 v2(67.98,130.38)
  BOTTOM w0.109: v2(67.98,130.38) 67.98,130.38 68.16,130.56 68.16,132.51 67.32,133.36 67.05,133.36 66.95,133.26 CC16.2
PEG_CRX_GTX_P0: length 105.4
  TOP w0.109: JCPU1.L29 171.74,132.84 172.06,133.16 v2(172.06,133.31)
  IN1 w0.089: v2(172.06,133.31) 172.19,133.18 172.19,132.93 172.08,132.83 171.8,132.83 171.64,132.99 171.64,134.54 171.3,134.89 170.94,134.89 170.64,135.19 170.64,135.54 170.27,135.9 169.94,135.9 169.63,136.21 169.63,136.54 169.27,136.91 168.92,136.91 168.67,137.16 168.67,138.52 168.08,139.11 168.08,139.71 168.11,139.74 168.11,139.76
  IN1 w0.135: 168.11,139.76 168.11,140.26 167.59,140.78 167.25,141.12 158.97,141.12 157.75,139.9 133.2,139.9 132.76,139.46 125.99,139.46 124.74,140.7 114.43,140.7 113.38,139.66 98.2,139.66 97.25,140.61 86.66,140.61 86.59,140.68 79.85,140.68 79.78,140.61 78.17,140.61 78.03,140.75 78.03,140.87 v2(78.19,141.04)
  BOTTOM w0.109: CC17.2 77.99,140.31 77.99,140.84 v2(78.19,141.04)
PEG_CRX_GTX_P1: length 105.9
  TOP w0.109: JCPU1.L28 v2(171.06,131.31)
  IN1 w0.089: v2(171.06,131.31) 171.06,131.63 170.94,131.75 170.66,131.75 170.46,131.95 170.46,132.53 169.46,133.53 169.46,134.46 169.23,134.7 168.85,134.7 168.45,135.1 168.45,135.47 168.18,135.74 167.8,135.74 166.44,137.1 166.44,139.46 166.22,139.69 162.45,139.69 161.47,138.71 160.41,138.71 160.38,138.68 160.37,138.68
  IN1 w0.135: v2(76.86,138.32) 76.81,138.37 76.66,138.37 76.55,138.47 76.55,138.72 76.73,138.9 77.08,138.9 77.24,138.75 77.51,138.75 77.62,138.65 78.12,138.65 78.22,138.75 78.63,138.75 78.73,138.65 79.23,138.65 79.34,138.75 85.55,138.75 86.86,137.43 110.4,137.43 110.75,137.78 114.32,137.78 115.23,138.69 123.88,138.69 125.04,137.53 134.14,137.53 134.65,138.04 158.9,138.04 159.55,138.68 160.37,138.68
  BOTTOM w0.109: CC18.2 76.6,137.77 76.6,138.05 v2(76.86,138.32)
PEG_CRX_GTX_P2: length 107.4
  TOP w0.109: v2(171.19,135.31) 171.59,134.91 JCPU1.L31
  IN1 w0.089: v2(171.19,135.31) 171.43,135.31 171.55,135.42 171.55,135.57 171.39,135.73 170.84,135.73 170.45,136.12 170.45,136.48 170.18,136.75 169.82,136.75 169.47,137.11 169.47,138.47 169.2,138.74 168.82,138.74 168.48,139.08 168.48,139.58 168.69,139.79 168.69,140.04 168.66,140.07 168.66,140.09
  IN1 w0.135: 168.66,140.09 168.66,140.57 167.57,141.66 158.45,141.66 157.25,140.47 137.65,140.47 136.37,141.75 129.11,141.75 128.98,141.62 120.75,141.62 120.39,141.26 114.09,141.26 113.03,140.2 98.54,140.2 97.46,141.29 87.22,141.29 86.92,141.59 77.38,141.59 77.27,141.47 76.82,141.47 76.71,141.59 76.3,141.59 76.19,141.47 75.74,141.47 75.62,141.59 75.11,141.59 74.97,141.45 74.97,140.92 75.06,140.83 75.26,140.83 75.4,140.97 v2(75.4,141.04)
  BOTTOM w0.109: CC19.2 75.07,140.31 75.07,140.71 v2(75.4,141.04)
PEG_CRX_GTX_P3: length 109.4
  TOP w0.109: v2(170.06,134.31) 170.53,133.84 JCPU1.K30
  IN1 w0.089: 160.31,139.48 160.32,139.48 160.35,139.51 160.95,139.51 161.53,140.09 166.88,140.09 167.45,139.52 167.45,137.07 167.81,136.7 168.27,136.7 168.48,136.5 168.48,136.06 168.83,135.7 169.27,135.7 169.47,135.51 169.47,135.1 169.83,134.74 170.27,134.74 170.56,134.46 170.56,134.33 170.38,134.15 170.22,134.15 v2(170.06,134.31)
  IN1 w0.135: 160.31,139.48 158.91,139.48 158.27,138.84 134.1,138.84 133.65,138.39 125.5,138.39 124.4,139.49 114.77,139.49 113.89,138.61 97.47,138.61 96.52,139.56 77.7,139.56 77.42,139.84 74.48,139.84 74.38,139.74 73.88,139.74 73.78,139.84 73.37,139.84 73.27,139.74 72.76,139.74 72.66,139.84 72.39,139.84 71.35,138.79 71.35,138.67 71.58,138.44 71.6,138.44 v2(71.73,138.32)
  BOTTOM w0.109: CC20.2 71.52,137.77 71.52,138.1 v2(71.73,138.32)
PEG_CRX_GTX_P4: length 115.5
  TOP w0.109: v2(171.15,137.3) 171.59,136.86 JCPU1.L33
  IN1 w0.089: 170.52,139 170.52,138.99 170.55,138.96 170.55,138.6 170.5,138.55 170.5,138.01 170.8,137.71 171.37,137.71 171.55,137.53 171.55,137.44 171.42,137.3 v2(171.15,137.3)
  IN1 w0.135: v2(70.47,141.04) 70.29,140.86 70.13,140.86 70.03,140.96 70.03,141.36 70.26,141.59 71.44,141.59 71.76,141.91 71.91,141.91 72.23,142.23 72.23,142.38 72.52,142.67 72.67,142.67 73,142.99 73,143.15 73.41,143.56 87.27,143.56 87.78,143.04 100.1,143.04 101.35,144.29 110.1,144.29 110.32,144.07 115.28,144.07 115.31,144.03 120.46,144.03 120.5,144.07 135.63,144.07 140.49,148.93 143.45,148.93 143.71,148.68 154.1,148.68 159.51,143.27 168.22,143.27 170.52,140.97 170.52,139
  BOTTOM w0.109: CC21.2 70.1,140.45 70.1,140.86 70.28,141.04 v2(70.47,141.04)
PEG_CRX_GTX_P5: length 115.5
  TOP w0.109: JCPU1.K32 170.72,135.84 171.07,136.18 v2(171.07,136.31)
  IN1 w0.089: 169.47,140.07 169.47,140.05 169.51,140.01 169.51,139.61 169.45,139.56 169.45,139.08 170,138.53 170,137.94 170.56,137.38 170.56,137.02 170.85,136.73 171.32,136.73 171.45,136.6 171.45,136.41 171.35,136.31 v2(171.07,136.31)
  IN1 w0.135: 169.47,140.07 169.47,140.89 167.9,142.46 157.26,142.46 156.06,141.26 138.12,141.26 136.82,142.56 128.58,142.56 128.45,142.43 122.12,142.43 121.56,142.99 114.93,142.99 114.65,143.28 111.49,143.28 109.32,141.11 101.24,141.11 100.15,142.2 87.48,142.2 87.3,142.38 73.61,142.38 71.27,140.04 71.27,139.94 71.27,139.87 70.95,139.55 70.78,139.55 70.55,139.32 69.84,139.32 69.72,139.21 69.27,139.21 69.16,139.32 68.59,139.32 68.32,139.05 68.32,138.88 68.48,138.72 68.9,138.72 69.04,138.59 69.04,138.44 v2(68.91,138.32)
  BOTTOM w0.109: CC22.2 68.59,137.77 68.59,138 v2(68.91,138.32)
PEG_CRX_GTX_P6: length 118.9
  TOP w0.109: JCPU1.L35 171.59,138.89 v2(172.11,139.41)
  IN1 w0.135: v2(67.37,141.04) 67.37,141.03 67.27,140.93 67.1,140.93 66.98,141.05 66.98,141.21 66.81,141.38 66.81,141.77 66.84,141.8 66.84,141.8 67.18,142.14 67.28,142.14 67.28,142.14 67.35,142.14 67.66,142.45 67.66,142.52 67.66,142.62 67.95,142.9 68.04,142.9 68.04,142.9 68.11,142.9 68.42,143.21 68.42,143.28 68.42,143.38 69.43,144.39 71.88,144.39 72.67,145.17 87.93,145.17 88.09,145.02 94.84,145.02 95.07,145.25 99.42,145.25 100.61,146.44 112.09,146.44 112.5,146.85 121.49,146.85 121.92,147.28 136.55,147.28 139.9,150.64 144.04,150.64 144.37,150.31 155.62,150.31 161.03,144.89 168.85,144.89 172.5,141.25 172.5,139.8 v2(172.11,139.41)
  BOTTOM w0.109: CC23.2 67.28,140.09 67.07,140.31 67.07,140.74 v2(67.37,141.04)
PEG_CRX_GTX_P7: length 121.6
  TOP w0.109: JCPU1.K34 170.59,138.07 170.81,138.29 v2(171.07,138.29)
  IN1 w0.135: v2(65.81,138.32) 65.98,138.49 65.98,138.64 65.83,138.79 65.43,138.79 65.33,138.89 65.33,139.2 65.52,139.39 65.68,139.39 66,139.72 66,139.88 66.24,140.12 66.7,140.12 66.82,140 67.26,140 67.38,140.12 68.05,140.12 68.68,140.75 68.68,141.84 69.79,142.95 69.79,143.18 70.15,143.55 72.24,143.55 73.05,144.36 87.59,144.36 87.74,144.21 95.13,144.21 95.18,144.26 99.73,144.26 101.09,145.63 112.44,145.63 112.84,146.04 136.45,146.04 140.16,149.75 143.78,149.75 144.04,149.49 154.61,149.49 160.02,144.08 168.53,144.08 171.32,141.29 171.32,139.09 171.48,138.94 171.48,138.7 v2(171.07,138.29)
  BOTTOM w0.109: v2(65.81,138.32) 65.55,138.05 65.55,137.77 CC24.2
PEG_CRX_GTX_P8: length 109.4
  TOP w0.109: JCPU1.F29 166.53,132.84 v2(166.06,133.31)
  IN1 w0.089: v2(166.06,133.31) 165.65,132.9 164.96,132.9 164.63,133.23 164.63,133.57 164.3,133.9 160.41,133.9 160.38,133.93 160.36,133.93
  IN1 w0.135: 160.36,133.93 159.8,133.93 159.68,134.05 159.25,134.05 159.13,133.93 158.72,133.93 158.61,134.05 158.17,134.05 158.05,133.93 157.48,133.93 157,134.41 133.91,134.41 133.52,134.02 126.34,134.02 125.95,134.41 64.23,134.41 63.95,134.69 63.95,134.8 64.07,134.92 64.07,135.01 64.15,135.09 v2(64.26,135.09)
  BOTTOM w0.109: v2(64.26,135.09) 64.06,135.3 64.06,138.44 64.02,138.48 64.02,138.84 CC25.2
PEG_CRX_GTX_P9: length 107.4
  TOP w0.109: v2(165.06,132.31) 165.53,131.84 JCPU1.E28
  IN1 w0.089: v2(165.06,132.31) 164.86,132.31 164.69,132.48 164.69,132.63 164.39,132.92 160.42,132.92 160.39,132.96 160.37,132.96
  IN1 w0.135: 160.37,132.96 159.86,132.96 159.74,133.07 159.3,133.07 159.18,132.96 158.78,132.96 158.66,133.07 158.21,133.07 158.09,132.96 157.17,132.96 156.51,133.61 134.64,133.61 134.21,133.19 126.03,133.19 125.6,133.61 63.27,133.61 62.38,134.5 62.38,134.75 62.55,134.92 62.55,135.01 62.63,135.09 v2(62.76,135.09)
  BOTTOM w0.109: CC26.2 62.5,136.17 62.5,135.85 62.55,135.8 62.55,135.3 v2(62.76,135.09)
PEG_CRX_GTX_P10: length 118.3
  TOP w0.109: JCPU1.F31 v2(166.06,134.31)
  IN1 w0.089: v2(166.06,134.31) 166.06,134.54 165.96,134.63 165.81,134.63 165.63,134.46 165.63,134.09 165.82,133.9 166.33,133.9 166.65,133.58 166.65,132.02 166.34,131.71 160.36,131.71 160.33,131.68 160.3,131.68
  IN1 w0.135: 160.3,131.68 156.96,131.68 156.09,132.55 135.33,132.55 134.9,132.12 125.14,132.12 124.71,132.55 123.52,132.55 122.65,131.69 118.23,131.69 117.79,132.13 117.09,132.13 116.65,132.57 62.1,132.57 60.63,134.04 60.63,135.09 v2(60.63,135.09)
  BOTTOM w0.109: CC27.2 60.76,138.84 60.76,138.59 60.83,138.53 60.83,135.29 v2(60.63,135.09)
PEG_CRX_GTX_P11: length 122.5
  TOP w0.109: v2(165.06,134.31) 165.53,133.84 JCPU1.E30
  IN1 w0.089: 160.36,130.88 160.38,130.88 160.41,130.85 161.74,130.85 161.79,130.91 166.23,130.91 166.48,131.16 166.48,131.54 166.84,131.89 167.21,131.89 167.47,132.15 167.47,133.43 167.17,133.73 166.81,133.73 166.48,134.06 166.48,135.42 166.2,135.7 165.91,135.7 165.66,135.45 165.66,135.07 165.31,134.72 164.63,134.72 164.44,134.53 164.44,134.2 164.64,134 164.84,134 165.06,134.21 v2(165.06,134.31)
  IN1 w0.135: v2(59.75,135.09) 59.67,135.09 59.56,134.99 59.56,134.91 59.38,134.73 59.38,134.19 61.55,132.02 109.64,132.02 110.08,131.59 117.57,131.59 118.06,131.1 124.44,131.1 124.9,131.56 135.25,131.56 135.58,131.89 152.88,131.89 153.88,130.88 157.79,130.88 157.9,131 158.35,131 158.47,130.88 158.87,130.88 158.99,131 159.43,131 159.55,130.88 160.36,130.88
  BOTTOM w0.109: CC28.2 59.58,136.17 59.58,135.73 59.55,135.7 59.55,135.3 v2(59.75,135.09)
PEG_CRX_GTX_P12: length 114.6
  TOP w0.109: JCPU1.F35 166.54,138.84 v2(166.06,138.36)
  IN1 w0.089: v2(166.06,138.36) 166.06,138.59 165.91,138.74 162.44,138.74 161.42,137.71 160.39,137.71 160.36,137.68 160.35,137.68
  IN1 w0.135: 160.35,137.68 159.7,137.68 159.25,137.23 135.87,137.23 135.36,136.72 132.38,136.72 131.88,136.21 130.66,136.21 130.26,136.61 123.68,136.61 123.06,137.23 115.38,137.23 115.12,136.97 111.38,136.97 111.04,136.63 86.11,136.63 85.17,137.57 61.88,137.57 60.86,138.59 60.86,139.15 58.9,141.11 58.62,141.11 v2(58.47,140.96)
  BOTTOM w0.109: CC29.2 58.06,140.09 57.99,140.17 57.99,141.11 58.08,141.2 58.2,141.2 58.29,141.11 58.39,141.11 58.47,141.03 v2(58.47,140.96)
PEG_CRX_GTX_P13: length 114.1
  TOP w0.109: v2(165.06,138.31) 165.53,137.84 JCPU1.E34
  IN1 w0.089: v2(165.06,138.31) 164.8,138.31 164.7,138.21 164.7,138.04 164.38,137.71 162.33,137.71 161.32,136.71 160.96,136.71 160.71,136.46 160.39,136.46 160.36,136.43 160.35,136.43
  IN1 w0.135: 160.35,136.43 136.59,136.43 135.96,135.8 132.79,135.8 132.38,135.4 130.12,135.4 129.71,135.8 122.78,135.8 122.15,136.43 115.71,136.43 115.11,135.82 85.62,135.82 84.67,136.77 59.3,136.77 57.68,138.39 56.97,138.39 v2(56.82,138.24)
  BOTTOM w0.109: v2(56.82,138.24) 56.82,138.32 56.74,138.39 56.64,138.39 56.57,138.46 56.43,138.46 56.31,138.34 56.31,138.01 56.45,137.88 56.45,137.52 56.54,137.43 CC30.2
PEG_CRX_GTX_P14: length 119.3
  TOP w0.109: v2(166.06,137.31) 166.53,136.84 JCPU1.F33
  IN1 w0.089: 160.42,135.54 160.44,135.54 160.47,135.57 160.79,135.57 160.91,135.7 163.33,135.7 163.64,136 163.64,136.51 163.83,136.7 165.3,136.7 165.72,137.12 165.72,137.21 165.82,137.31 v2(166.06,137.31)
  IN1 w0.135: 160.42,135.54 138.24,135.54 137.67,134.96 133.35,134.96 132.97,134.58 129.69,134.58 129.31,134.96 85.02,134.96 84.02,135.97 57.96,135.97 56.08,137.86 56.08,139.69 56.41,140.02 56.41,140.67 56.23,140.86 56,140.86 v2(55.84,140.7)
  BOTTOM w0.109: v2(55.84,140.7) 55.84,140.77 55.73,140.88 55.62,140.88 55.53,140.98 55.25,140.98 54.81,140.53 54.81,140.22 54.94,140.09 CC31.2
PEG_CRX_GTX_P15: length 116
  TOP w0.109: v2(165.06,136.31) JCPU1.D32
  IN1 w0.089: 160.38,129.76 160.41,129.76 160.44,129.8 161.73,129.8 161.8,129.72 166.33,129.72 167.64,131.03 167.64,131.43 167.9,131.7 168.31,131.7 168.66,132.04 168.66,134.52 168.29,134.89 167.94,134.89 167.64,135.19 167.64,135.63 166.36,136.91 165.83,136.91 165.49,136.57 165.49,136.46 165.34,136.31 v2(165.06,136.31)
  IN1 w0.135: 160.38,129.76 159.7,129.76 159.59,129.65 159.12,129.65 159,129.76 158.6,129.76 158.48,129.65 158.01,129.65 157.89,129.76 153.5,129.76 152.61,130.65 136.2,130.65 136.02,130.47 125.31,130.47 124.88,130.03 117.58,130.03 117.09,130.53 109.64,130.53 109.2,130.96 68.39,130.96 68.27,130.85 68.27,130.7 68.4,130.57 68.4,130.47 68.49,130.38 v2(68.57,130.38)
  BOTTOM w0.109: CC32.2 67.2,133.57 67.4,133.57 68.38,132.59 68.38,130.58 v2(68.57,130.38)
PEG_CTX_GRX_C_N0: length 107.8
  TOP w0.109: CC44.2 78.13,148.73 78.23,148.83 78.23,149.5 77.96,149.77 77.85,149.77 77.7,149.62 v2(77.7,149.52) ; JCPU1.H35 168.59,139 168.9,139.31 v2(169.06,139.31)
  IN3 w0.089: v2(169.06,139.31) 168.9,139.15 168.9,138.99 169.07,138.82 169.3,138.82 169.48,139 169.48,140.56 169.45,140.59 169.45,140.62
  IN3 w0.14: v2(77.7,149.52) 77.7,149.65 77.77,149.73 77.87,149.73 77.97,149.82 78.15,149.82 78.33,149.64 78.89,149.64 79.22,149.97 79.38,149.97 79.71,150.31 79.71,150.46 80.01,150.76 80.17,150.76 80.51,151.1 80.51,151.26 80.81,151.56 86.42,151.56 87.54,152.68 93.46,152.68 94.64,153.86 106.12,153.86 106.37,154.12 110.26,154.12 111.63,155.49 137.97,155.49 138.45,155.97 156.08,155.97 169.45,142.6 169.45,140.62
