# Allegro board LA9781PR10-0624_GERBER.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CAS#: length 69.4
  TOP w0.102: v2(152.17,68.92) 152,68.92 151.62,69.3 151.62,70.7 151.88,70.96 152.4,70.96 152.64,71.19 JDIMM1.115 ; v2(177.06,111.31) JCPU1.U8
  IN1 w0.089: 173.15,103.62 173.43,103.9 173.43,109.36 173.86,109.79 174.09,109.79 174.62,110.33 174.62,110.48 174.85,110.71 176.59,110.71 177.06,111.17 v2(177.06,111.31)
  IN1 w0.208: v2(152.17,68.92) 151.89,68.92 151.68,68.72 151.68,68.24 151.5,68.06 151.23,68.06 151.05,68.24 151.05,70.75 150.97,70.82 150.97,76.28 150.92,76.33 150.92,79.43 150.63,79.72 150.63,80.24 151.42,81.03 151.42,82.82 153.64,85.04 153.64,86.45 155.64,88.45 155.86,88.45 161.28,93.87 164.33,93.87 173.15,102.69 173.15,103.62
  BOTTOM w0.102: v2(152.17,68.92) 152.75,68.34 152.75,65.2 152.64,65.09 JDIMM2.115
DDR_A_D0: length 80.6
  TOP w0.102: JCPU1.AR15 195.59,118.78 v2(196.06,118.31)
  TOP w0.14: v2(189.66,67.59) 189.66,68.3 187.44,70.52 JDIMM1.7
  IN1 w0.089: 197.84,118.91 197.59,118.91 197.59,118.91 196.66,118.91 v2(196.06,118.31)
  IN1 w0.147: v2(189.66,67.59) 189.66,66.52 189.91,66.26 190.81,66.26 199.72,75.16 199.72,76.26 205.73,82.28 205.73,112.99 199.81,118.91 197.84,118.91
  BOTTOM w0.14: v2(189.66,67.59) 189.63,67.57 189.63,67.35 189.51,67.22 189.23,67.22 189.1,67.35 189.1,67.83 189.43,68.16 189.43,68.53 187.74,70.22 JDIMM2.6
DDR_A_D1: length 76
  TOP w0.102: v2(197.06,117.31) 196.59,117.78 JCPU1.AT14
  TOP w0.14: JDIMM1.4 188.34,64.88 188.27,64.96 188.27,65.29 188.38,65.4 v2(188.52,65.4)
  IN1 w0.089: 197.84,117.31 v2(197.06,117.31)
  IN1 w0.147: v2(188.52,65.4) 188.35,65.23 187.94,65.23 187.76,65.42 187.76,66.71 188.2,67.15 188.2,69.16 189.08,70.05 190.05,70.05 190.19,70.18 192.22,70.18 192.37,70.34 192.37,70.52 192.52,70.67 192.69,70.67 192.97,70.4 193.13,70.4 193.37,70.63 193.37,70.85 192.76,71.46 192.76,71.66 192.97,71.87 193.18,71.87 193.78,71.27 194,71.27 194.2,71.47 194.2,71.69 193.6,72.29 193.6,72.5 195.67,74.57 196.38,74.57 204.56,82.75 204.56,112.51 199.76,117.31 197.84,117.31
  BOTTOM w0.14: JDIMM2.5 188.04,64.89 187.65,65.28 187.65,66.2 187.78,66.33 187.97,66.33 188.11,66.2 188.11,65.9 188.58,65.43 188.54,65.4 v2(188.52,65.4)
DDR_A_D2: length 81
  TOP w0.102: JCPU1.AM14 192.59,117.78 v2(193.06,117.31)
  TOP w0.14: JDIMM1.16 184.74,65.29 v2(185.15,65.71)
  IN1 w0.089: v2(193.06,117.31) 193.44,117.69 194.32,117.69 194.66,117.35 194.66,116.02 194.77,115.91 197.53,115.91
  IN1 w0.147: v2(185.15,65.71) 184.88,65.98 184.53,65.98 184.28,65.73 184.28,64.17 184.43,64.02 186.39,64.02 186.54,64.17 186.54,69.18 188.59,71.23 189.56,71.23 189.67,71.34 190.79,71.34 203.39,83.94 203.39,112.04 199.52,115.91 197.53,115.91
  BOTTOM w0.14: JDIMM2.15 185.04,64.92 184.36,65.6 184.36,66.21 184.5,66.35 184.7,66.35 184.84,66.21 184.84,65.86 184.99,65.71 v2(185.15,65.71)
DDR_A_D3: length 81.7
  TOP w0.102: v2(194.06,117.31) 193.59,117.78 JCPU1.AN14
  TOP w0.14: JDIMM1.18 184.14,66.22 v2(185.15,67.23)
  IN1 w0.089: v2(194.06,117.31) 194.45,116.92 194.45,115.93 194.65,115.72 197.32,115.72 197.38,115.66
  IN1 w0.147: 197.38,115.66 197.53,115.51 199.38,115.51 203,111.88 203,84.1 190.63,71.73 189.5,71.73 189.41,71.64 188.45,71.64 186.15,69.35 186.15,64.57 186,64.42 185.19,64.42 185.01,64.6 185.01,64.98 185.19,65.16 185.51,65.16 185.6,65.25 185.6,67.08 185.44,67.23 v2(185.15,67.23)
  BOTTOM w0.14: v2(185.15,67.23) 185.15,67.46 185.03,67.58 183.96,67.58 183.7,67.32 183.7,67 184.05,66.65 184.05,65.49 184.44,65.1 JDIMM2.17
DDR_A_D4: length 77.2
  TOP w0.102: v2(197.06,118.31) 196.59,118.78 JCPU1.AT15
  TOP w0.14: JDIMM1.5 188.04,70.52 189.38,69.18 v2(189.51,69.18)
  IN1 w0.147: v2(197.06,118.31) 197.15,118.39 198.11,118.39 198.23,118.52 199.66,118.52 205.34,112.83 205.34,82.44 198.92,76.02 198.92,75.81 199.23,75.49 199.23,75.29 199.03,75.08 198.82,75.08 198.5,75.39 198.3,75.39 198.09,75.18 198.09,74.97 198.4,74.66 198.4,74.45 198.05,74.11 197.85,74.11 197.53,74.42 197.33,74.42 197.12,74.21 197.12,74 197.43,73.69 197.43,73.48 197.22,73.27 197.01,73.27 196.5,73.79 196.28,73.79 196.08,73.59 196.08,73.37 196.6,72.86 196.6,72.65 193.29,69.35 190.52,69.35 190.3,69.12 189.57,69.12 v2(189.51,69.18)
  BOTTOM w0.14: JDIMM2.4 188.34,70.32 188.84,69.81 190.14,69.81 190.29,69.66 190.29,69.31 190.14,69.15 189.53,69.15 v2(189.51,69.18)
DDR_A_D5: length 78.6
  TOP w0.102: JCPU1.AR14 195.59,117.78 v2(196.06,117.31)
  TOP w0.14: v2(188.52,66.69) 188.52,66.73 187.99,66.2 187.99,65.46 187.74,65.21 JDIMM1.6
  IN1 w0.147: v2(196.06,117.31) 196.52,117.77 197.4,117.77 197.59,117.97 199.66,117.97 204.95,112.68 204.95,82.59 196.54,74.18 195.83,74.18 195.2,73.55 195.2,73.34 195.84,72.7 195.84,72.49 195.63,72.29 195.42,72.29 194.78,72.92 194.57,72.92 194.37,72.72 194.37,72.51 195,71.87 195,71.66 193.14,69.79 190.35,69.79 190.21,69.66 189.24,69.66 189.06,69.47 189.06,68.98 189.33,68.71 189.33,68.17 189.1,67.94 189.1,67.06 188.72,66.69 v2(188.52,66.69)
  BOTTOM w0.14: v2(188.52,66.69) 188.52,66.73 188.63,66.84 188.63,67.4 188.48,67.56 188.11,67.56 187.96,67.4 187.96,67.06 187.4,66.5 187.4,65.13 187.44,65.09 JDIMM2.7
DDR_A_D6: length 82.2
  TOP w0.102: v2(194.06,118.31) 193.59,118.78 JCPU1.AN15
  TOP w0.14: JDIMM1.17 184.44,69.47 v2(185.15,68.76)
  IN1 w0.089: 197.41,114.92 192.86,114.92 192.62,115.16 192.62,117.58 192.97,117.92 193.67,117.92 v2(194.06,118.31)
  IN1 w0.147: v2(185.15,68.76) 185.39,68.52 185.62,68.52 185.77,68.66 185.77,69.51 188.29,72.03 189.2,72.03 189.29,72.12 190.22,72.12 199.24,81.13 199.24,81.6 199.11,81.72 199.11,81.94 199.35,82.18 199.57,82.18 199.93,81.82 200.15,81.82 200.35,82.02 200.35,82.23 199.98,82.6 199.98,82.81 200.19,83.02 200.4,83.02 200.77,82.65 200.98,82.65 201.19,82.85 201.19,83.07 200.81,83.44 200.81,83.65 201.02,83.86 201.23,83.86 201.6,83.48 201.82,83.48 202.02,83.68 202.02,83.9 201.65,84.26 201.65,84.48 201.91,84.74 202.13,84.74 202.24,84.63 202.45,84.63 202.61,84.79 202.61,111.72 199.41,114.92 197.41,114.92
  BOTTOM w0.14: JDIMM2.18 184.14,71.26 184.34,71.06 184.34,70.79 184.49,70.64 184.59,70.64 184.75,70.49 184.75,70.21 184.59,70.06 184.49,70.06 184.34,69.91 184.34,69.62 184.49,69.47 184.56,69.47 184.71,69.31 184.71,69.05 184.56,68.9 184.49,68.9 184.34,68.75 184.34,68.55 184.49,68.4 185,68.4 185.15,68.55 v2(185.15,68.76)
DDR_A_D7: length 81.2
  TOP w0.102: v2(193.06,118.31) 192.59,118.78 JCPU1.AM15
  TOP w0.14: JDIMM1.15 185.04,70.39 v2(185.15,70.28)
  IN1 w0.089: 195.52,114.47 195.26,114.73 192.64,114.73 192.43,114.94 192.43,117.83 192.91,118.31 v2(193.06,118.31)
  IN1 w0.147: v2(185.15,70.28) 185.15,70.1 185.34,69.91 185.56,69.91 188.1,72.45 189.07,72.45 190.43,73.81 190.63,73.81 190.89,73.55 191.1,73.55 191.31,73.76 191.31,73.97 191.05,74.23 191.05,74.43 191.26,74.64 191.47,74.64 191.73,74.38 191.94,74.38 192.14,74.59 192.14,74.8 191.89,75.06 191.89,75.27 192.09,75.48 192.3,75.48 192.56,75.22 192.77,75.22 192.98,75.43 192.98,75.63 192.72,75.89 192.72,76.1 192.93,76.31 193.14,76.31 193.39,76.05 193.6,76.05 193.81,76.26 193.81,76.47 193.55,76.73 193.55,76.94 193.76,77.14 193.97,77.14 194.23,76.89 194.44,76.89 194.64,77.09 194.64,77.3 194.39,77.56 194.39,77.77 194.59,77.98 194.8,77.98 195.06,77.72 195.27,77.72 195.48,77.93 195.48,78.14 195.22,78.39 195.22,78.6 195.43,78.81 195.64,78.81 195.9,78.55 196.1,78.55 196.31,78.76 196.31,78.97 196.05,79.23 196.05,79.44 196.26,79.64 196.47,79.64 196.73,79.39 196.94,79.39 197.15,79.59 197.15,79.8 196.89,80.06 196.89,80.27 197.1,80.48 197.3,80.48 197.56,80.22 197.77,80.22 197.98,80.43 197.98,80.64 197.72,80.9 197.72,81.1 197.93,81.31 198.14,81.31 198.4,81.05 198.6,81.05 198.81,81.26 198.81,81.47 198.55,81.73 198.55,81.94 202.22,85.61 202.22,111.56 199.31,114.47 195.52,114.47
  BOTTOM w0.14: v2(185.15,70.28) 185.15,70.07 185.31,69.92 185.62,69.92 185.77,70.07 185.77,70.87 185.62,71.02 184.85,71.02 184.74,71.14 JDIMM2.16
DDR_A_D8: length 70.8
  TOP w0.102: v2(193.06,112.31) 192.59,112.78 JCPU1.AM9
  TOP w0.14: v2(183.15,68.81) 183.6,69.26 183.6,70.84 183.24,71.2 JDIMM1.21
  IN1 w0.089: 195.58,114.02 195.47,113.91 194.79,113.91 194.49,113.61 194.49,113.21 194.01,112.73 193.48,112.73 v2(193.06,112.31)
  IN1 w0.147: v2(183.15,68.81) 183.34,68.61 184.2,68.61 184.68,69.09 184.68,70.45 184.99,70.75 185.62,70.75 187.77,72.9 188.86,72.9 201.77,85.81 201.77,110.38 198.13,114.02 195.58,114.02
  BOTTOM w0.14: v2(183.15,68.81) 183.12,68.81 183.56,69.24 183.56,70.45 182.94,71.06 JDIMM2.22
DDR_A_D9: length 68.9
  TOP w0.102: v2(194.06,112.31) 193.59,112.78 JCPU1.AN9
  TOP w0.14: v2(183.15,70.05) 182.64,70.56 JDIMM1.23
  IN1 w0.089: 197.84,113.5 197.76,113.5 197.55,113.72 194.87,113.72 194.68,113.53 194.68,112.4 194.53,112.25 194.12,112.25 v2(194.06,112.31)
  IN1 w0.147: 197.84,113.5 198.09,113.5 201.38,110.21 201.38,85.97 201.04,85.64 200.84,85.64 200.79,85.68 200.58,85.68 200.37,85.47 200.37,85.27 200.42,85.22 200.42,85.01 200.21,84.8 200,84.8 199.96,84.85 199.75,84.85 199.54,84.64 199.54,84.43 199.59,84.39 199.59,84.18 199.38,83.97 199.17,83.97 199.12,84.02 198.92,84.02 198.71,83.81 198.71,83.6 198.75,83.55 198.75,83.35 198.54,83.14 198.34,83.14 198.29,83.18 198.08,83.18 197.87,82.97 197.87,82.77 197.92,82.72 197.92,82.51 188.7,73.29 187.6,73.29 185.46,71.14 184.81,71.14 184.1,70.43 184.1,69.91 184.29,69.72 184.29,69.27 184.02,69 183.72,69 183.6,69.13 183.6,70.14 183.46,70.27 183.31,70.27 183.15,70.11 v2(183.15,70.05)
  BOTTOM w0.14: v2(183.15,70.05) 183.12,70.05 182.34,70.84 JDIMM2.24
DDR_A_D10: length 67.9
  TOP w0.102: JCPU1.AM8 192.59,111.78 v2(193.06,111.31)
  TOP w0.14: v2(179.47,66.04) 178.74,65.31 JDIMM1.36
  IN1 w0.147: v2(179.47,66.04) 179.38,66.04 179.2,65.86 179.2,64.34 179.05,64.19 178.64,64.19 178.41,64.43 178.41,65.29 178.54,65.43 178.54,66.8 178.68,66.94 178.68,68.62 179.04,68.98 179.04,70.4 182.92,74.28 184.11,74.28 186.25,76.42 186.85,76.42 197.88,87.44 197.88,101.76 198.28,102.16 198.28,102.91 197.93,103.26 197.93,105.62 197.6,105.94 197.6,108.45 197.33,108.73 196.87,108.73 196.59,109 196.59,109.56 196.26,109.89 194.87,109.89 194.61,110.15 194.61,110.53 194.31,110.83 193.85,110.83 193.38,111.31 v2(193.06,111.31)
  BOTTOM w0.14: JDIMM2.35 179.04,65.61 v2(179.47,66.04)
DDR_A_D11: length 68.8
  TOP w0.102: JCPU1.AN8 193.59,111.78 v2(194.06,111.31)
  TOP w0.14: JDIMM1.34 179.34,65.27 180.02,65.95 180.02,66.83 v2(179.48,67.37)
  IN1 w0.089: v2(194.06,111.31) 194.49,111.31 194.89,110.91 195.2,110.91 195.87,111.58 197.38,111.58 197.79,111.18 197.79,110.94 197.84,110.89
  IN1 w0.147: 197.84,110.89 199.45,109.28 199.45,87.36 195.73,83.64 195.73,83.1 187.88,75.25 186.73,75.25 184.59,73.11 184.01,73.11 183.15,72.25 182.54,72.25 181.02,70.73 181.02,69.83 180.84,69.65 180.58,69.65 180.4,69.47 180.4,66.7 180.25,66.55 180.08,66.55 179.93,66.71 179.93,67.28 179.77,67.43 179.55,67.43 v2(179.48,67.37)
  BOTTOM w0.14: JDIMM2.33 179.64,65.32 180,65.67 180,66.86 v2(179.48,67.37)
DDR_A_D12: length 68.3
  TOP w0.102: v2(196.04,112.38) 195.59,112.83 JCPU1.AR9
  TOP w0.14: JDIMM1.24 182.34,65.04 182.7,65.4 182.7,67.11 v2(183.15,67.56)
  IN1 w0.147: v2(183.15,67.56) 183.16,67.55 183.16,67.33 182.59,66.75 182.38,66.75 182.24,66.9 182.24,67.1 182.69,67.56 182.69,70.21 183.16,70.68 183.78,70.68 184.63,71.53 185.3,71.53 187.44,73.68 188.54,73.68 197.28,82.42 197.28,82.97 200.99,86.69 200.99,110.04 198.14,112.89 196.54,112.89 v2(196.04,112.38)
  BOTTOM w0.14: v2(183.15,67.56) 183.15,67.25 182.64,66.74 JDIMM2.23
DDR_A_D13: length 65.8
  TOP w0.102: JCPU1.AT9 196.68,112.84 v2(197.14,112.39)
  TOP w0.14: v2(183.15,66.04) 183.12,66.01 183.12,65.21 182.94,65.02 JDIMM1.22
  IN1 w0.147: v2(197.14,112.39) 197.16,112.41 198.07,112.41 200.61,109.87 200.61,86.85 196.89,83.13 196.89,82.58 188.37,74.07 187.19,74.07 185.07,71.95 184.49,71.95 183.62,71.08 183.01,71.08 182.3,70.37 182.3,67.72 181.59,67 181.59,65.32 181.92,64.99 182.76,64.99 183.09,65.32 183.09,65.99 v2(183.15,66.04)
  BOTTOM w0.14: v2(183.15,66.04) 183.12,66.04 183.24,65.92 JDIMM2.21
DDR_A_D14: length 67.6
  TOP w0.102: v2(196.03,111.19) 195.59,111.63 JCPU1.AR8
  TOP w0.14: v2(179.47,68.91) 179.04,69.34 JDIMM1.35
  IN1 w0.089: v2(196.03,111.19) 196.16,111.32 197.37,111.32 197.6,111.1 197.6,110.71 197.79,110.52 197.79,110.17 197.84,110.12
  IN1 w0.147: 197.84,110.12 199.06,108.9 199.06,87.52 195.25,83.71 195.25,83.5 195.29,83.46 195.29,83.24 195.09,83.04 194.88,83.04 194.83,83.09 194.63,83.09 194.35,82.81 194.35,82.6 194.41,82.54 194.41,82.33 194.2,82.12 193.99,82.12 193.93,82.18 193.72,82.18 193.51,81.97 193.51,81.76 193.57,81.7 193.57,81.5 193.36,81.29 193.16,81.29 193.1,81.35 192.89,81.35 192.68,81.14 192.68,80.93 192.74,80.87 192.74,80.66 192.53,80.45 192.32,80.45 192.26,80.51 192.05,80.51 191.85,80.3 191.85,80.1 191.91,80.04 191.91,79.83 191.7,79.62 191.49,79.62 191.43,79.68 191.22,79.68 191.01,79.47 191.01,79.26 191.07,79.2 191.07,78.99 187.72,75.64 186.57,75.64 184.43,73.5 183.24,73.5 183.07,73.33 183.07,73.12 183.16,73.04 183.16,72.81 183,72.65 182.77,72.65 182.68,72.75 182.49,72.75 180.63,70.89 180.63,70.22 180.45,70.04 180.16,70.04 180.01,69.89 180.01,67.97 179.86,67.82 179.23,67.82 179.07,67.97 179.07,68.45 179.47,68.84 v2(179.47,68.91)
  BOTTOM w0.14: v2(179.47,68.91) 178.74,69.64 JDIMM2.36
DDR_A_D15: length 65.4
  TOP w0.102: v2(197.22,110.95) 197.22,111.1 196.59,111.73 JCPU1.AT8
  TOP w0.14: v2(179.47,70.09) 179.64,70.26 JDIMM1.33
  IN1 w0.089: 197.84,109.56 197.55,109.86 197.55,110.44 197.22,110.77 v2(197.22,110.95)
  IN1 w0.147: v2(179.47,70.09) 179.47,70.27 179.64,70.43 180.09,70.43 180.24,70.58 180.24,71.05 183.08,73.89 184.27,73.89 186.41,76.03 187.02,76.03 187.29,76.3 187.46,76.3 187.53,76.23 187.74,76.23 187.9,76.39 187.9,76.6 187.84,76.66 187.84,76.85 187.97,76.98 188.16,76.98 188.23,76.92 188.44,76.92 188.68,77.15 188.68,77.37 188.63,77.42 188.63,77.64 188.79,77.79 189,77.79 189.05,77.75 189.25,77.75 189.4,77.89 189.4,78.1 189.35,78.14 189.35,78.36 189.54,78.55 189.75,78.55 189.8,78.5 190.02,78.5 190.2,78.68 190.2,78.9 190.15,78.94 190.15,79.16 198.64,87.65 198.64,87.92 198.49,88.07 198.38,88.07 198.26,88.19 198.26,88.55 198.41,88.7 198.52,88.7 198.67,88.84 198.67,89.14 198.52,89.29 198.41,89.29 198.26,89.43 198.26,89.73 198.41,89.87 198.52,89.87 198.67,90.02 198.67,90.32 198.52,90.46 198.41,90.46 198.26,90.61 198.26,90.91 198.41,91.05 198.52,91.05 198.67,91.2 198.67,91.5 198.52,91.64 198.41,91.64 198.26,91.79 198.26,92.08 198.41,92.23 198.52,92.23 198.67,92.38 198.67,92.67 198.52,92.82 198.41,92.82 198.26,92.97 198.26,93.26 198.41,93.41 198.52,93.41 198.67,93.56 198.67,93.85 198.52,94 198.41,94 198.26,94.15 198.26,94.44 198.41,94.59 198.52,94.59 198.67,94.74 198.67,95.03 198.52,95.18 198.41,95.18 198.26,95.33 198.26,95.62 198.41,95.77 198.52,95.77 198.67,95.91 198.67,96.21 198.52,96.36 198.41,96.36 198.26,96.5 198.26,96.8 198.41,96.95 198.52,96.95 198.67,97.09 198.67,97.39 198.52,97.54 198.41,97.54 198.26,97.68 198.26,97.98 198.41,98.12 198.52,98.12 198.67,98.27 198.67,98.57 198.52,98.71 198.41,98.71 198.26,98.86 198.26,99.16 198.41,99.3 198.52,99.3 198.67,99.45 198.67,99.75 198.52,99.89 198.41,99.89 198.26,100.04 198.26,100.33 198.41,100.48 198.52,100.48 198.67,100.63 198.67,100.92 198.52,101.07 198.41,101.07 198.26,101.22 198.26,101.59 198.67,102 198.67,103.7 198.39,103.98 198.39,104.29 198.67,104.57 198.67,104.88 198.39,105.16 198.39,105.34 198.67,105.62 198.67,106.19 198.52,106.34 198.3,106.34 198.15,106.49 198.15,106.78 198.3,106.93 198.52,106.93 198.67,107.08 198.67,107.41 198.52,107.56 198.29,107.56 198.14,107.71 198.14,108.01 198.29,108.16 198.52,108.16 198.67,108.32 198.67,108.66 198.47,108.85 198.19,108.85 198.04,109 198.04,109.36 197.84,109.56
  BOTTOM w0.14: v2(179.47,70.09) 179.34,70.23 JDIMM2.34
DDR_A_D16: length 67.6
  TOP w0.102: JCPU1.AJ9 189.59,112.78 v2(190.06,112.31)
  TOP w0.14: v2(177.38,67.7) 177.26,67.7 176.88,67.32 176.88,66.05 176.94,65.99 JDIMM1.42
  IN1 w0.089: 196.75,105.55 196.47,105.82 196.47,107.44 196.2,107.72 195.78,107.72 195.46,108.03 195.46,108.48 195.23,108.71 194.76,108.71 194.46,109.01 194.46,109.48 194.23,109.71 193.81,109.71 193.46,110.06 193.46,110.48 193.23,110.71 192.82,110.71 192.46,111.07 192.46,111.49 192.24,111.71 191.73,111.71 191.37,112.07 190.3,112.07 v2(190.06,112.31)
  IN1 w0.147: 196.75,105.55 197.04,105.26 197.04,87.8 186.49,77.26 185.9,77.26 183.76,75.12 182.57,75.12 178.2,70.75 178.2,69.33 177.77,68.91 177.77,68.72 177.84,68.65 177.84,67.93 177.55,67.63 177.45,67.63 v2(177.38,67.7)
  BOTTOM w0.14: JDIMM2.41 177.24,65.01 176.87,65.38 176.87,67.03 177.04,67.2 177.04,67.36 v2(177.38,67.7)
DDR_A_D17: length 64.4
  TOP w0.102: v2(191.03,112.45) 190.98,112.45 JCPU1.AK9
  TOP w0.14: JDIMM1.40 177.54,65.41 177.62,65.49 177.62,65.73 v2(177.37,65.98)
  IN1 w0.089: 197.1,105.75 196.67,106.19 196.67,107.52 196.28,107.91 195.92,107.91 195.65,108.18 195.65,108.55 195.3,108.9 194.94,108.9 194.65,109.19 194.65,109.55 194.3,109.9 193.9,109.9 193.65,110.15 193.65,110.55 193.3,110.9 192.93,110.9 192.65,111.18 192.65,111.57 192.32,111.9 191.93,111.9 191.38,112.45 v2(191.03,112.45)
  IN1 w0.147: v2(177.37,65.98) 177.4,65.98 178.23,67.75 178.23,68.81 178.59,69.16 178.59,70.59 182.73,74.73 183.92,74.73 186.07,76.87 186.66,76.87 197.42,87.64 197.42,105.43 197.1,105.75
  BOTTOM w0.14: v2(177.37,65.98) 177.84,65.51 JDIMM2.39
DDR_A_D18: length 65.1
  TOP w0.102: JCPU1.AJ6 189.59,109.78 v2(190.06,109.31)
  TOP w0.14: JDIMM1.52 173.94,67.02 v2(174.39,67.47)
  IN1 w0.089: v2(190.06,109.31) 190.53,109.31 191.1,108.74 192.24,108.74 192.49,108.49 192.49,108.07 192.87,107.7 193.24,107.7 193.43,107.5 193.43,103.91 193.65,103.7
  IN1 w0.147: 193.65,103.7 194.71,102.63 194.71,89.46 182.73,77.49 181.62,77.49 175.83,71.7 175.83,69.69 175.64,69.5 175.43,69.5 174.9,68.97 174.9,68.15 174.71,67.96 174.14,67.96 173.35,67.17 173.35,66.79 173.49,66.65 173.68,66.65 173.83,66.8 173.83,66.91 v2(174.39,67.47)
  BOTTOM w0.14: JDIMM2.53 173.64,64.97 173.86,65.19 173.86,66.73 v2(174.39,67.47)
DDR_A_D19: length 62.9
  TOP w0.102: v2(191.06,109.31) 190.59,109.78 JCPU1.AK6
  TOP w0.14: JDIMM1.50 174.54,66.02 v2(174.39,66.18)
  IN1 w0.089: v2(191.06,109.31) 191.44,108.93 192.32,108.93 192.68,108.57 192.68,108.15 192.94,107.9 193.3,107.9 193.66,107.54 193.66,104.14 193.93,103.87 194.03,103.87 194.11,103.8
  IN1 w0.147: 194.11,103.8 195.1,102.8 195.1,89.3 182.89,77.1 181.78,77.1 176.22,71.54 176.22,69.34 175.99,69.11 175.59,69.11 175.29,68.81 175.29,65.19 175.16,65.06 174.45,65.06 174.27,65.24 174.27,66.06 v2(174.39,66.18)
  BOTTOM w0.14: v2(174.39,66.18) 174.24,66.03 JDIMM2.51
DDR_A_D20: length 65.8
  TOP w0.102: JCPU1.AJ10 189.57,113.84 v2(189.06,113.33)
  TOP w0.14: v2(177.38,70.75) 177.33,70.75 177.14,70.95 177.14,71.22 177.24,71.32 JDIMM1.41
  IN1 w0.089: 195.6,104.59 195.47,104.72 195.47,107.49 195.25,107.71 194.8,107.71 194.46,108.05 194.46,108.48 194.23,108.71 193.81,108.71 193.46,109.06 193.46,109.48 193.23,109.71 192.82,109.71 192.46,110.07 192.46,110.48 192.23,110.71 191.82,110.71 191.46,111.07 191.46,111.44 191.21,111.68 189.82,111.68 189.43,112.07 189.43,113.01 189.11,113.33 v2(189.06,113.33)
  IN1 w0.147: 195.6,104.59 196.26,103.93 196.26,88.82 194.74,87.3 194.74,87.14 194.89,86.99 194.89,86.76 194.72,86.6 194.49,86.6 194.37,86.72 194.17,86.72 194.03,86.57 194.03,86.37 194.17,86.23 194.17,86.04 194.03,85.89 193.83,85.89 193.68,86.05 193.48,86.05 193.35,85.91 193.35,85.72 193.49,85.57 193.49,85.37 193.35,85.23 193.15,85.23 193.01,85.37 192.81,85.37 192.67,85.23 192.67,85.04 192.83,84.88 192.83,84.69 192.69,84.55 192.49,84.55 192.35,84.7 192.14,84.7 191.99,84.55 191.99,84.35 192.14,84.2 192.14,84.01 192.01,83.87 191.81,83.87 191.66,84.02 191.46,84.02 191.32,83.88 191.32,83.68 191.49,83.52 191.49,83.35 191.28,83.15 191.03,83.15 190.88,83 190.88,82.74 190.51,82.37 190.3,82.37 190.16,82.51 189.96,82.51 189.82,82.37 189.82,82.17 189.96,82.03 189.96,81.82 189.81,81.68 189.61,81.68 189.46,81.82 189.27,81.82 189.13,81.69 189.13,81.49 189.25,81.37 189.25,81.16 189.11,81.02 188.9,81.02 188.78,81.14 188.58,81.14 188.44,80.99 188.44,80.79 188.6,80.63 188.6,80.46 186.9,78.77 186.4,78.77 186.23,78.6 186.23,78.39 185.88,78.04 185.58,78.04 183.44,75.89 182.24,75.89 177.38,71.03 v2(177.38,70.75)
  BOTTOM w0.14: JDIMM2.42 176.94,71.2 177.39,70.75 v2(177.38,70.75)
DDR_A_D21: length 66.3
  TOP w0.102: v2(190.06,113.33) 190.57,113.84 JCPU1.AK10
  TOP w0.14: v2(177.4,69.4) 177.49,69.31 177.78,69.31 178,69.53 178,70.21 177.84,70.37 JDIMM1.39
  IN1 w0.089: 195.86,104.97 195.66,105.17 195.66,107.57 195.32,107.9 194.88,107.9 194.65,108.13 194.65,108.55 194.3,108.9 193.89,108.9 193.65,109.14 193.65,109.55 193.3,109.9 192.9,109.9 192.65,110.15 192.65,110.55 192.3,110.9 191.9,110.9 191.65,111.15 191.65,111.52 191.29,111.87 189.9,111.87 189.62,112.15 189.62,112.89 v2(190.06,113.33)
  IN1 w0.147: v2(177.4,69.4) 177.69,69.4 177.81,69.52 177.81,70.91 182.41,75.5 183.6,75.5 185.74,77.65 186.33,77.65 195.36,86.68 195.36,86.96 195.28,87.05 195.28,87.26 195.43,87.41 195.64,87.41 195.76,87.29 195.97,87.29 196.12,87.44 196.12,87.65 195.98,87.79 195.98,87.97 196.18,88.17 196.53,88.17 196.65,88.29 196.65,104.18 195.86,104.97
  BOTTOM w0.14: v2(177.4,69.4) 177.41,69.4 177.8,69.79 177.8,71 177.54,71.26 JDIMM2.40
DDR_A_D22: length 65.2
  TOP w0.102: JCPU1.AJ7 189.59,110.78 v2(190.06,110.31)
  TOP w0.14: JDIMM1.53 173.64,71.21 173.86,71 173.86,69.75 v2(174.39,69.22)
  IN1 w0.089: v2(190.06,110.31) 190.06,110.52 189.68,110.9 187.83,110.9 187.63,110.69 187.63,109.9 187.83,109.7 189.2,109.7 189.48,109.42 189.48,109.09 189.83,108.74 190.15,108.74 190.49,108.4 190.49,108.07 190.83,107.73 192.16,107.73 192.45,107.44 192.45,103.82
  IN1 w0.147: 192.45,103.82 193.93,102.34 193.93,89.79 182.41,78.26 181.3,78.26 175.06,72.02 175.06,71.84 174.9,71.69 174.73,71.69 173.96,70.92 173.96,69.65 v2(174.39,69.22)
  BOTTOM w0.14: JDIMM2.52 173.94,69.67 v2(174.39,69.22)
DDR_A_D23: length 63
  TOP w0.102: JCPU1.AK7 190.59,110.78 v2(191.06,110.31)
  TOP w0.14: JDIMM1.51 174.24,70.72 v2(174.39,70.57)
  IN1 w0.089: 192.95,103.84 192.64,104.15 192.64,107.53 192.25,107.93 190.91,107.93 190.68,108.15 190.68,108.76 190.51,108.93 189.9,108.93 189.67,109.17 189.67,109.62 189.37,109.92 188.64,109.92 188.49,110.07 188.49,110.39 188.78,110.69 189.3,110.69 189.57,110.42 189.57,110.2 189.86,109.91 190.66,109.91 v2(191.06,110.31)
  IN1 w0.147: v2(174.39,70.57) 174.6,70.57 174.83,70.35 174.83,70.02 175,69.84 175.24,69.84 175.45,70.05 175.45,70.68 175.29,70.84 174.88,70.84 174.75,70.97 174.75,71.15 174.88,71.28 175.29,71.28 175.45,71.43 175.45,71.86 181.46,77.87 182.57,77.87 194.32,89.62 194.32,102.47 192.95,103.84
  BOTTOM w0.14: v2(174.39,70.57) 174.54,70.72 JDIMM2.50
DDR_A_D24: length 64.4
  TOP w0.102: JCPU1.AF4 v2(187.06,108.31)
  TOP w0.14: JDIMM1.58 172.14,64.95 171.86,65.23 171.86,66.87 v2(172.28,67.28)
  IN1 w0.089: 193.09,102.09 193.09,102.3 191.46,103.92 191.46,106.44 191.16,106.74 190.82,106.74 190.49,107.08 190.49,107.42 190.18,107.72 189.84,107.72 189.48,108.08 189.48,108.42 189.21,108.69 187.88,108.69 v2(187.06,108.31)
  IN1 w0.147: 193.09,102.09 193.09,90.13 182.06,79.1 180.95,79.1 173.1,71.25 173.1,69.32 173.46,68.96 173.46,68.46 v2(172.28,67.28)
  BOTTOM w0.14: v2(172.28,67.28) 172.28,67.15 171.93,66.79 171.51,66.79 171.39,66.68 171.39,66.45 171.54,66.29 171.79,66.29 171.94,66.14 171.94,65.99 171.79,65.83 171.61,65.83 171.45,65.68 171.45,65.54 171.6,65.39 171.89,65.39 172,65.28 172,65.17 171.84,65.01 JDIMM2.59
DDR_A_D25: length 63.5
  TOP w0.102: JCPU1.AF5 v2(187.06,109.31)
  TOP w0.14: JDIMM1.56 172.74,65.3 v2(172.28,65.76)
  IN1 w0.089: 193.48,102.11 193.48,102.25 191.65,104.08 191.65,106.61 191.33,106.93 190.9,106.93 190.68,107.16 190.68,107.62 190.39,107.91 189.92,107.91 189.67,108.16 189.67,108.57 189.31,108.93 187.43,108.93 v2(187.06,109.31)
  IN1 w0.147: 193.48,102.11 193.48,89.97 182.22,78.72 181.11,78.72 173.49,71.09 173.49,69.49 173.89,69.08 173.89,68.34 172.73,67.18 172.73,66.21 v2(172.28,65.76)
  BOTTOM w0.14: JDIMM2.57 172.44,65.15 173.08,65.79 173.08,66.01 172.86,66.22 172.65,66.22 172.28,65.85 v2(172.28,65.76)
DDR_A_D26: length 59.4
  TOP w0.102: JCPU1.AF1 186.59,104.78 v2(187.06,104.31)
  TOP w0.14: JDIMM1.70 168.54,64.98 v2(169.43,65.87)
  IN1 w0.089: v2(187.06,104.31) 189.39,101.98
  IN1 w0.147: v2(169.43,65.87) 169.52,65.78 169.52,65.01 169.19,64.68 168.63,64.68 168.48,64.83 168.48,65.13 168.66,65.3 168.83,65.3 168.95,65.43 168.95,65.71 168.83,65.84 168.54,65.84 168.41,65.97 168.41,66.31 168.54,66.44 168.8,66.44 168.93,66.57 168.93,66.83 168.8,66.96 168.76,66.96 168.63,67.08 168.63,67.4 168.76,67.52 168.87,67.52 169,67.66 169,70.62 169.82,71.44 169.82,72.38 179.66,82.23 180.02,82.23 185.25,87.45 185.25,87.64 189.58,91.97 189.58,101.79 189.39,101.98
  BOTTOM w0.14: JDIMM2.69 168.84,65.16 168.58,65.42 168.27,65.42 168.15,65.54 168.15,65.87 168.27,66 169.3,66 v2(169.43,65.87)
DDR_A_D27: length 62
  TOP w0.102: JCPU1.AF2 186.59,105.78 v2(187.06,105.31)
  TOP w0.14: v2(169.43,67.39) 169.85,66.97 169.85,65.57 169.14,64.86 JDIMM1.68
  IN1 w0.089: 188.97,103.87 188.66,104.19 188.66,105.24 188.21,105.68 187.43,105.68 v2(187.06,105.31)
  IN1 w0.147: v2(169.43,67.39) 169.74,67.39 169.87,67.27 169.87,66.75 170.04,66.58 170.28,66.58 170.45,66.75 170.45,68.02 170.58,68.15 170.58,68.44 171.11,68.97 171.11,72.02 180.15,81.06 180.51,81.06 183.57,84.12 184.26,84.12 190.81,90.67 190.81,102.04 188.97,103.87
  BOTTOM w0.14: JDIMM2.67 169.44,65.09 169.92,65.57 169.92,66.2 169.77,66.36 168.79,66.36 168.64,66.51 168.64,67.24 168.79,67.39 v2(169.43,67.39)
DDR_A_D28: length 62.6
  TOP w0.102: JCPU1.AG4 187.59,107.78 v2(188.06,107.31)
  TOP w0.14: JDIMM1.59 171.84,70.97 171.73,70.85 171.73,70.23 171.88,70.08 172.13,70.08 172.28,70.23 v2(172.28,70.33)
  IN1 w0.089: 191.79,102.71 190.49,104.01 190.49,106.49 190.26,106.72 189.76,106.72 189.43,107.04 189.43,107.51 189.25,107.69 188.44,107.69 v2(188.06,107.31)
  IN1 w0.147: 191.79,102.71 191.97,102.53 191.97,101.72 192.07,101.62 192.16,101.62 192.31,101.46 192.31,101.24 192.16,101.09 192.12,101.09 191.97,100.94 191.97,100.68 192.07,100.58 192.18,100.58 192.31,100.44 192.31,100.25 192.18,100.12 192.12,100.12 191.97,99.97 191.97,99.77 192.12,99.62 192.17,99.62 192.31,99.48 192.31,99.29 192.17,99.15 192.12,99.15 191.97,98.99 191.97,98.79 192.12,98.64 192.17,98.64 192.31,98.49 192.31,98.29 192.17,98.14 192.12,98.14 191.97,97.99 191.97,97.8 192.09,97.68 192.17,97.68 192.31,97.54 192.31,97.35 192.17,97.21 192.08,97.21 191.97,97.1 191.97,96.91 192.12,96.76 192.17,96.76 192.3,96.62 192.3,96.43 192.17,96.29 192.12,96.29 191.97,96.14 191.97,95.98 192.12,95.83 192.17,95.83 192.31,95.69 192.31,95.49 192.17,95.35 192.12,95.35 191.97,95.2 191.97,95.03 192.12,94.88 192.17,94.88 192.3,94.75 192.3,94.55 192.17,94.42 192.11,94.42 191.97,94.28 191.97,94.09 192.11,93.95 192.18,93.95 192.31,93.82 192.31,93.62 192.18,93.49 192.1,93.49 191.97,93.35 191.97,93.16 192.1,93.02 192.16,93.02 192.31,92.88 192.31,92.67 192.16,92.53 192.12,92.53 191.97,92.38 191.97,90.13 184.78,82.94 184.04,82.94 182.37,81.28 182.37,81.08 182.56,80.89 182.56,80.7 182.42,80.56 182.23,80.56 182.04,80.75 181.85,80.75 181.71,80.62 181.71,80.43 181.91,80.23 181.91,80.05 181.78,79.92 181.6,79.92 181.4,80.12 181.21,80.12 180.97,79.88 180.63,79.88 172.28,71.53 v2(172.28,70.33)
  BOTTOM w0.14: JDIMM2.58 172.14,71.02 171.99,70.86 171.48,70.86 171.33,70.71 171.33,69.59 171.48,69.44 171.71,69.44 171.87,69.59 171.87,70.18 172.02,70.33 v2(172.28,70.33)
DDR_A_D29: length 65
  TOP w0.102: v2(188.06,108.31) 187.59,108.78 JCPU1.AG5
  TOP w0.14: JDIMM1.57 172.44,71.08 172.7,70.82 172.7,69.23 v2(172.28,68.81)
  IN1 w0.089: v2(188.06,108.31) 188.05,108.32 187.73,108.32 187.57,108.17 187.57,107.95 187.73,107.8 188.24,107.8 188.32,107.88 189.33,107.88 189.62,107.59 189.62,107.12 189.84,106.91 190.34,106.91 190.68,106.57 190.68,104.15 192.7,102.13 192.7,101.92
  IN1 w0.147: 192.7,101.92 192.7,92.18 192.55,92.03 192.5,92.03 192.36,91.89 192.36,91.68 192.5,91.54 192.55,91.54 192.7,91.38 192.7,91.18 192.55,91.03 192.5,91.03 192.37,90.89 192.37,90.7 192.5,90.56 192.6,90.56 192.7,90.46 192.7,90.3 181.9,79.49 180.79,79.49 172.71,71.41 172.71,69.16 173.06,68.81 173.06,68.62 172.86,68.42 172.49,68.42 172.28,68.64 v2(172.28,68.81)
  BOTTOM w0.14: JDIMM2.56 172.74,69.45 173.62,68.57 173.62,68.35 173.29,68.02 173.07,68.02 v2(172.28,68.81)
DDR_A_D30: length 60
  TOP w0.102: v2(188.06,104.31) 187.59,104.78 JCPU1.AG1
  TOP w0.14: JDIMM1.69 168.84,69.51 v2(169.43,68.92)
  IN1 w0.147: v2(169.43,68.92) 169.43,68.77 169.73,68.46 170.06,68.46 170.72,69.13 170.72,70.58 170.48,70.82 170.48,71 170.6,71.12 170.6,72.06 179.99,81.45 180.35,81.45 183.41,84.51 184.07,84.51 185.65,86.1 185.65,86.31 185.54,86.42 185.54,86.62 185.68,86.76 185.88,86.76 186,86.63 186.22,86.63 186.89,87.3 186.89,87.52 186.69,87.71 186.69,87.91 186.83,88.05 187.02,88.05 187.22,87.85 187.43,87.85 188.1,88.51 188.1,88.73 187.87,88.95 187.87,89.14 188.01,89.28 188.2,89.28 188.43,89.06 188.64,89.06 189.31,89.73 189.31,89.94 189.09,90.17 189.09,90.37 189.23,90.51 189.42,90.51 189.61,90.33 189.86,90.33 190.38,90.85 190.38,101.83 188.06,104.15 v2(188.06,104.31)
  BOTTOM w0.14: v2(169.43,68.92) 169.43,69.05 169.26,69.22 169.04,69.22 168.91,69.1 168.91,68.72 168.76,68.57 168.46,68.57 168.31,68.72 168.31,69.23 168.07,69.47 168.07,70.86 168.54,71.33 JDIMM2.70
DDR_A_D31: length 59.7
  TOP w0.102: JCPU1.AG2 187.59,105.78 v2(188.06,105.31)
  TOP w0.14: v2(169.43,70.44) 169.44,70.46 JDIMM1.67
  IN1 w0.089: 189.69,102.05 187.68,104.05 187.68,105.19 187.8,105.31 v2(188.06,105.31)
  IN1 w0.147: v2(169.43,70.44) 169.71,70.44 169.86,70.29 169.86,69.29 170,69.15 170.19,69.15 170.33,69.29 170.33,70.42 170.01,70.74 170.01,71.08 170.21,71.28 170.21,72.22 179.83,81.84 180.18,81.84 183.25,84.9 183.64,84.9 183.74,85 183.74,85.37 183.87,85.5 184.05,85.5 184.18,85.36 184.36,85.36 184.48,85.48 184.48,85.65 184.33,85.8 184.33,85.98 184.46,86.1 184.64,86.1 184.78,85.97 184.97,85.97 185.11,86.11 185.11,86.31 185,86.42 185,86.64 185.66,87.3 185.88,87.3 186.01,87.17 186.21,87.17 186.35,87.31 186.35,87.51 186.13,87.73 186.13,87.95 186.79,88.61 187.01,88.61 187.23,88.39 187.42,88.39 187.56,88.52 187.56,88.72 187.33,88.94 187.33,89.16 188,89.82 188.21,89.82 188.43,89.6 188.63,89.6 188.77,89.74 188.77,89.94 188.54,90.16 188.54,90.38 189.22,91.05 189.43,91.05 189.64,90.84 189.83,90.84 189.96,90.97 189.96,91.16 189.75,91.37 189.75,91.6 189.97,91.81 189.97,101.77 189.69,102.05
  BOTTOM w0.14: v2(169.43,70.44) 169.18,70.44 169.03,70.29 169.03,69.69 168.87,69.53 168.68,69.53 168.55,69.66 168.55,70.76 169.14,71.35 JDIMM2.68
DDR_A_D32: length 62.6
  TOP w0.102: v2(169.06,104.31) JCPU1.J1
  TOP w0.14: JDIMM1.132 147.54,65.15 147.15,65.53 v2(146.86,65.53)
  IN1 w0.089: v2(169.06,104.31) 168.92,104.31 168.21,103.59 167.94,103.59 165.63,101.28 165,101.28
  IN1 w0.147: v2(146.86,65.53) 146.86,64.72 147.01,64.57 147.76,64.57 147.92,64.72 147.92,65.61 147.67,65.85 147.67,71.89 146.67,72.9 146.67,73.79 144.59,75.87 144.59,86.14 148.62,90.17 149.31,90.17 150.84,91.7 151.48,91.7 152.99,93.21 153.98,93.21 159.43,98.66 162.38,98.66 165,101.28
  BOTTOM w0.14: JDIMM2.131 147.84,65.82 147.69,65.98 147.43,65.98 147.28,65.82 147.28,65.65 147.16,65.53 v2(146.86,65.53)
DDR_A_D33: length 65.5
  TOP w0.102: v2(169.06,105.31) JCPU1.J2
  TOP w0.14: v2(146.86,67.06) 148.14,65.77 JDIMM1.130
  IN1 w0.089: v2(169.06,105.31) 168.66,104.91 168.66,104.37 168.14,103.85 167.86,103.85 165.5,101.5 164.67,101.5 164.45,101.28
  IN1 w0.147: 164.45,101.28 162.22,99.05 159.27,99.05 153.82,93.6 152.83,93.6 151.32,92.09 150.68,92.09 149.15,90.56 148.46,90.56 144.2,86.3 144.2,75.71 146.28,73.63 146.28,72.74 147.28,71.73 147.28,66.78 147.08,66.58 146.36,66.58 146.21,66.73 146.21,66.97 146.36,67.12 146.79,67.12 v2(146.86,67.06)
  BOTTOM w0.14: v2(146.86,67.06) 147,67.06 147.15,66.91 147.15,66.69 147.3,66.53 147.59,66.53 147.74,66.69 147.74,66.92 147.89,67.08 148.13,67.08 148.44,66.77 JDIMM2.129
DDR_A_D34: length 67.6
  TOP w0.102: v2(169.06,108.31) JCPU1.J5
  TOP w0.14: v2(144.02,69.85) 144.84,70.67 JDIMM1.141
  IN1 w0.089: 160.12,101.76 161.06,101.76 162.49,103.19 165.02,103.19 166.85,105.02 166.85,105.99 166.66,106.18 166.66,107.52 166.88,107.73 168.48,107.73 v2(169.06,108.31)
  IN1 w0.147: v2(144.02,69.85) 144.02,70.97 143.57,71.42 143.57,72.51 141.49,74.58 141.49,88.19 141.71,88.41 141.71,88.66 141.63,88.73 141.63,88.95 141.8,89.11 142.01,89.11 142.1,89.02 142.32,89.02 142.46,89.17 142.46,89.78 144.87,92.19 145.49,92.19 145.78,92.48 145.78,92.69 145.67,92.8 145.67,93.01 145.88,93.22 146.09,93.22 146.2,93.1 146.41,93.1 146.62,93.31 146.62,93.52 146.5,93.63 146.5,93.84 146.71,94.05 146.92,94.05 147.03,93.94 147.24,93.94 147.45,94.15 147.45,94.35 147.34,94.47 147.34,94.68 147.55,94.88 147.76,94.88 147.87,94.77 148.08,94.77 148.19,94.88 148.84,94.88 148.99,95.03 148.99,95.24 149.14,95.39 149.45,95.39 149.6,95.24 149.6,95.03 149.76,94.88 150.26,94.88 151.98,96.6 152.96,96.6 158.12,101.76 160.12,101.76
  BOTTOM w0.14: v2(144.02,69.85) 144.06,69.81 144.11,69.81 144.26,69.66 144.26,69.55 144.41,69.4 144.64,69.4 144.79,69.55 144.79,70.62 145.14,70.97 JDIMM2.140
DDR_A_D35: length 68.3
  TOP w0.102: v2(168.06,108.31) JCPU1.H5
  TOP w0.14: v2(144.02,68.58) 143.6,69 143.6,70.04 144.24,70.68 JDIMM1.143
  IN1 w0.089: v2(168.06,108.31) 167.68,107.93 166.79,107.93 166.46,107.6 166.46,106.11 166.66,105.91 166.66,105.1 164.95,103.39 162.14,103.39 160.9,102.15 160.12,102.15
  IN1 w0.147: v2(144.02,68.58) 143.59,69.01 143.59,70.84 143.18,71.26 143.18,72.34 141.1,74.42 141.1,88.99 147.42,95.31 148.52,95.31 148.98,95.78 149.91,95.78 151.13,96.99 152.8,96.99 157.96,102.15 160.12,102.15
  BOTTOM w0.14: v2(144.02,68.58) 143.3,68.58 143.15,68.73 143.15,68.96 143.3,69.11 143.41,69.11 143.56,69.27 143.56,69.99 144.54,70.97 JDIMM2.142
DDR_A_D36: length 66.2
  TOP w0.102: v2(168.06,105.31) JCPU1.H2
  TOP w0.14: JDIMM1.131 147.84,71.18 147.21,70.55 146.66,70.55 146.43,70.32 146.43,69.01 v2(146.86,68.58)
  IN1 w0.089: v2(168.06,105.31) 168.06,104.84 165.16,101.94 164.01,101.94 163.91,101.84
  IN1 w0.147: 163.91,101.84 162.96,100.89 161.89,99.82 158.94,99.82 153.5,94.37 152.5,94.37 151.01,92.88 148.93,92.88 143.42,87.38 143.42,75.39 145.5,73.31 145.5,72.42 146.01,71.91 146.01,70.65 146.43,70.23 146.43,68.52 145.92,68.02 145.92,67.82 146.07,67.67 146.27,67.67 146.86,68.26 v2(146.86,68.58)
  BOTTOM w0.14: v2(146.86,68.58) 146.95,68.48 146.95,68.34 146.8,68.19 146.56,68.19 146.4,68.34 146.4,70.25 146.68,70.53 147.39,70.53 147.54,70.67 JDIMM2.132
DDR_A_D37: length 63.3
  TOP w0.102: v2(168.06,104.31) JCPU1.H1
  TOP w0.14: JDIMM1.129 148.44,71.16 147.38,70.1 v2(146.86,70.1)
  IN1 w0.089: v2(168.06,104.31) 167.92,104.31 165.31,101.69 164.31,101.69 164.17,101.55
  IN1 w0.147: 164.17,101.55 163.8,101.18 162.06,99.43 159.11,99.43 153.66,93.99 152.67,93.99 151.16,92.48 150.52,92.48 150.36,92.31 150.07,92.31 149.89,92.49 149.68,92.49 149.52,92.33 149.52,92.11 149.73,91.9 149.73,91.69 149.58,91.53 149.37,91.53 148.85,92.05 148.65,92.05 148.51,91.91 148.51,91.71 148.99,91.22 148.99,91.11 148.83,90.95 148.56,90.95 148.23,91.28 147.9,91.28 147.76,91.14 147.76,90.94 147.92,90.78 147.92,90.57 147.73,90.38 147.51,90.38 147.37,90.52 147.16,90.52 146.96,90.33 146.96,90.11 147.1,89.98 147.1,89.76 146.94,89.6 146.72,89.6 146.56,89.76 146.36,89.76 146.22,89.61 146.22,89.41 146.37,89.26 146.37,89.04 146.17,88.84 145.95,88.84 145.82,88.97 145.56,88.97 143.81,87.22 143.81,75.55 145.89,73.47 145.89,72.58 146.86,71.61 146.86,71.44 146.7,71.29 146.56,71.29 146.4,71.14 146.4,70.9 146.56,70.75 146.73,70.75 146.88,70.59 146.88,70.13 v2(146.86,70.1)
  BOTTOM w0.14: v2(146.86,70.1) 147.36,70.1 147.48,69.98 147.48,69.58 147.63,69.43 147.99,69.43 148.14,69.58 JDIMM2.130
DDR_A_D38: length 66.6
  TOP w0.102: v2(169.06,107.31) JCPU1.J4
  TOP w0.14: JDIMM1.140 145.14,65.39 144.49,66.04 v2(144.02,66.04)
  IN1 w0.089: v2(169.06,107.31) 168.66,106.91 167.82,106.91 167.66,106.74 167.66,106.07 167.23,105.64 167.23,104.82 165.18,102.78 163.17,102.78 161.68,101.28
  IN1 w0.147: v2(144.02,66.04) 144.84,66.86 144.84,70.85 144.84,70.86 144.84,71.44 144.63,71.65 144.34,71.94 144.34,72.83 142.27,74.91 142.27,87.87 143.24,88.84 143.24,89.46 145.2,91.41 145.82,91.41 148.5,94.09 150.58,94.09 152.29,95.81 153.26,95.81 158.44,100.98 161.38,100.98 161.68,101.28
  BOTTOM w0.14: JDIMM2.141 144.84,65.05 144.69,65.21 144.35,65.21 144.2,65.36 144.2,65.56 144.33,65.69 144.64,65.69 144.76,65.81 144.76,66.02 144.49,66.29 144.27,66.29 v2(144.02,66.04)
DDR_A_D39: length 67.8
  TOP w0.102: v2(168.06,107.31) JCPU1.H4
  TOP w0.14: v2(144.02,67.31) 143.53,66.82 143.53,65.92 143.84,65.61 144.29,65.61 144.54,65.36 JDIMM1.142
  IN1 w0.089: 160.12,101.37 161.22,101.37 162.81,102.97 165.06,102.97 167.04,104.94 167.04,105.72 167.46,106.14 167.46,107.02 167.74,107.31 v2(168.06,107.31)
  IN1 w0.147: 160.12,101.37 158.28,101.37 153.1,96.2 152.13,96.2 150.43,94.49 148.35,94.49 145.66,91.8 145.03,91.8 142.85,89.62 142.85,89 141.88,88.03 141.88,74.75 143.96,72.67 143.96,71.7 144.45,71.21 144.45,67.74 v2(144.02,67.31)
  BOTTOM w0.14: v2(144.02,67.31) 143.86,67.31 143.7,67.46 143.7,67.69 143.55,67.84 143.32,67.84 143.16,67.69 143.16,67.02 143.32,66.87 143.44,66.87 143.6,66.71 143.6,65.46 144.24,64.82 JDIMM2.143
DDR_A_D40: length 66.6
  TOP w0.102: JCPU1.F2 166.53,105.84 v2(166.06,106.31)
  TOP w0.14: JDIMM1.148 142.74,65.03 141.96,65.81 v2(141.96,66.06)
  IN1 w0.089: v2(166.06,106.31) 166.06,106.24 166.47,105.83 166.47,105.18 164.88,103.59 161.7,103.59 160.71,102.6 160.12,102.6
  IN1 w0.147: 160.12,102.6 157.74,102.6 152.59,97.45 150.94,97.45 149.72,96.23 148.8,96.23 148.33,95.76 147.24,95.76 140.65,89.18 140.65,74.24 142.73,72.16 142.73,71.05 143.11,70.67 143.11,68.85 143.56,68.4 143.56,65.38 143.4,65.23 142.12,65.23 141.96,65.38 v2(141.96,66.06)
  BOTTOM w0.14: v2(141.96,66.06) 142.34,66.06 142.44,65.96 JDIMM2.149
DDR_A_D41: length 67.1
  TOP w0.102: JCPU1.F1 166.53,104.84 v2(166.06,105.31)
  TOP w0.14: v2(141.97,67.26) 142.61,66.63 142.61,65.77 143.34,65.03 JDIMM1.146
  IN1 w0.089: 160.12,102.99 160.52,102.99 161.35,103.82 164.29,103.82 165.77,105.31 v2(166.06,105.31)
  IN1 w0.147: v2(141.97,67.26) 142.3,67.26 142.45,67.11 142.45,66.27 142.6,66.11 143.02,66.11 143.17,66.27 143.17,68.24 142.73,68.68 142.73,70.4 142.34,70.79 142.34,72 140.26,74.07 140.26,89.34 147.08,96.15 148.17,96.15 148.64,96.62 149.56,96.62 150.78,97.84 152.43,97.84 157.58,102.99 160.12,102.99
  BOTTOM w0.14: v2(141.97,67.26) 142.82,66.41 142.82,65.27 143.04,65.05 JDIMM2.147
DDR_A_D42: length 66
  TOP w0.102: JCPU1.D2 164.53,105.84 v2(164.06,106.31)
  TOP w0.14: JDIMM1.160 139.14,65.44 138.74,65.85 v2(138.74,66.06)
  IN1 w0.089: v2(164.06,106.31) 164.06,106.57 163.93,106.69 163.78,106.69 163.5,106.41 163.5,106.19 163.22,105.91 162.86,105.91 162.46,105.5 162.46,105.17 162.21,104.92 160.12,104.92
  IN1 w0.147: v2(138.74,66.06) 138.74,65.84 138.89,65.69 139.66,65.69 139.81,65.84 139.81,69.25 139.96,69.39 140.06,69.39 140.2,69.54 140.2,69.84 140.06,69.98 139.96,69.98 139.81,70.13 139.81,70.43 139.96,70.57 140.06,70.57 140.2,70.72 140.2,71.02 140.06,71.16 139.96,71.16 139.81,71.31 139.81,71.69 137.9,73.6 137.9,89.75 147.97,99.82 151.6,99.82 156.7,104.92 160.12,104.92
  BOTTOM w0.14: JDIMM2.159 139.44,65.36 v2(138.74,66.06)
DDR_A_D43: length 68.5
  TOP w0.102: v2(164.06,107.31) 164.53,106.84 JCPU1.D3
  TOP w0.14: JDIMM1.158 139.74,65.41 139.18,65.98 139.18,67.14 v2(138.74,67.58)
  IN1 w0.089: v2(164.06,107.31) 164.57,107.31 164.7,107.44 164.7,107.69 164.57,107.81 163.59,107.81 163.47,107.69 163.47,106.99 163.27,106.79 162.86,106.79 162.66,106.59 162.66,106.01 162.36,105.7 161.8,105.7 161.41,105.31 160.12,105.31
  IN1 w0.147: 160.12,105.31 156.54,105.31 151.44,100.21 147.72,100.21 137.51,90.01 137.51,73.43 139.42,71.53 139.42,68.27 v2(138.74,67.58)
  BOTTOM w0.14: v2(138.74,67.58) 139.39,66.93 139.39,66.12 140.04,65.47 JDIMM2.157
DDR_A_D44: length 66.3
  TOP w0.102: JCPU1.D1 164.53,104.84 v2(164.06,105.31)
  TOP w0.14: v2(141.96,68.85) 141.49,69.33 141.49,70.26 142.44,71.21 JDIMM1.149
  IN1 w0.089: 160.12,103.76 160.19,103.76 160.66,104.23 163.35,104.23 164.06,104.94
  IN1 w0.097: v2(164.06,105.31) 164.06,104.94
  IN1 w0.147: v2(141.96,68.85) 141.98,68.85 142.42,68.42 142.42,67.92 142.27,67.77 141.76,67.77 141.43,68.1 141.43,69.82 141.5,69.89 141.5,71.74 139.48,73.75 139.48,74.25 139.06,74.67 139.06,86.8 139.21,86.95 139.34,86.95 139.48,87.09 139.48,87.39 139.34,87.54 139.21,87.54 139.06,87.68 139.06,87.98 139.21,88.12 139.34,88.12 139.48,88.27 139.48,88.57 139.34,88.71 139.21,88.71 139.06,88.86 139.06,89.24 148.44,98.61 152.11,98.61 157.26,103.76 160.12,103.76
  BOTTOM w0.14: JDIMM2.148 142.74,71.49 142.3,71.05 142,71.05 141.54,70.59 141.54,70.2 141.54,70.19 141.54,69.28 v2(141.96,68.85)
DDR_A_D45: length 67.9
  TOP w0.102: JCPU1.F3 166.53,106.84 v2(166.06,107.31)
  TOP w0.14: JDIMM1.147 143.04,71.2 v2(141.96,70.12)
  IN1 w0.089: v2(166.06,107.31) 166.05,107.31 165.68,106.94 165.68,106.2 165.42,105.93 164.75,105.93 164.43,105.61 164.43,104.53 163.93,104.03 161.01,104.03 160.36,103.38 160.12,103.38
  IN1 w0.147: 160.12,103.38 157.42,103.38 152.27,98.22 150.12,98.22 149.98,98.09 149.98,97.59 149.83,97.44 149.52,97.44 149.37,97.59 149.37,98.09 149.24,98.22 148.6,98.22 148.38,98 148.38,97.81 148.76,97.43 148.76,97.21 148.55,97 148.33,97 147.97,97.36 147.76,97.36 147.54,97.13 147.54,96.92 147.57,96.88 147.57,96.68 147.44,96.54 146.91,96.54 139.87,89.5 139.87,86.28 139.72,86.13 139.6,86.13 139.45,85.98 139.45,85.7 139.6,85.54 139.72,85.54 139.87,85.4 139.87,85.1 139.72,84.96 139.64,84.96 139.49,84.81 139.49,84.51 139.64,84.37 139.72,84.37 139.87,84.22 139.87,83.92 139.72,83.78 139.64,83.78 139.49,83.63 139.49,83.33 139.64,83.19 139.72,83.19 139.87,83.04 139.87,82.75 139.72,82.6 139.64,82.6 139.49,82.45 139.49,82.16 139.64,82.01 139.72,82.01 139.87,81.86 139.87,81.57 139.72,81.42 139.64,81.42 139.49,81.27 139.49,80.98 139.64,80.83 139.72,80.83 139.87,80.68 139.87,80.39 139.72,80.24 139.64,80.24 139.49,80.09 139.49,79.8 139.64,79.65 139.72,79.65 139.87,79.5 139.87,79.21 139.72,79.06 139.64,79.06 139.49,78.92 139.49,78.62 139.64,78.47 139.72,78.47 139.87,78.33 139.87,78.03 139.72,77.88 139.64,77.88 139.49,77.74 139.49,77.44 139.64,77.29 139.72,77.29 139.87,77.15 139.87,76.85 139.72,76.71 139.64,76.71 139.49,76.56 139.49,76.26 139.64,76.12 139.72,76.12 139.87,75.97 139.87,75.67 139.72,75.53 139.64,75.53 139.49,75.38 139.49,75.08 139.64,74.94 139.72,74.94 139.87,74.79 139.87,73.91 141.89,71.9 141.89,70.2 v2(141.96,70.12)
  BOTTOM w0.14: v2(141.96,70.12) 141.97,70.12 143.34,71.49 JDIMM2.146
DDR_A_D46: length 65.7
  TOP w0.102: v2(163.06,107.31) 163.53,106.84 JCPU1.C3
  TOP w0.14: JDIMM1.159 139.44,71.34 v2(138.74,70.63)
  IN1 w0.089: 160.12,105.71 161.47,105.71 161.66,105.91 162.2,105.91 162.46,106.16 162.46,106.71 v2(163.06,107.31)
  IN1 w0.147: v2(138.74,70.63) 138.74,71.66 137.13,73.27 137.13,90.17 142.34,95.38 142.34,95.59 141.83,96.1 141.83,96.31 142.04,96.52 142.24,96.52 142.76,96.01 142.96,96.01 143.17,96.21 143.17,96.42 142.66,96.94 142.66,97.14 142.87,97.35 143.08,97.35 143.46,96.97 143.81,96.97 144.09,97.24 144.09,99.04 144.75,99.71 144.96,99.71 145.7,98.97 145.91,98.97 146.12,99.17 146.12,99.39 145.38,100.12 145.38,100.33 145.64,100.6 146.22,100.6 146.36,100.46 146.36,100.09 146.52,99.94 146.83,99.94 146.98,100.09 146.98,100.5 147.08,100.6 151.28,100.6 156.39,105.71 160.12,105.71
  BOTTOM w0.14: JDIMM2.160 139.14,71.01 138.77,70.63 v2(138.74,70.63)
DDR_A_D47: length 66.6
  TOP w0.102: v2(162.06,107.31) 162.53,106.84 JCPU1.B3
  TOP w0.14: v2(138.74,69.11) 139.41,69.78 139.41,70.59 140.04,71.22 JDIMM1.157
  IN1 w0.089: v2(162.06,107.31) 162.05,107.3 162.05,106.87 161.57,106.39 161.57,106.13 161.33,105.9 160.77,105.9 160.58,106.1 160.12,106.1
  IN1 w0.147: v2(138.74,69.11) 138.74,68.91 138.58,68.76 138.38,68.76 138.23,68.91 138.23,71.62 136.74,73.11 136.74,90.33 141.44,95.03 141.44,96.47 142.93,97.96 143.13,97.96 143.22,97.87 143.43,97.87 143.68,98.12 143.68,98.33 143.49,98.52 143.49,98.99 145.34,100.84 145.34,101.13 145.28,101.19 145.28,101.41 145.75,101.88 145.96,101.88 146.86,100.99 151.12,100.99 156.23,106.1 160.12,106.1
  BOTTOM w0.14: JDIMM2.158 139.74,70.06 138.79,69.11 v2(138.74,69.11)
DDR_A_D48: length 74.2
  TOP w0.102: JCPU1.B5 162.53,108.84 v2(162.06,109.31)
  TOP w0.14: v2(136.7,69.29) 137.36,69.95 137.36,70.34 138.24,71.22 JDIMM1.163
  IN1 w0.089: v2(162.06,109.31) 162.54,109.31 162.66,109.19 162.66,109.02 162.54,108.9 161.77,108.9 161.42,108.55 161.42,108.07 161.2,107.85 160.83,107.85 160.61,108.06 160.45,108.06
  IN1 w0.147: v2(136.7,69.29) 136.27,69.72 136.27,71.29 135.12,72.44 135.12,91.5 135.35,91.73 135.84,91.73 136.23,92.12 136.23,92.34 136.07,92.5 135.82,92.5 135.57,92.25 135.36,92.25 135.15,92.46 135.15,92.68 138.92,96.45 139.15,96.45 139.42,96.18 139.64,96.18 139.82,96.36 139.82,96.58 139.53,96.87 139.53,97.06 139.9,97.44 140.09,97.44 140.82,98.17 140.82,98.38 141.22,98.78 141.44,98.78 141.87,99.22 141.87,99.9 141.76,100.01 141.76,100.18 142.03,100.45 142.25,100.45 142.35,100.35 142.56,100.35 142.77,100.56 142.77,100.77 142.67,100.87 142.67,101.08 142.87,101.29 143.08,101.29 143.18,101.18 143.39,101.18 143.66,101.45 143.66,102.08 145.26,103.68 145.26,106 148.06,108.8 159.48,108.8 160.22,108.06 160.45,108.06
  BOTTOM w0.14: JDIMM2.164 137.94,71.42 137.29,70.76 137.29,69.87 v2(136.7,69.29)
DDR_A_D49: length 74.6
  TOP w0.102: JCPU1.E6 165.53,109.84 v2(165.06,110.31)
  TOP w0.14: v2(136.7,70.81) 137.3,70.81 137.64,71.16 JDIMM1.165
  IN1 w0.089: 160.45,107.68 160.7,107.68 160.74,107.65 161.29,107.65 161.62,107.98 161.62,108.48 161.85,108.71 162.62,108.71 162.82,108.91 163.22,108.91 163.66,109.34 163.66,109.48 163.89,109.71 164.46,109.71 v2(165.06,110.31)
  IN1 w0.147: v2(136.7,70.81) 136.7,71.41 135.51,72.6 135.51,90.84 136.79,92.12 136.79,92.33 136.17,92.95 136.17,93.16 136.38,93.36 136.59,93.36 137.21,92.75 137.42,92.75 137.62,92.95 137.62,93.16 137.01,93.78 137.01,93.99 137.21,94.2 137.42,94.2 138.04,93.58 138.25,93.58 138.46,93.79 138.46,94 137.84,94.61 137.84,94.82 138.05,95.03 138.26,95.03 138.87,94.41 139.08,94.41 139.29,94.62 139.29,94.83 138.67,95.45 138.67,95.66 138.88,95.87 139.09,95.87 139.71,95.25 139.92,95.25 140.21,95.54 140.21,97.01 142.26,99.05 142.26,99.5 144.05,101.29 144.05,101.92 145.64,103.52 145.64,105.84 148.22,108.42 159.21,108.42 159.94,107.68 160.45,107.68
  BOTTOM w0.14: JDIMM2.166 137.34,71.45 v2(136.7,70.81)
DDR_A_D50: length 72.1
  TOP w0.102: v2(161.06,109.31) 161.53,108.84 JCPU1.A5
  TOP w0.14: v2(133.7,66.24) 134.34,65.61 JDIMM1.176
  IN1 w0.089: v2(161.06,109.31) 160.29,110.08 160.12,110.08
  IN1 w0.147: v2(133.7,66.24) 133.7,65.52 133.86,65.36 134.73,65.36 134.89,65.52 134.89,69.26 135.06,69.43 135.06,70.87 134.5,71.42 133.96,71.96 133.96,93.16 140.5,99.7 140.5,100.57 144.07,104.14 144.07,106.56 147.59,110.08 160.12,110.08
  BOTTOM w0.14: v2(133.7,66.24) 133.7,65.37 134.04,65.03 JDIMM2.177
DDR_A_D51: length 75.6
  TOP w0.102: JCPU1.D6 164.53,109.84 v2(164.06,110.31)
  TOP w0.14: v2(133.7,69.29) 133.87,69.29 134.64,70.06 JDIMM1.175
  IN1 w0.089: 160.12,111.28 160.56,111.28 161.13,110.71 163.66,110.71 v2(164.06,110.31)
  IN1 w0.147: v2(133.7,69.29) 133.45,69.29 133.23,69.51 133.23,71.04 132.79,71.48 132.79,94.73 139.44,101.37 139.65,101.37 140.19,101.91 140.19,102.11 140.05,102.25 140.05,102.46 140.26,102.67 140.47,102.67 140.61,102.53 140.81,102.53 141.02,102.74 141.02,102.95 140.89,103.08 140.89,103.29 141.1,103.5 141.3,103.5 141.44,103.36 141.65,103.36 141.86,103.57 141.86,103.78 141.72,103.92 141.72,104.12 141.93,104.33 142.14,104.33 142.27,104.2 142.48,104.2 142.91,104.62 142.91,107.09 147.09,111.28 160.12,111.28
  BOTTOM w0.14: v2(133.7,69.29) 134,69.29 134.44,69.74 134.44,70.6 134.94,71.09 JDIMM2.174
DDR_A_D52: length 75.3
  TOP w0.102: JCPU1.D5 164.53,108.84 v2(164.06,109.31)
  TOP w0.14: JDIMM1.164 137.94,65.54 137.13,66.36 137.13,67.34 v2(136.7,67.77)
  IN1 w0.089: 160.12,107.07 160.4,107.07 160.6,106.87 161.29,106.87 161.47,107.05 161.47,107.55 161.81,107.9 162.22,107.9 162.59,108.28 162.59,108.41 162.9,108.72 163.47,108.72 v2(164.06,109.31)
  IN1 w0.147: v2(136.7,67.77) 136.97,67.77 137.12,67.61 137.12,67.24 137.28,67.09 137.7,67.09 137.85,67.24 137.85,68.1 137.38,68.56 137.38,71.28 135.9,72.76 135.9,90.68 140.6,95.38 140.6,96.84 142.65,98.89 142.65,99.34 144.44,101.13 144.44,101.76 146.03,103.36 146.03,105.68 148.38,108.03 158.59,108.03 159.54,107.07 160.12,107.07
  BOTTOM w0.14: JDIMM2.163 138.24,65.24 137.22,66.27 137.22,67.25 v2(136.7,67.77)
DDR_A_D53: length 74
  TOP w0.102: v2(165.06,109.31) 165.53,108.84 JCPU1.E5
  TOP w0.14: v2(136.7,66.24) 137.34,65.6 JDIMM1.166
  IN1 w0.089: 162.53,107.71 161.89,107.71 161.66,107.48 161.66,106.97 161.37,106.68 160.12,106.68 ; v2(165.06,109.31) 164.51,108.76 163.84,108.76 163.54,108.46 163.54,108.12 163.29,107.87
  IN1 w0.097: 162.53,107.71 162.69,107.87 163.29,107.87
  IN1 w0.147: 160.12,106.68 159.38,106.68 158.42,107.64 148.54,107.64 146.42,105.52 146.42,103.2 144.82,101.6 144.82,100.97 143.04,99.18 143.04,98.73 140.99,96.68 140.99,95.22 136.28,90.51 136.28,72.92 137.77,71.44 137.77,68.72 138.28,68.22 138.28,65.9 138.13,65.75 136.85,65.75 136.7,65.9 v2(136.7,66.24)
  BOTTOM w0.14: JDIMM2.165 137.64,65.3 v2(136.7,66.24)
DDR_A_D54: length 75.5
  TOP w0.102: v2(162.06,110.31) 162.53,109.84 JCPU1.B6
  TOP w0.14: v2(133.7,67.77) 134.94,66.53 JDIMM1.174
  IN1 w0.089: 160.12,110.47 160.18,110.47 160.74,109.91 161.27,109.91 161.67,110.31 v2(162.06,110.31)
  IN1 w0.147: 160.12,110.47 147.43,110.47 143.68,106.72 143.68,104.3 140.12,100.73 140.12,99.86 133.57,93.32 133.57,71.8 134.41,70.96 134.67,70.71 134.67,70.48 134.51,70.33 134.3,70.33 134.14,70.18 134.14,69.92 134.3,69.76 134.34,69.76 134.5,69.61 134.5,68.88 134.35,68.73 134.29,68.73 134.14,68.58 134.14,68.29 134.29,68.14 134.35,68.14 134.5,68 134.5,67.34 134.35,67.19 134.14,67.19 133.99,67.34 133.99,67.61 133.83,67.77 v2(133.7,67.77)
  BOTTOM w0.14: v2(133.7,67.77) 134.15,67.32 134.15,65.7 134.64,65.21 JDIMM2.175
